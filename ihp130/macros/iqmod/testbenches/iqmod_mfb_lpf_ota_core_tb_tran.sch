** sch_path: ihp130/macros/iqmod/testbenches/iqmod_mfb_lpf_ota_core_tb_tran.sch
**.subckt iqmod_mfb_lpf_ota_core_tb_tran
VDD VDD GND {VDD}
C1 voutp GND {Cload} m=1
C2 voutn GND {Cload} m=1
vsine vin GND sin(0 40m {fsig})
Vcm Vcm GND {Vcm}
Vmeasp net2 voutp 0
Vmeasn net1 voutn 0
E8 vout_cm GND voutp net3 0.5
E10 net3 GND voutn GND -1
E1 vout_dm GND voutp voutn 1
x4 net2 net1 vinn vinp VDD GND VDD iqmod_mfb_lpf_ota_core_hybrid_bm_pex
x6 vinp vin Vcm GND vinn single2dm
**** begin user architecture code


.include ../../netlist/pex/iqmod_mfb_lpf_ota_core_hybrid_bm_pex.spice
.param VDD=1.5
.csparam VDD=VDD
.param Vcm=VDD/2
.param temp=27
.param fsig=400e3
.csparam fsig=fsig
.param Cload=10p
.param Rload=1k
.options savecurrents method=gear reltol=1e-3 abstol=1e-15 gmin=1e-15
.control

* save vin vinp vinn voutp voutn vout_cm vout_dm
save all

* User Constants
let tstart = 1/fsig
let tstop = 4/fsig
let tstep = 0.05/fsig

* Operating Point Analysis
op
remzerovec
write @schname\.raw
set appendwrite

* Transient Analysis
* Sine Input
tran $&tstep $&tstop $&tstart
* Pulse Input
* tran 50n 2.05m 1.95m
write @schname\.raw

* Plotting
plot vinp vinn voutp voutn
plot vin vout_dm vout_cm
* plot i(VDD)

* Measurements
meas tran vin_peak MAX v(vin)
meas tran vout_peak MAX v(vout_dm)

let Adm = vout_peak / vin_peak
let Adm_dB = vdb(Adm)
print Adm_dB

meas tran vout_pp_max MAX v(voutp)
meas tran vout_pp_min MIN v(voutp)
let vout_pp = vout_pp_max - vout_pp_min
print vout_pp

* Calculation of Power Consumption & Efficiency
let PDD_inst = VDD * -i(VDD)
meas tran PDD_int INTEG PDD_inst from=tstart to=tstop
let PDD = 1/(tstop - tstart) * PDD_int * 1e3
echo PDD = $&PDD mW

let Pout_inst = v(vout_dm) * (i(Vmeasp) - i(Vmeasn))
meas tran Pout_int INTEG Pout_inst from=tstart to=tstop
let Pout = 1/(tstop - tstart) * Pout_int * 1e3
echo Pout = $&Pout mW

let efficiency = Pout / PDD * 100
echo efficiency = $&efficiency %

* Write Data
unset appendwrite
set wr_vecnames
set wr_singlescale
wrdata $PROJECT_PATH/scripts/plot_simulations/data/iqmod_mfb_lpf_ota_core_tb_tran.txt  v(vin)
+ v(vout_dm) v(vout_cm) v(vinp) v(vinn) v(voutp) v(voutn)

*quit
.endc



.lib cornerMOSlv.lib mos_tt
.lib cornerMOShv.lib mos_tt
.lib cornerHBT.lib hbt_typ
.lib cornerRES.lib res_typ
.lib cornerCAP.lib cap_typ
.lib cornerDIO.lib dio_tt

 .include [file rootname [xschem get schname]].save

**** end user architecture code
**.ends
.GLOBAL GND
.GLOBAL VDD
.end
