C {devices/vsource.sym} 560 -1610 0 0 {name=vpwm_cosine_50 spice_ignore=true hide_texts=true value="dc 0 pwl(0.0 1.5 6.138392857142856e-09 1.5 6.696428571428571e-09 0.0 1.1160714285714285e-08 0.0 1.1718749999999999e-08 1.5 2.399553571428571e-08 1.5 2.4553571428571426e-08 0.0 2.9017857142857142e-08 0.0 2.9575892857142856e-08 1.5 4.185267857142857e-08 1.5 4.241071428571428e-08 0.0 4.6874999999999995e-08 0.0 4.743303571428571e-08 1.5 5.970982142857143e-08 1.5 6.026785714285714e-08 0.0 6.473214285714285e-08 0.0 6.529017857142856e-08 1.5 7.756696428571428e-08 1.5 7.812499999999999e-08 0.0 8.25892857142857e-08 0.0 8.314732142857142e-08 1.5 9.542410714285713e-08 1.5 9.598214285714285e-08 0.0 1.0044642857142856e-07 0.0 1.0100446428571428e-07 1.5 1.1328124999999999e-07 1.5 1.1383928571428571e-07 0.0 1.1830357142857142e-07 0.0 1.1886160714285714e-07 1.5 1.3113839285714285e-07 1.5 1.3169642857142855e-07 0.0 1.3616071428571426e-07 0.0 1.3671875e-07 1.5 1.489955357142857e-07 1.5 1.4955357142857143e-07 0.0 1.5401785714285714e-07 0.0 1.5457589285714284e-07 1.5 1.6685267857142856e-07 1.5 1.6741071428571428e-07 0.0 1.71875e-07 0.0 1.724330357142857e-07 1.5 1.847098214285714e-07 1.5 1.8526785714285713e-07 0.0 1.8973214285714285e-07 0.0 1.9029017857142855e-07 1.5 2.0256696428571426e-07 1.5 2.03125e-07 0.0 2.075892857142857e-07 0.0 2.0814732142857142e-07 1.5 2.2042410714285712e-07 1.5 2.2098214285714284e-07 0.0 2.2544642857142855e-07 0.0 2.2600446428571428e-07 1.5 2.3828125e-07 1.5 2.388392857142857e-07 0.0 2.433035714285714e-07 0.0 2.438616071428571e-07 1.5 2.561383928571428e-07 1.5 2.5669642857142857e-07 0.0 2.6116071428571426e-07 0.0 2.6171874999999996e-07 1.5 2.739955357142857e-07 1.5 2.745535714285714e-07 0.0 2.790178571428571e-07 0.0 2.7957589285714286e-07 1.5 2.918526785714285e-07 1.5 2.924107142857143e-07 0.0 2.9687499999999996e-07 0.0 2.974330357142857e-07 1.5 3.0970982142857143e-07 1.5 3.1026785714285713e-07 0.0 3.147321428571428e-07 0.0 3.1529017857142857e-07 1.5 3.275669642857143e-07 1.5 3.28125e-07 0.0 3.3258928571428567e-07 0.0 3.331473214285714e-07 1.5 3.4542410714285714e-07 1.5 3.4598214285714283e-07 0.0 3.504464285714285e-07 0.0 3.5100446428571427e-07 1.5 3.6328125e-07 1.5 3.638392857142857e-07 0.0 3.6830357142857143e-07 0.0 3.688616071428571e-07 1.5 3.8113839285714284e-07 1.5 3.8169642857142854e-07 0.0 3.861607142857143e-07 0.0 3.8671875e-07 1.5 3.989955357142857e-07 1.5 3.995535714285714e-07 0.0 4.0401785714285713e-07 0.0 4.0457589285714283e-07 1.5 4.1685267857142855e-07 1.5 4.1741071428571424e-07 0.0 4.21875e-07 0.0 4.224330357142857e-07 1.5 4.347098214285714e-07 1.5 4.352678571428571e-07 0.0 4.3973214285714284e-07 0.0 4.4029017857142853e-07 1.5 4.5256696428571425e-07 1.5 4.5312499999999995e-07 0.0 4.575892857142857e-07 0.0 4.581473214285714e-07 1.5 4.704241071428571e-07 1.5 4.709821428571428e-07 0.0 4.7544642857142854e-07 0.0 4.7600446428571424e-07 1.5 4.8828125e-07 1.5 4.888392857142857e-07 0.0 4.933035714285714e-07 0.0 4.938616071428571e-07 1.5 5.061383928571429e-07 1.5 5.066964285714286e-07 0.0 5.111607142857142e-07 0.0 5.117187499999999e-07 1.5 5.239955357142857e-07 1.5 5.245535714285714e-07 0.0 5.290178571428571e-07 0.0 5.295758928571428e-07 1.5 5.418526785714286e-07 1.5 5.424107142857143e-07 0.0 5.46875e-07 0.0 5.474330357142856e-07 1.5 5.597098214285714e-07 1.5 5.602678571428571e-07 0.0 5.647321428571428e-07 0.0 5.652901785714285e-07 1.5 5.775669642857143e-07 1.5 5.78125e-07 0.0 5.825892857142857e-07 0.0 5.831473214285714e-07 1.5 5.954241071428571e-07 1.5 5.959821428571428e-07 0.0 6.004464285714285e-07 0.0 6.010044642857142e-07 1.5 6.1328125e-07 1.5 6.138392857142857e-07 0.0 6.183035714285714e-07 0.0 6.188616071428571e-07 1.5 6.311383928571428e-07 1.5 6.316964285714285e-07 0.0 6.361607142857142e-07 0.0 6.367187499999999e-07 1.5 6.489955357142857e-07 1.5 6.495535714285714e-07 0.0 6.540178571428571e-07 0.0 6.545758928571428e-07 1.5 6.668526785714285e-07 1.5 6.674107142857142e-07 0.0 6.718749999999999e-07 0.0 6.724330357142856e-07 1.5 6.847098214285714e-07 1.5 6.852678571428571e-07 0.0 6.897321428571428e-07 0.0 6.902901785714285e-07 1.5 7.025669642857142e-07 1.5 7.031249999999999e-07 0.0 7.075892857142856e-07 0.0 7.081473214285714e-07 1.5 7.204241071428571e-07 1.5 7.209821428571428e-07 0.0 7.254464285714285e-07 0.0 7.260044642857143e-07 1.5 7.382812499999999e-07 1.5 7.388392857142856e-07 0.0 7.433035714285713e-07 0.0 7.438616071428571e-07 1.5 7.561383928571428e-07 1.5 7.566964285714285e-07 0.0 7.611607142857142e-07 0.0 7.6171875e-07 1.5 7.739955357142857e-07 1.5 7.745535714285713e-07 0.0 7.79017857142857e-07 0.0 7.795758928571428e-07 1.5 7.918526785714285e-07 1.5 7.924107142857142e-07 0.0 7.96875e-07 0.0 7.974330357142857e-07 1.5 8.097098214285714e-07 1.5 8.102678571428571e-07 0.0 8.147321428571428e-07 0.0 8.152901785714285e-07 1.5 8.275669642857142e-07 1.5 8.281249999999999e-07 0.0 8.325892857142857e-07 0.0 8.331473214285714e-07 1.5 8.454241071428571e-07 1.5 8.459821428571428e-07 0.0 8.504464285714286e-07 0.0 8.510044642857142e-07 1.5 8.632812499999999e-07 1.5 8.638392857142856e-07 0.0 8.683035714285714e-07 0.0 8.688616071428571e-07 1.5 8.811383928571428e-07 1.5 8.816964285714285e-07 0.0 8.861607142857143e-07 0.0 8.8671875e-07 1.5 8.989955357142856e-07 1.5 8.995535714285713e-07 0.0 9.040178571428571e-07 0.0 9.045758928571428e-07 1.5 9.168526785714285e-07 1.5 9.174107142857142e-07 0.0 9.21875e-07 0.0 9.224330357142857e-07 1.5 9.341517857142856e-07 1.5 9.347098214285713e-07 0.0 9.402901785714285e-07 0.0 9.408482142857142e-07 1.5 9.520089285714285e-07 1.5 9.525669642857142e-07 0.0 9.581473214285714e-07 0.0 9.58705357142857e-07 1.5 9.698660714285714e-07 1.5 9.704241071428571e-07 0.0 9.760044642857141e-07 0.0 9.765625e-07 1.5 9.877232142857142e-07 1.5 9.882812499999999e-07 0.0 9.93861607142857e-07 0.0 9.944196428571428e-07 1.5 1.0055803571428571e-06 1.5 1.0061383928571428e-06 0.0 1.01171875e-06 0.0 1.0122767857142857e-06 1.5 1.0234374999999999e-06 1.5 1.0239955357142856e-06 0.0 1.0295758928571428e-06 0.0 1.0301339285714285e-06 1.5 1.0412946428571428e-06 1.5 1.0418526785714285e-06 0.0 1.0474330357142857e-06 0.0 1.0479910714285714e-06 1.5 1.0591517857142856e-06 1.5 1.0597098214285713e-06 0.0 1.0652901785714285e-06 0.0 1.0658482142857142e-06 1.5 1.0770089285714286e-06 1.5 1.0775669642857143e-06 0.0 1.0831473214285714e-06 0.0 1.0837053571428571e-06 1.5 1.0948660714285713e-06 1.5 1.095424107142857e-06 0.0 1.1010044642857142e-06 0.0 1.1015624999999999e-06 1.5 1.1127232142857143e-06 1.5 1.11328125e-06 0.0 1.1188616071428571e-06 0.0 1.1194196428571428e-06 1.5 1.130580357142857e-06 1.5 1.1311383928571427e-06 0.0 1.1367187499999999e-06 0.0 1.1372767857142856e-06 1.5 1.1484375e-06 1.5 1.1489955357142857e-06 0.0 1.1545758928571428e-06 0.0 1.1551339285714285e-06 1.5 1.1662946428571427e-06 1.5 1.1668526785714284e-06 0.0 1.1724330357142856e-06 0.0 1.1729910714285713e-06 1.5 1.1841517857142857e-06 1.5 1.1847098214285714e-06 0.0 1.1902901785714286e-06 0.0 1.1908482142857143e-06 1.5 1.2020089285714284e-06 1.5 1.2025669642857141e-06 0.0 1.2081473214285713e-06 0.0 1.208705357142857e-06 1.5 1.2198660714285714e-06 1.5 1.220424107142857e-06 0.0 1.2260044642857143e-06 0.0 1.2265625e-06 1.5 1.2377232142857141e-06 1.5 1.2382812499999998e-06 0.0 1.243861607142857e-06 0.0 1.2444196428571427e-06 1.5 1.255580357142857e-06 1.5 1.2561383928571428e-06 0.0 1.26171875e-06 0.0 1.2622767857142857e-06 1.5 1.2734374999999998e-06 1.5 1.2739955357142855e-06 0.0 1.2795758928571427e-06 0.0 1.2801339285714284e-06 1.5 1.2912946428571428e-06 1.5 1.2918526785714285e-06 0.0 1.2974330357142857e-06 0.0 1.2979910714285714e-06 1.5 1.3091517857142855e-06 1.5 1.3097098214285714e-06 0.0 1.3152901785714284e-06 0.0 1.3158482142857141e-06 1.5 1.3270089285714285e-06 1.5 1.3275669642857142e-06 0.0 1.3331473214285714e-06 0.0 1.333705357142857e-06 1.5 1.3443080357142855e-06 1.5 1.3448660714285712e-06 0.0 1.3515624999999998e-06 0.0 1.3521205357142855e-06 1.5 1.3621651785714285e-06 1.5 1.3627232142857142e-06 0.0 1.3694196428571428e-06 0.0 1.3699776785714285e-06 1.5 1.3800223214285712e-06 1.5 1.380580357142857e-06 0.0 1.3872767857142855e-06 0.0 1.3878348214285714e-06 1.5 1.3978794642857142e-06 1.5 1.3984375e-06 0.0 1.4051339285714285e-06 0.0 1.4056919642857142e-06 1.5 1.415736607142857e-06 1.5 1.4162946428571429e-06 0.0 1.4229910714285712e-06 0.0 1.4235491071428571e-06 1.5 1.43359375e-06 1.5 1.4341517857142856e-06 0.0 1.4408482142857142e-06 0.0 1.4414062499999999e-06 1.5 1.4514508928571427e-06 1.5 1.4520089285714286e-06 0.0 1.458705357142857e-06 0.0 1.4592633928571428e-06 1.5 1.4693080357142856e-06 1.5 1.4698660714285713e-06 0.0 1.4765624999999999e-06 0.0 1.4771205357142856e-06 1.5 1.4871651785714286e-06 1.5 1.4877232142857143e-06 0.0 1.4944196428571429e-06 0.0 1.4949776785714285e-06 1.5 1.5050223214285713e-06 1.5 1.505580357142857e-06 0.0 1.5122767857142856e-06 0.0 1.5128348214285713e-06 1.5 1.5228794642857143e-06 1.5 1.5234375e-06 0.0 1.5301339285714286e-06 0.0 1.5306919642857143e-06 1.5 1.540736607142857e-06 1.5 1.5412946428571427e-06 0.0 1.5479910714285713e-06 0.0 1.548549107142857e-06 1.5 1.55859375e-06 1.5 1.5591517857142857e-06 0.0 1.5658482142857143e-06 0.0 1.56640625e-06 1.5 1.5764508928571427e-06 1.5 1.5770089285714284e-06 0.0 1.583705357142857e-06 0.0 1.5842633928571427e-06 1.5 1.5943080357142857e-06 1.5 1.5948660714285714e-06 0.0 1.6015625e-06 0.0 1.6021205357142857e-06 1.5 1.6121651785714284e-06 1.5 1.6127232142857141e-06 0.0 1.6194196428571427e-06 0.0 1.6199776785714284e-06 1.5 1.6300223214285714e-06 1.5 1.630580357142857e-06 0.0 1.6372767857142857e-06 0.0 1.6378348214285714e-06 1.5 1.6478794642857141e-06 1.5 1.6484374999999998e-06 0.0 1.6551339285714284e-06 0.0 1.6556919642857141e-06 1.5 1.665736607142857e-06 1.5 1.6662946428571428e-06 0.0 1.6729910714285714e-06 0.0 1.673549107142857e-06 1.5 1.6835937499999998e-06 1.5 1.6841517857142855e-06 0.0 1.6914062499999998e-06 0.0 1.6919642857142855e-06 1.5 1.700892857142857e-06 1.5 1.7014508928571428e-06 0.0 1.7092633928571428e-06 0.0 1.7098214285714285e-06 1.5 1.7187499999999998e-06 1.5 1.7193080357142855e-06 0.0 1.7271205357142855e-06 0.0 1.7276785714285712e-06 1.5 1.7366071428571428e-06 1.5 1.7371651785714285e-06 0.0 1.7449776785714285e-06 0.0 1.7455357142857142e-06 1.5 1.7544642857142856e-06 1.5 1.7550223214285713e-06 0.0 1.7628348214285712e-06 0.0 1.763392857142857e-06 1.5 1.7723214285714285e-06 1.5 1.7728794642857142e-06 0.0 1.7806919642857142e-06 0.0 1.7812499999999999e-06 1.5 1.7901785714285713e-06 1.5 1.790736607142857e-06 0.0 1.798549107142857e-06 0.0 1.7991071428571426e-06 1.5 1.8080357142857142e-06 1.5 1.80859375e-06 0.0 1.8164062499999999e-06 0.0 1.8169642857142856e-06 1.5 1.825892857142857e-06 1.5 1.8264508928571427e-06 0.0 1.8342633928571426e-06 0.0 1.8348214285714283e-06 1.5 1.84375e-06 1.5 1.8443080357142856e-06 0.0 1.8521205357142856e-06 0.0 1.8526785714285713e-06 1.5 1.8616071428571427e-06 1.5 1.8621651785714284e-06 0.0 1.8699776785714283e-06 0.0 1.8705357142857143e-06 1.5 1.8794642857142856e-06 1.5 1.8800223214285713e-06 0.0 1.8878348214285713e-06 0.0 1.888392857142857e-06 1.5 1.8973214285714284e-06 1.5 1.897879464285714e-06 0.0 1.905691964285714e-06 0.0 1.90625e-06 1.5 1.9151785714285713e-06 1.5 1.915736607142857e-06 0.0 1.923549107142857e-06 0.0 1.924107142857143e-06 1.5 1.933035714285714e-06 1.5 1.93359375e-06 0.0 1.9414062499999998e-06 0.0 1.9419642857142857e-06 1.5 1.950892857142857e-06 1.5 1.9514508928571427e-06 0.0 1.959263392857143e-06 0.0 1.9598214285714284e-06 1.5 1.96875e-06 1.5 1.9693080357142855e-06 0.0 1.9771205357142857e-06 0.0 1.977678571428571e-06 1.5 1.9866071428571427e-06 1.5 1.9871651785714282e-06 0.0 1.9949776785714284e-06 0.0 1.9955357142857143e-06 1.5 2.0044642857142855e-06 1.5 2.0050223214285714e-06 0.0 2.013392857142857e-06 0.0 2.0139508928571426e-06 1.5 2.0217633928571428e-06 1.5 2.0223214285714282e-06 0.0 2.03125e-06 0.0 2.0318080357142857e-06 1.5 2.0396205357142855e-06 1.5 2.0401785714285714e-06 0.0 2.0491071428571426e-06 0.0 2.0496651785714285e-06 1.5 2.0574776785714282e-06 1.5 2.058035714285714e-06 0.0 2.0669642857142857e-06 0.0 2.0675223214285712e-06 1.5 2.0753348214285714e-06 1.5 2.075892857142857e-06 0.0 2.0848214285714285e-06 0.0 2.085379464285714e-06 1.5 2.093191964285714e-06 1.5 2.0937499999999996e-06 0.0 2.1026785714285712e-06 0.0 2.103236607142857e-06 1.5 2.111049107142857e-06 1.5 2.111607142857143e-06 0.0 2.120535714285714e-06 0.0 2.12109375e-06 1.5 2.1289062499999997e-06 1.5 2.1294642857142856e-06 0.0 2.138392857142857e-06 0.0 2.1389508928571426e-06 1.5 2.146763392857143e-06 1.5 2.1473214285714283e-06 0.0 2.15625e-06 0.0 2.1568080357142854e-06 1.5 2.1646205357142856e-06 1.5 2.1651785714285715e-06 0.0 2.1741071428571426e-06 0.0 2.1746651785714286e-06 1.5 2.1824776785714283e-06 1.5 2.1830357142857142e-06 0.0 2.1919642857142854e-06 0.0 2.1925223214285713e-06 1.5 2.200334821428571e-06 1.5 2.200892857142857e-06 0.0 2.2098214285714286e-06 0.0 2.210379464285714e-06 1.5 2.2181919642857142e-06 1.5 2.2187499999999997e-06 0.0 2.2276785714285713e-06 0.0 2.228236607142857e-06 1.5 2.236049107142857e-06 1.5 2.236607142857143e-06 0.0 2.245535714285714e-06 0.0 2.24609375e-06 1.5 2.2539062499999997e-06 1.5 2.2544642857142856e-06 0.0 2.263392857142857e-06 0.0 2.2639508928571427e-06 1.5 2.271763392857143e-06 1.5 2.2723214285714284e-06 0.0 2.28125e-06 0.0 2.2818080357142855e-06 1.5 2.2896205357142856e-06 1.5 2.290178571428571e-06 0.0 2.2991071428571427e-06 0.0 2.299665178571428e-06 1.5 2.3074776785714284e-06 1.5 2.3080357142857143e-06 0.0 2.3169642857142855e-06 0.0 2.3175223214285714e-06 1.5 2.325334821428571e-06 1.5 2.325892857142857e-06 0.0 2.335379464285714e-06 0.0 2.3359375e-06 1.5 2.3426339285714284e-06 1.5 2.3431919642857143e-06 0.0 2.353236607142857e-06 0.0 2.3537946428571428e-06 1.5 2.360491071428571e-06 1.5 2.361049107142857e-06 0.0 2.37109375e-06 0.0 2.3716517857142855e-06 1.5 2.3783482142857143e-06 1.5 2.37890625e-06 0.0 2.3889508928571428e-06 0.0 2.3895089285714283e-06 1.5 2.396205357142857e-06 1.5 2.3967633928571425e-06 0.0 2.4068080357142855e-06 0.0 2.4073660714285714e-06 1.5 2.4140625e-06 1.5 2.4146205357142857e-06 0.0 2.4246651785714283e-06 0.0 2.425223214285714e-06 1.5 2.4319196428571426e-06 1.5 2.4324776785714285e-06 0.0 2.4425223214285714e-06 0.0 2.443080357142857e-06 1.5 2.4497767857142857e-06 1.5 2.4503348214285712e-06 0.0 2.460379464285714e-06 0.0 2.4609374999999997e-06 1.5 2.4676339285714285e-06 1.5 2.468191964285714e-06 0.0 2.478236607142857e-06 0.0 2.478794642857143e-06 1.5 2.4854910714285712e-06 1.5 2.486049107142857e-06 0.0 2.4960937499999997e-06 0.0 2.4966517857142856e-06 1.5 2.503348214285714e-06 1.5 2.50390625e-06 0.0 2.513950892857143e-06 0.0 2.5145089285714283e-06 1.5 2.521205357142857e-06 1.5 2.5217633928571426e-06 0.0 2.5318080357142856e-06 0.0 2.532366071428571e-06 1.5 2.5390625e-06 1.5 2.5396205357142854e-06 0.0 2.5496651785714283e-06 0.0 2.5502232142857143e-06 1.5 2.5569196428571426e-06 1.5 2.5574776785714285e-06 0.0 2.567522321428571e-06 0.0 2.568080357142857e-06 1.5 2.5747767857142854e-06 1.5 2.5753348214285713e-06 0.0 2.5853794642857143e-06 0.0 2.5859374999999998e-06 1.5 2.5926339285714285e-06 1.5 2.593191964285714e-06 0.0 2.603236607142857e-06 0.0 2.6037946428571425e-06 1.5 2.6104910714285713e-06 1.5 2.6110491071428568e-06 0.0 2.6210937499999998e-06 0.0 2.6216517857142857e-06 1.5 2.628348214285714e-06 1.5 2.62890625e-06 0.0 2.6389508928571425e-06 0.0 2.6395089285714284e-06 1.5 2.6462053571428568e-06 1.5 2.6467633928571427e-06 0.0 2.6568080357142857e-06 0.0 2.657366071428571e-06 1.5 2.6640625e-06 1.5 2.6646205357142854e-06 0.0 2.6746651785714284e-06 0.0 2.675223214285714e-06 1.5 2.681361607142857e-06 1.5 2.6819196428571427e-06 0.0 2.693080357142857e-06 0.0 2.6936383928571426e-06 1.5 2.69921875e-06 1.5 2.6997767857142855e-06 0.0 2.7109375e-06 0.0 2.7114955357142853e-06 1.5 2.7170758928571427e-06 1.5 2.717633928571428e-06 0.0 2.7287946428571426e-06 0.0 2.7293526785714285e-06 1.5 2.7349330357142855e-06 1.5 2.7354910714285714e-06 0.0 2.7466517857142853e-06 0.0 2.7472098214285712e-06 1.5 2.752790178571428e-06 1.5 2.753348214285714e-06 0.0 2.7645089285714285e-06 0.0 2.765066964285714e-06 1.5 2.7706473214285714e-06 1.5 2.771205357142857e-06 0.0 2.7823660714285712e-06 0.0 2.782924107142857e-06 1.5 2.788504464285714e-06 1.5 2.7890624999999996e-06 0.0 2.800223214285714e-06 0.0 2.80078125e-06 1.5 2.806361607142857e-06 1.5 2.8069196428571428e-06 0.0 2.8180803571428567e-06 0.0 2.8186383928571426e-06 1.5 2.8242187499999996e-06 1.5 2.8247767857142855e-06 0.0 2.8359375e-06 0.0 2.8364955357142854e-06 1.5 2.8420758928571428e-06 1.5 2.8426339285714283e-06 0.0 2.8537946428571426e-06 0.0 2.8543526785714286e-06 1.5 2.8599330357142855e-06 1.5 2.860491071428571e-06 0.0 2.8716517857142854e-06 0.0 2.8722098214285713e-06 1.5 2.8777901785714283e-06 1.5 2.878348214285714e-06 0.0 2.8895089285714286e-06 0.0 2.890066964285714e-06 1.5 2.895647321428571e-06 1.5 2.896205357142857e-06 0.0 2.9073660714285713e-06 0.0 2.907924107142857e-06 1.5 2.913504464285714e-06 1.5 2.9140624999999997e-06 0.0 2.925223214285714e-06 0.0 2.92578125e-06 1.5 2.931361607142857e-06 1.5 2.931919642857143e-06 0.0 2.943080357142857e-06 0.0 2.9436383928571427e-06 1.5 2.9492187499999997e-06 1.5 2.9497767857142856e-06 0.0 2.9609375e-06 0.0 2.9614955357142855e-06 1.5 2.9670758928571424e-06 1.5 2.9676339285714283e-06 0.0 2.9787946428571427e-06 0.0 2.979352678571428e-06 1.5 2.9849330357142856e-06 1.5 2.985491071428571e-06 0.0 2.9966517857142855e-06 0.0 2.9972098214285714e-06 1.5 3.0027901785714284e-06 1.5 3.0033482142857143e-06 0.0 3.0145089285714282e-06 0.0 3.015066964285714e-06 1.5 3.020647321428571e-06 1.5 3.021205357142857e-06 0.0 3.0323660714285714e-06 0.0 3.032924107142857e-06 1.5 3.0385044642857143e-06 1.5 3.0390624999999998e-06 0.0 3.050223214285714e-06 0.0 3.0507812499999996e-06 1.5 3.056361607142857e-06 1.5 3.0569196428571425e-06 0.0 3.068080357142857e-06 0.0 3.0686383928571428e-06 1.5 3.0742187499999998e-06 1.5 3.0747767857142857e-06 0.0 3.0859374999999996e-06 0.0 3.0864955357142855e-06 1.5 3.091517857142857e-06 1.5 3.0920758928571425e-06 0.0 3.1043526785714283e-06 0.0 3.104910714285714e-06 1.5 3.1093749999999998e-06 1.5 3.1099330357142857e-06 0.0 3.122209821428571e-06 0.0 3.122767857142857e-06 1.5 3.1272321428571425e-06 1.5 3.1277901785714284e-06 0.0 3.140066964285714e-06 0.0 3.1406249999999997e-06 1.5 3.1450892857142857e-06 1.5 3.145647321428571e-06 0.0 3.157924107142857e-06 0.0 3.1584821428571424e-06 1.5 3.1629464285714284e-06 1.5 3.163504464285714e-06 0.0 3.1757812499999997e-06 0.0 3.1763392857142856e-06 1.5 3.180803571428571e-06 1.5 3.181361607142857e-06 0.0 3.1936383928571424e-06 0.0 3.1941964285714283e-06 1.5 3.198660714285714e-06 1.5 3.19921875e-06 0.0 3.2114955357142856e-06 0.0 3.212053571428571e-06 1.5 3.216517857142857e-06 1.5 3.2170758928571426e-06 0.0 3.2293526785714284e-06 0.0 3.2299107142857143e-06 1.5 3.234375e-06 1.5 3.2349330357142853e-06 0.0 3.247209821428571e-06 0.0 3.247767857142857e-06 1.5 3.2522321428571426e-06 1.5 3.2527901785714285e-06 0.0 3.265066964285714e-06 0.0 3.2656249999999998e-06 1.5 3.2700892857142853e-06 1.5 3.2706473214285712e-06 0.0 3.282924107142857e-06 0.0 3.2834821428571425e-06 1.5 3.2879464285714285e-06 1.5 3.288504464285714e-06 0.0 3.3007812499999998e-06 0.0 3.3013392857142857e-06 1.5 3.3058035714285713e-06 1.5 3.3063616071428567e-06 0.0 3.3186383928571425e-06 0.0 3.3191964285714284e-06 1.5 3.323660714285714e-06 1.5 3.32421875e-06 0.0 3.3364955357142857e-06 0.0 3.337053571428571e-06 1.5 3.3415178571428567e-06 1.5 3.3420758928571427e-06 0.0 3.3543526785714284e-06 0.0 3.354910714285714e-06 1.5 3.359375e-06 1.5 3.3599330357142854e-06 0.0 3.372209821428571e-06 0.0 3.372767857142857e-06 1.5 3.3772321428571427e-06 1.5 3.377790178571428e-06 0.0 3.390066964285714e-06 0.0 3.390625e-06 1.5 3.3950892857142854e-06 1.5 3.3956473214285713e-06 0.0 3.407924107142857e-06 0.0 3.4084821428571426e-06 1.5 3.412946428571428e-06 1.5 3.413504464285714e-06 0.0 3.42578125e-06 0.0 3.4263392857142853e-06 1.5 3.4308035714285713e-06 1.5 3.431361607142857e-06 0.0 3.4436383928571426e-06 0.0 3.4441964285714285e-06 1.5 3.448660714285714e-06 1.5 3.4492187499999996e-06 0.0 3.4614955357142853e-06 0.0 3.4620535714285712e-06 1.5 3.466517857142857e-06 1.5 3.4670758928571427e-06 0.0 3.4793526785714285e-06 0.0 3.479910714285714e-06 1.5 3.4843749999999996e-06 1.5 3.4849330357142855e-06 0.0 3.4972098214285712e-06 0.0 3.4977678571428567e-06 1.5 3.5022321428571427e-06 1.5 3.5027901785714282e-06 0.0 3.515066964285714e-06 0.0 3.515625e-06 1.5 3.5200892857142855e-06 1.5 3.520647321428571e-06 0.0 3.5329241071428567e-06 0.0 3.5334821428571427e-06 1.5 3.5379464285714282e-06 1.5 3.538504464285714e-06 0.0 3.55078125e-06 0.0 3.5513392857142854e-06 1.5 3.555803571428571e-06 1.5 3.556361607142857e-06 0.0 3.5686383928571427e-06 0.0 3.569196428571428e-06 1.5 3.573660714285714e-06 1.5 3.5742187499999996e-06 0.0 3.5864955357142854e-06 0.0 3.5870535714285713e-06 1.5 3.591517857142857e-06 1.5 3.592075892857143e-06 0.0 3.604352678571428e-06 0.0 3.604910714285714e-06 1.5 3.6093749999999996e-06 1.5 3.6099330357142856e-06 0.0 3.6222098214285713e-06 0.0 3.622767857142857e-06 1.5 3.6272321428571424e-06 1.5 3.6277901785714283e-06 0.0 3.640066964285714e-06 0.0 3.6406249999999996e-06 1.5 3.6450892857142856e-06 1.5 3.645647321428571e-06 0.0 3.657924107142857e-06 0.0 3.6584821428571427e-06 1.5 3.6629464285714283e-06 1.5 3.6635044642857142e-06 0.0 3.6757812499999996e-06 0.0 3.6763392857142855e-06 1.5 3.680803571428571e-06 1.5 3.681361607142857e-06 0.0 3.6936383928571427e-06 0.0 3.6941964285714282e-06 1.5 3.6986607142857142e-06 1.5 3.6992187499999997e-06 0.0 3.7114955357142855e-06 0.0 3.712053571428571e-06 1.5 3.716517857142857e-06 1.5 3.7170758928571425e-06 0.0 3.7293526785714282e-06 0.0 3.729910714285714e-06 1.5 3.7343749999999997e-06 1.5 3.7349330357142856e-06 0.0 3.747209821428571e-06 0.0 3.747767857142857e-06 1.5 3.7522321428571425e-06 1.5 3.7527901785714284e-06 0.0 3.765066964285714e-06 0.0 3.7656249999999996e-06 1.5 3.7700892857142856e-06 1.5 3.770647321428571e-06 0.0 3.782924107142857e-06 0.0 3.7834821428571424e-06 1.5 3.7879464285714284e-06 1.5 3.788504464285714e-06 0.0 3.8007812499999996e-06 0.0 3.8013392857142855e-06 1.5 3.805803571428571e-06 1.5 3.806361607142857e-06 0.0 3.818638392857143e-06 0.0 3.819196428571429e-06 1.5 3.823660714285714e-06 1.5 3.824218749999999e-06 0.0 3.836495535714285e-06 0.0 3.837053571428571e-06 1.5 3.841517857142857e-06 1.5 3.8420758928571425e-06 0.0 3.854352678571428e-06 0.0 3.854910714285714e-06 1.5 3.859375e-06 1.5 3.859933035714286e-06 0.0 3.8722098214285715e-06 0.0 3.8727678571428565e-06 1.5 3.877232142857143e-06 1.5 3.877790178571428e-06 0.0 3.890066964285714e-06 0.0 3.890625e-06 1.5 3.895089285714285e-06 1.5 3.895647321428571e-06 0.0 3.907924107142857e-06 0.0 3.908482142857143e-06 1.5 3.9129464285714285e-06 1.5 3.913504464285714e-06 0.0 3.92578125e-06 0.0 3.926339285714285e-06 1.5 3.930803571428571e-06 1.5 3.931361607142857e-06 0.0 3.9436383928571425e-06 0.0 3.944196428571428e-06 1.5 3.948660714285714e-06 1.5 3.94921875e-06 0.0 3.961495535714286e-06 0.0 3.9620535714285715e-06 1.5 3.966517857142857e-06 1.5 3.967075892857142e-06 0.0 3.979352678571428e-06 0.0 3.979910714285714e-06 1.5 3.9843749999999994e-06 1.5 3.984933035714285e-06 0.0 3.997209821428571e-06 0.0 3.997767857142857e-06 1.5 4.002232142857143e-06 1.5 4.0027901785714285e-06 0.0 4.015066964285714e-06 0.0 4.015624999999999e-06 1.5 4.020089285714286e-06 1.5 4.020647321428571e-06 0.0 4.032924107142857e-06 0.0 4.0334821428571425e-06 1.5 4.037946428571428e-06 1.5 4.038504464285714e-06 0.0 4.05078125e-06 0.0 4.051339285714286e-06 1.5 4.055803571428571e-06 1.5 4.056361607142857e-06 0.0 4.068638392857143e-06 0.0 4.069196428571428e-06 1.5 4.073660714285714e-06 1.5 4.0742187499999995e-06 0.0 4.086495535714285e-06 0.0 4.087053571428571e-06 1.5 4.091517857142857e-06 1.5 4.092075892857143e-06 0.0 4.1043526785714284e-06 0.0 4.104910714285714e-06 1.5 4.109375e-06 1.5 4.109933035714285e-06 0.0 4.122209821428571e-06 0.0 4.122767857142857e-06 1.5 4.127232142857142e-06 1.5 4.127790178571428e-06 0.0 4.140066964285714e-06 0.0 4.140625e-06 1.5 4.1450892857142854e-06 1.5 4.145647321428571e-06 0.0 4.157924107142857e-06 0.0 4.158482142857142e-06 1.5 4.162946428571429e-06 1.5 4.163504464285714e-06 0.0 4.1757812499999994e-06 0.0 4.176339285714285e-06 1.5 4.180803571428571e-06 1.5 4.181361607142857e-06 0.0 4.193638392857143e-06 0.0 4.1941964285714285e-06 1.5 4.198660714285714e-06 1.5 4.19921875e-06 0.0 4.211495535714286e-06 0.0 4.212053571428571e-06 1.5 4.216517857142857e-06 1.5 4.217075892857142e-06 0.0 4.229352678571428e-06 0.0 4.229910714285714e-06 1.5 4.234375e-06 1.5 4.2349330357142855e-06 0.0 4.247209821428571e-06 0.0 4.247767857142857e-06 1.5 4.252232142857143e-06 1.5 4.252790178571429e-06 0.0 4.265066964285714e-06 0.0 4.2656249999999995e-06 1.5 4.270089285714285e-06 1.5 4.270647321428571e-06 0.0 4.282924107142857e-06 0.0 4.283482142857143e-06 1.5 4.287946428571428e-06 1.5 4.288504464285714e-06 0.0 4.30078125e-06 0.0 4.301339285714285e-06 1.5 4.305803571428571e-06 1.5 4.3063616071428565e-06 0.0 4.318638392857142e-06 0.0 4.319196428571428e-06 1.5 4.323660714285714e-06 1.5 4.32421875e-06 0.0 4.3364955357142854e-06 0.0 4.337053571428571e-06 1.5 4.341517857142857e-06 1.5 4.342075892857143e-06 0.0 4.354352678571429e-06 0.0 4.354910714285714e-06 1.5 4.359375e-06 1.5 4.359933035714285e-06 0.0 4.372209821428571e-06 0.0 4.372767857142857e-06 1.5 4.377232142857142e-06 1.5 4.377790178571428e-06 0.0 4.390066964285714e-06 0.0 4.390625e-06 1.5 4.395089285714286e-06 1.5 4.3956473214285715e-06 0.0 4.407924107142856e-06 0.0 4.408482142857142e-06 1.5 4.412946428571428e-06 1.5 4.413504464285714e-06 0.0 4.42578125e-06 0.0 4.4263392857142855e-06 1.5 4.430803571428571e-06 1.5 4.431361607142857e-06 0.0 4.443638392857143e-06 0.0 4.444196428571429e-06 1.5 4.448660714285714e-06 1.5 4.449218749999999e-06 0.0 4.461495535714285e-06 0.0 4.462053571428571e-06 1.5 4.4665178571428566e-06 1.5 4.4670758928571425e-06 0.0 4.479352678571428e-06 0.0 4.479910714285714e-06 1.5 4.484375e-06 1.5 4.484933035714286e-06 0.0 4.497209821428571e-06 0.0 4.4977678571428565e-06 1.5 4.502232142857143e-06 1.5 4.502790178571428e-06 0.0 4.515066964285714e-06 0.0 4.515625e-06 1.5 4.520089285714285e-06 1.5 4.520647321428571e-06 0.0 4.532924107142857e-06 0.0 4.533482142857143e-06 1.5 4.537946428571428e-06 1.5 4.538504464285714e-06 0.0 4.55078125e-06 0.0 4.551339285714285e-06 1.5 4.555803571428571e-06 1.5 4.556361607142857e-06 0.0 4.568638392857142e-06 0.0 4.569196428571428e-06 1.5 4.573660714285714e-06 1.5 4.57421875e-06 0.0 4.5864955357142856e-06 0.0 4.5870535714285715e-06 1.5 4.591517857142857e-06 1.5 4.592075892857142e-06 0.0 4.604352678571428e-06 0.0 4.604910714285714e-06 1.5 4.609374999999999e-06 1.5 4.609933035714285e-06 0.0 4.622209821428571e-06 0.0 4.622767857142857e-06 1.5 4.6272321428571426e-06 1.5 4.6277901785714285e-06 0.0 4.640066964285714e-06 0.0 4.640624999999999e-06 1.5 4.645089285714286e-06 1.5 4.645647321428571e-06 0.0 4.6579241071428566e-06 0.0 4.6584821428571425e-06 1.5 4.662946428571428e-06 1.5 4.663504464285714e-06 0.0 4.67578125e-06 0.0 4.676339285714286e-06 1.5 4.680803571428571e-06 1.5 4.681361607142857e-06 0.0 4.693638392857143e-06 0.0 4.694196428571428e-06 1.5 4.6986607142857135e-06 1.5 4.6992187499999995e-06 0.0 4.711495535714285e-06 0.0 4.712053571428571e-06 1.5 4.716517857142857e-06 1.5 4.717075892857143e-06 0.0 4.729352678571428e-06 0.0 4.729910714285714e-06 1.5 4.734375e-06 1.5 4.734933035714286e-06 0.0 4.747209821428571e-06 0.0 4.747767857142857e-06 1.5 4.752232142857142e-06 1.5 4.752790178571428e-06 0.0 4.765066964285714e-06 0.0 4.765625e-06 1.5 4.770089285714285e-06 1.5 4.770647321428571e-06 0.0 4.782924107142857e-06 0.0 4.783482142857142e-06 1.5 4.7879464285714285e-06 1.5 4.788504464285714e-06 0.0 4.800781249999999e-06 0.0 4.801339285714285e-06 1.5 4.805803571428571e-06 1.5 4.806361607142857e-06 0.0 4.8186383928571425e-06 0.0 4.8191964285714285e-06 1.5 4.823660714285714e-06 1.5 4.82421875e-06 0.0 4.836495535714286e-06 0.0 4.837053571428571e-06 1.5 4.841517857142857e-06 1.5 4.842075892857142e-06 0.0 4.854352678571428e-06 0.0 4.854910714285714e-06 1.5 4.8593749999999995e-06 1.5 4.8599330357142854e-06 0.0 4.872209821428571e-06 0.0 4.872767857142857e-06 1.5 4.877232142857143e-06 1.5 4.877790178571429e-06 0.0 4.8900669642857135e-06 0.0 4.8906249999999994e-06 1.5 4.895089285714285e-06 1.5 4.895647321428571e-06 0.0 4.907924107142857e-06 0.0 4.908482142857143e-06 1.5 4.912946428571428e-06 1.5 4.913504464285714e-06 0.0 4.92578125e-06 0.0 4.926339285714285e-06 1.5 4.930803571428571e-06 1.5 4.9313616071428564e-06 0.0 4.943080357142857e-06 0.0 4.943638392857142e-06 1.5 4.94921875e-06 1.5 4.9497767857142855e-06 0.0 4.9609374999999995e-06 0.0 4.961495535714285e-06 1.5 4.967075892857143e-06 1.5 4.967633928571428e-06 0.0 4.978794642857143e-06 0.0 4.9793526785714285e-06 1.5 4.984933035714285e-06 1.5 4.985491071428571e-06 0.0 4.996651785714285e-06 0.0 4.997209821428571e-06 1.5 5.002790178571428e-06 1.5 5.003348214285714e-06 0.0 5.014508928571428e-06 0.0 5.015066964285714e-06 1.5 5.0206473214285714e-06 1.5 5.0212053571428565e-06 0.0 5.032366071428571e-06 0.0 5.032924107142857e-06 1.5 5.038504464285714e-06 1.5 5.0390625e-06 0.0 5.050223214285714e-06 0.0 5.0507812499999995e-06 1.5 5.056361607142857e-06 1.5 5.056919642857143e-06 0.0 5.068080357142857e-06 0.0 5.068638392857143e-06 1.5 5.074218749999999e-06 1.5 5.074776785714285e-06 0.0 5.0859375e-06 0.0 5.086495535714285e-06 1.5 5.092075892857142e-06 1.5 5.092633928571428e-06 0.0 5.103794642857142e-06 0.0 5.104352678571428e-06 1.5 5.109933035714286e-06 1.5 5.110491071428571e-06 0.0 5.1216517857142855e-06 0.0 5.122209821428571e-06 1.5 5.127790178571428e-06 1.5 5.128348214285714e-06 0.0 5.139508928571429e-06 0.0 5.140066964285714e-06 1.5 5.145647321428571e-06 1.5 5.146205357142857e-06 0.0 5.157366071428571e-06 0.0 5.157924107142857e-06 1.5 5.163504464285714e-06 1.5 5.164062499999999e-06 0.0 5.175223214285714e-06 0.0 5.17578125e-06 1.5 5.1813616071428566e-06 1.5 5.1819196428571425e-06 0.0 5.1930803571428564e-06 0.0 5.193638392857142e-06 1.5 5.19921875e-06 1.5 5.199776785714286e-06 0.0 5.2109375e-06 0.0 5.2114955357142855e-06 1.5 5.217075892857142e-06 1.5 5.217633928571428e-06 0.0 5.228794642857143e-06 0.0 5.229352678571428e-06 1.5 5.234933035714285e-06 1.5 5.235491071428571e-06 0.0 5.246651785714285e-06 0.0 5.247209821428571e-06 1.5 5.252790178571428e-06 1.5 5.253348214285714e-06 0.0 5.264508928571428e-06 0.0 5.265066964285714e-06 1.5 5.270647321428571e-06 1.5 5.271205357142857e-06 0.0 5.2823660714285714e-06 0.0 5.2829241071428565e-06 1.5 5.288504464285714e-06 1.5 5.2890625e-06 0.0 5.300223214285714e-06 0.0 5.30078125e-06 1.5 5.306361607142857e-06 1.5 5.306919642857142e-06 0.0 5.318080357142857e-06 0.0 5.318638392857143e-06 1.5 5.324218749999999e-06 1.5 5.324776785714285e-06 0.0 5.335937499999999e-06 0.0 5.336495535714285e-06 1.5 5.3420758928571426e-06 1.5 5.3426339285714285e-06 0.0 5.3532366071428565e-06 0.0 5.3537946428571424e-06 1.5 5.360491071428571e-06 1.5 5.361049107142857e-06 0.0 5.37109375e-06 0.0 5.371651785714286e-06 1.5 5.378348214285714e-06 1.5 5.37890625e-06 0.0 5.388950892857143e-06 0.0 5.389508928571428e-06 1.5 5.396205357142857e-06 1.5 5.396763392857142e-06 0.0 5.406808035714285e-06 0.0 5.407366071428571e-06 1.5 5.4140624999999995e-06 1.5 5.414620535714285e-06 0.0 5.424665178571428e-06 0.0 5.425223214285714e-06 1.5 5.431919642857143e-06 1.5 5.4324776785714285e-06 0.0 5.442522321428571e-06 0.0 5.443080357142857e-06 1.5 5.449776785714285e-06 1.5 5.450334821428571e-06 0.0 5.460379464285714e-06 0.0 5.4609375e-06 1.5 5.467633928571428e-06 1.5 5.468191964285714e-06 0.0 5.478236607142857e-06 0.0 5.478794642857142e-06 1.5 5.485491071428571e-06 1.5 5.486049107142856e-06 0.0 5.496093749999999e-06 0.0 5.496651785714285e-06 1.5 5.503348214285714e-06 1.5 5.5039062499999995e-06 0.0 5.5139508928571425e-06 0.0 5.514508928571428e-06 1.5 5.521205357142857e-06 1.5 5.521763392857143e-06 0.0 5.531808035714286e-06 0.0 5.532366071428571e-06 1.5 5.5390625e-06 1.5 5.539620535714285e-06 0.0 5.549665178571428e-06 0.0 5.550223214285714e-06 1.5 5.556919642857142e-06 1.5 5.557477678571428e-06 0.0 5.567522321428571e-06 0.0 5.568080357142857e-06 1.5 5.5747767857142855e-06 1.5 5.575334821428571e-06 0.0 5.5853794642857135e-06 0.0 5.585937499999999e-06 1.5 5.592633928571428e-06 1.5 5.593191964285714e-06 0.0 5.603236607142857e-06 0.0 5.6037946428571426e-06 1.5 5.610491071428571e-06 1.5 5.611049107142857e-06 0.0 5.62109375e-06 0.0 5.621651785714285e-06 1.5 5.628348214285714e-06 1.5 5.628906249999999e-06 0.0 5.638950892857142e-06 0.0 5.639508928571428e-06 1.5 5.6462053571428564e-06 1.5 5.646763392857142e-06 0.0 5.656808035714285e-06 0.0 5.657366071428571e-06 1.5 5.6640625e-06 1.5 5.6646205357142855e-06 0.0 5.6746651785714285e-06 0.0 5.6752232142857136e-06 1.5 5.681919642857143e-06 1.5 5.682477678571428e-06 0.0 5.692522321428571e-06 0.0 5.693080357142857e-06 1.5 5.700334821428571e-06 1.5 5.700892857142857e-06 0.0 5.709821428571428e-06 0.0 5.710379464285714e-06 1.5 5.718191964285714e-06 1.5 5.718749999999999e-06 0.0 5.727678571428571e-06 0.0 5.728236607142856e-06 1.5 5.7360491071428565e-06 1.5 5.736607142857142e-06 0.0 5.745535714285714e-06 0.0 5.7460937499999995e-06 1.5 5.75390625e-06 1.5 5.754464285714286e-06 0.0 5.763392857142857e-06 0.0 5.763950892857143e-06 1.5 5.771763392857143e-06 1.5 5.772321428571428e-06 0.0 5.78125e-06 0.0 5.781808035714285e-06 1.5 5.789620535714285e-06 1.5 5.790178571428571e-06 0.0 5.799107142857142e-06 0.0 5.799665178571428e-06 1.5 5.807477678571428e-06 1.5 5.808035714285714e-06 0.0 5.816964285714285e-06 0.0 5.817522321428571e-06 1.5 5.825334821428571e-06 1.5 5.8258928571428566e-06 0.0 5.834821428571428e-06 0.0 5.835379464285714e-06 1.5 5.843191964285714e-06 1.5 5.84375e-06 0.0 5.852678571428571e-06 0.0 5.853236607142857e-06 1.5 5.861049107142857e-06 1.5 5.861607142857142e-06 0.0 5.870535714285714e-06 0.0 5.87109375e-06 1.5 5.878906249999999e-06 1.5 5.879464285714285e-06 0.0 5.888392857142856e-06 0.0 5.888950892857142e-06 1.5 5.8967633928571425e-06 1.5 5.897321428571428e-06 0.0 5.9062499999999996e-06 0.0 5.9068080357142855e-06 1.5 5.914620535714286e-06 1.5 5.915178571428571e-06 0.0 5.924107142857143e-06 0.0 5.924665178571428e-06 1.5 5.932477678571428e-06 1.5 5.933035714285714e-06 0.0 5.941964285714285e-06 0.0 5.942522321428571e-06 1.5 5.950334821428571e-06 1.5 5.950892857142857e-06 0.0 5.959821428571428e-06 0.0 5.960379464285714e-06 1.5 5.9681919642857135e-06 1.5 5.968749999999999e-06 0.0 5.977678571428571e-06 0.0 5.9782366071428565e-06 1.5 5.986049107142857e-06 1.5 5.9866071428571426e-06 0.0 5.995535714285714e-06 0.0 5.99609375e-06 1.5 6.00390625e-06 1.5 6.004464285714285e-06 0.0 6.013392857142857e-06 0.0 6.013950892857143e-06 1.5 6.022321428571428e-06 1.5 6.022879464285714e-06 0.0 6.030691964285714e-06 0.0 6.031249999999999e-06 1.5 6.040178571428571e-06 1.5 6.040736607142856e-06 0.0 6.0485491071428565e-06 0.0 6.049107142857142e-06 1.5 6.0580357142857135e-06 1.5 6.0585937499999995e-06 0.0 6.06640625e-06 0.0 6.0669642857142856e-06 1.5 6.075892857142857e-06 1.5 6.076450892857143e-06 0.0 6.084263392857143e-06 0.0 6.084821428571428e-06 1.5 6.09375e-06 1.5 6.094308035714285e-06 0.0 6.102120535714285e-06 0.0 6.102678571428571e-06 1.5 6.111607142857142e-06 1.5 6.112165178571428e-06 0.0 6.119977678571428e-06 0.0 6.120535714285714e-06 1.5 6.129464285714285e-06 1.5 6.130022321428571e-06 0.0 6.137834821428571e-06 0.0 6.1383928571428565e-06 1.5 6.1473214285714286e-06 1.5 6.147879464285714e-06 0.0 6.155691964285714e-06 0.0 6.15625e-06 1.5 6.165178571428571e-06 1.5 6.165736607142857e-06 0.0 6.173549107142857e-06 0.0 6.174107142857142e-06 1.5 6.183035714285714e-06 1.5 6.18359375e-06 0.0 6.191406249999999e-06 0.0 6.191964285714285e-06 1.5 6.200892857142856e-06 1.5 6.201450892857142e-06 0.0 6.2092633928571425e-06 0.0 6.209821428571428e-06 1.5 6.2187499999999995e-06 1.5 6.2193080357142854e-06 0.0 6.227120535714286e-06 0.0 6.227678571428571e-06 1.5 6.236607142857143e-06 1.5 6.237165178571428e-06 0.0 6.244977678571428e-06 0.0 6.245535714285714e-06 1.5 6.254464285714285e-06 1.5 6.255022321428571e-06 0.0 6.262834821428571e-06 0.0 6.263392857142857e-06 1.5 6.272321428571428e-06 1.5 6.272879464285714e-06 0.0 6.2806919642857135e-06 0.0 6.281249999999999e-06 1.5 6.290178571428571e-06 1.5 6.2907366071428564e-06 0.0 6.298549107142857e-06 0.0 6.2991071428571425e-06 1.5 6.308035714285714e-06 1.5 6.30859375e-06 0.0 6.31640625e-06 0.0 6.316964285714285e-06 1.5 6.325892857142857e-06 1.5 6.326450892857143e-06 0.0 6.334263392857142e-06 0.0 6.334821428571428e-06 1.5 6.344308035714285e-06 1.5 6.344866071428571e-06 0.0 6.351562499999999e-06 0.0 6.352120535714285e-06 1.5 6.362165178571428e-06 1.5 6.362723214285714e-06 0.0 6.3694196428571426e-06 0.0 6.3699776785714285e-06 1.5 6.380022321428571e-06 1.5 6.3805803571428565e-06 0.0 6.387276785714285e-06 0.0 6.387834821428571e-06 1.5 6.397879464285714e-06 1.5 6.3984375e-06 0.0 6.405133928571428e-06 0.0 6.405691964285714e-06 1.5 6.415736607142857e-06 1.5 6.416294642857142e-06 0.0 6.422991071428571e-06 0.0 6.423549107142856e-06 1.5 6.433593749999999e-06 1.5 6.434151785714285e-06 0.0 6.4408482142857135e-06 0.0 6.4414062499999994e-06 1.5 6.4514508928571424e-06 1.5 6.452008928571428e-06 0.0 6.458705357142857e-06 0.0 6.459263392857143e-06 1.5 6.469308035714286e-06 1.5 6.469866071428571e-06 0.0 6.4765625e-06 0.0 6.477120535714285e-06 1.5 6.487165178571428e-06 1.5 6.487723214285714e-06 0.0 6.494419642857142e-06 0.0 6.494977678571428e-06 1.5 6.505022321428571e-06 1.5 6.505580357142857e-06 0.0 6.512276785714285e-06 0.0 6.512834821428571e-06 1.5 6.522879464285713e-06 1.5 6.523437499999999e-06 0.0 6.530133928571428e-06 0.0 6.530691964285714e-06 1.5 6.540736607142857e-06 1.5 6.5412946428571425e-06 0.0 6.547991071428571e-06 0.0 6.548549107142857e-06 1.5 6.55859375e-06 1.5 6.559151785714286e-06 0.0 6.565848214285714e-06 0.0 6.56640625e-06 1.5 6.576450892857142e-06 1.5 6.577008928571428e-06 0.0 6.583705357142856e-06 0.0 6.584263392857142e-06 1.5 6.594308035714285e-06 1.5 6.594866071428571e-06 0.0 6.6015624999999995e-06 0.0 6.6021205357142854e-06 1.5 6.612165178571428e-06 1.5 6.6127232142857135e-06 0.0 6.619419642857143e-06 0.0 6.619977678571428e-06 1.5 6.630022321428571e-06 1.5 6.630580357142857e-06 0.0 6.637276785714285e-06 0.0 6.637834821428571e-06 1.5 6.647879464285714e-06 1.5 6.6484375e-06 0.0 6.655133928571428e-06 0.0 6.655691964285714e-06 1.5 6.665736607142857e-06 1.5 6.666294642857142e-06 0.0 6.672991071428571e-06 0.0 6.6735491071428564e-06 1.5 6.683593749999999e-06 1.5 6.684151785714285e-06 0.0 6.690290178571428e-06 0.0 6.690848214285714e-06 1.5 6.7020089285714285e-06 1.5 6.7025669642857135e-06 0.0 6.708147321428571e-06 0.0 6.708705357142857e-06 1.5 6.719866071428571e-06 1.5 6.720424107142857e-06 0.0 6.726004464285714e-06 0.0 6.726562499999999e-06 1.5 6.737723214285714e-06 1.5 6.73828125e-06 0.0 6.7438616071428564e-06 0.0 6.744419642857142e-06 1.5 6.755580357142856e-06 1.5 6.756138392857142e-06 0.0 6.76171875e-06 0.0 6.7622767857142855e-06 1.5 6.7734374999999995e-06 1.5 6.773995535714285e-06 0.0 6.779575892857143e-06 0.0 6.780133928571428e-06 1.5 6.791294642857143e-06 1.5 6.791852678571428e-06 0.0 6.797433035714285e-06 0.0 6.797991071428571e-06 1.5 6.809151785714285e-06 1.5 6.809709821428571e-06 0.0 6.815290178571428e-06 0.0 6.815848214285714e-06 1.5 6.827008928571428e-06 1.5 6.827566964285714e-06 0.0 6.833147321428571e-06 0.0 6.8337053571428565e-06 1.5 6.844866071428571e-06 1.5 6.845424107142856e-06 0.0 6.851004464285714e-06 0.0 6.8515625e-06 1.5 6.862723214285714e-06 1.5 6.8632812499999995e-06 0.0 6.868861607142857e-06 0.0 6.869419642857142e-06 1.5 6.880580357142857e-06 1.5 6.881138392857143e-06 0.0 6.886718749999999e-06 0.0 6.887276785714285e-06 1.5 6.898437499999999e-06 1.5 6.898995535714285e-06 0.0 6.9045758928571424e-06 0.0 6.905133928571428e-06 1.5 6.916294642857142e-06 1.5 6.916852678571428e-06 0.0 6.922433035714286e-06 0.0 6.922991071428571e-06 1.5 6.9341517857142855e-06 1.5 6.9347098214285705e-06 0.0 6.940290178571428e-06 0.0 6.940848214285714e-06 1.5 6.952008928571428e-06 1.5 6.952566964285714e-06 0.0 6.958147321428571e-06 0.0 6.958705357142857e-06 1.5 6.969866071428571e-06 1.5 6.970424107142857e-06 0.0 6.976004464285713e-06 0.0 6.976562499999999e-06 1.5 6.987723214285714e-06 1.5 6.988281249999999e-06 0.0 6.993861607142857e-06 0.0 6.9944196428571425e-06 1.5 7.0055803571428564e-06 1.5 7.006138392857142e-06 0.0 7.01171875e-06 0.0 7.012276785714285e-06 1.5 7.0234375e-06 1.5 7.0239955357142855e-06 0.0 7.029575892857142e-06 0.0 7.030133928571428e-06 1.5 7.041294642857142e-06 1.5 7.041852678571428e-06 0.0 7.047433035714285e-06 0.0 7.047991071428571e-06 1.5 7.059151785714285e-06 1.5 7.059709821428571e-06 0.0 7.065290178571428e-06 0.0 7.0658482142857135e-06 1.5 7.077008928571428e-06 1.5 7.077566964285714e-06 0.0 7.083147321428571e-06 0.0 7.083705357142857e-06 1.5 7.094866071428571e-06 1.5 7.0954241071428565e-06 0.0 7.101004464285714e-06 0.0 7.1015625e-06 1.5 7.11328125e-06 1.5 7.113839285714286e-06 0.0 7.118303571428571e-06 0.0 7.118861607142856e-06 1.5 7.131138392857142e-06 1.5 7.131696428571428e-06 0.0 7.1361607142857135e-06 0.0 7.136718749999999e-06 1.5 7.148995535714285e-06 1.5 7.149553571428571e-06 0.0 7.154017857142857e-06 0.0 7.154575892857143e-06 1.5 7.166852678571428e-06 1.5 7.167410714285713e-06 0.0 7.171875e-06 0.0 7.172433035714285e-06 1.5 7.184709821428571e-06 1.5 7.185267857142857e-06 0.0 7.189732142857142e-06 0.0 7.190290178571428e-06 1.5 7.202566964285714e-06 1.5 7.203125e-06 0.0 7.207589285714285e-06 0.0 7.208147321428571e-06 1.5 7.220424107142857e-06 1.5 7.220982142857142e-06 0.0 7.225446428571428e-06 0.0 7.2260044642857136e-06 1.5 7.238281249999999e-06 1.5 7.238839285714285e-06 0.0 7.243303571428571e-06 0.0 7.243861607142857e-06 1.5 7.2561383928571425e-06 1.5 7.256696428571428e-06 0.0 7.261160714285714e-06 0.0 7.261718749999999e-06 1.5 7.273995535714285e-06 1.5 7.274553571428571e-06 0.0 7.279017857142856e-06 0.0 7.279575892857142e-06 1.5 7.291852678571428e-06 1.5 7.292410714285714e-06 0.0 7.2968749999999995e-06 0.0 7.297433035714285e-06 1.5 7.309709821428571e-06 1.5 7.310267857142856e-06 0.0 7.314732142857143e-06 0.0 7.315290178571428e-06 1.5 7.3275669642857135e-06 1.5 7.328124999999999e-06 0.0 7.332589285714285e-06 0.0 7.333147321428571e-06 1.5 7.345424107142857e-06 1.5 7.3459821428571426e-06 0.0 7.350446428571428e-06 0.0 7.351004464285714e-06 1.5 7.36328125e-06 1.5 7.363839285714285e-06 0.0 7.368303571428571e-06 0.0 7.368861607142856e-06 1.5 7.381138392857142e-06 1.5 7.381696428571428e-06 0.0 7.386160714285714e-06 0.0 7.3867187499999996e-06 1.5 7.398995535714285e-06 1.5 7.399553571428571e-06 0.0 7.404017857142857e-06 0.0 7.404575892857143e-06 1.5 7.416852678571428e-06 1.5 7.4174107142857136e-06 0.0 7.421874999999999e-06 0.0 7.422433035714285e-06 1.5 7.434709821428571e-06 1.5 7.435267857142857e-06 0.0 7.439732142857142e-06 0.0 7.440290178571428e-06 1.5 7.452566964285714e-06 1.5 7.453124999999999e-06 0.0 7.4575892857142855e-06 0.0 7.4581473214285705e-06 1.5 7.470424107142856e-06 1.5 7.470982142857142e-06 0.0 7.475446428571428e-06 0.0 7.476004464285714e-06 1.5 7.4882812499999995e-06 1.5 7.488839285714285e-06 0.0 7.493303571428571e-06 0.0 7.493861607142857e-06 1.5 7.506138392857143e-06 1.5 7.506696428571428e-06 0.0 7.511160714285714e-06 0.0 7.511718749999999e-06 1.5 7.523995535714285e-06 1.5 7.524553571428571e-06 0.0 7.5290178571428565e-06 0.0 7.529575892857142e-06 1.5 7.541852678571428e-06 1.5 7.542410714285714e-06 0.0 7.546875e-06 0.0 7.5474330357142855e-06 1.5 7.5597098214285705e-06 1.5 7.560267857142856e-06 0.0 7.564732142857142e-06 0.0 7.565290178571428e-06 1.5 7.577566964285714e-06 1.5 7.5781249999999995e-06 0.0 7.582589285714285e-06 0.0 7.583147321428571e-06 1.5 7.595424107142857e-06 1.5 7.595982142857143e-06 0.0 7.600446428571428e-06 0.0 7.601004464285713e-06 1.5 7.613281249999999e-06 1.5 7.613839285714285e-06 0.0 7.618303571428571e-06 0.0 7.6188616071428565e-06 1.5 7.631138392857143e-06 1.5 7.631696428571428e-06 0.0 7.636160714285714e-06 0.0 7.636718749999999e-06 1.5 7.648995535714285e-06 1.5 7.64955357142857e-06 0.0 7.654017857142856e-06 0.0 7.654575892857143e-06 1.5 7.666852678571428e-06 1.5 7.667410714285715e-06 0.0 7.671875e-06 0.0 7.672433035714285e-06 1.5 7.68470982142857e-06 1.5 7.685267857142857e-06 0.0 7.689732142857142e-06 0.0 7.690290178571428e-06 1.5 7.702566964285714e-06 1.5 7.703125e-06 0.0 7.707589285714285e-06 0.0 7.708147321428572e-06 1.5 7.720424107142856e-06 1.5 7.720982142857142e-06 0.0 7.725446428571429e-06 0.0 7.726004464285714e-06 1.5 7.738281249999999e-06 1.5 7.738839285714286e-06 0.0 7.743303571428571e-06 0.0 7.743861607142856e-06 1.5 7.756138392857143e-06 1.5 7.756696428571428e-06 0.0 7.761160714285713e-06 0.0 7.76171875e-06 1.5 7.773995535714285e-06 1.5 7.77455357142857e-06 0.0 7.779017857142856e-06 0.0 7.779575892857143e-06 1.5 7.791852678571427e-06 1.5 7.792410714285714e-06 0.0 7.796875e-06 0.0 7.797433035714285e-06 1.5 7.809709821428571e-06 1.5 7.810267857142857e-06 0.0 7.814732142857142e-06 0.0 7.815290178571427e-06 1.5 7.827566964285714e-06 1.5 7.828124999999999e-06 0.0 7.832589285714284e-06 0.0 7.833147321428571e-06 1.5 7.845424107142856e-06 1.5 7.845982142857143e-06 0.0 7.850446428571428e-06 0.0 7.851004464285714e-06 1.5 7.86328125e-06 1.5 7.863839285714285e-06 0.0 7.86830357142857e-06 0.0 7.868861607142856e-06 1.5 7.881138392857142e-06 1.5 7.881696428571428e-06 0.0 7.886160714285713e-06 0.0 7.88671875e-06 1.5 7.898995535714285e-06 1.5 7.899553571428572e-06 0.0 7.904017857142857e-06 0.0 7.904575892857142e-06 1.5 7.916852678571429e-06 1.5 7.917410714285714e-06 0.0 7.921875e-06 0.0 7.922433035714284e-06 1.5 7.934709821428571e-06 1.5 7.935267857142856e-06 0.0 7.939732142857142e-06 0.0 7.940290178571429e-06 1.5 7.952566964285713e-06 1.5 7.953125e-06 0.0 7.957589285714286e-06 0.0 7.95814732142857e-06 1.5 7.970424107142856e-06 1.5 7.970982142857143e-06 0.0 7.975446428571428e-06 0.0 7.976004464285713e-06 1.5 7.98828125e-06 1.5 7.988839285714285e-06 0.0 7.99330357142857e-06 0.0 7.993861607142857e-06 1.5 8.006138392857142e-06 1.5 8.006696428571427e-06 0.0 8.011160714285714e-06 0.0 8.01171875e-06 1.5 8.023995535714284e-06 1.5 8.024553571428571e-06 0.0 8.029017857142857e-06 0.0 8.029575892857142e-06 1.5 8.041852678571428e-06 1.5 8.042410714285714e-06 0.0 8.046874999999999e-06 0.0 8.047433035714286e-06 1.5 8.05970982142857e-06 1.5 8.060267857142856e-06 0.0 8.064732142857143e-06 0.0 8.065290178571428e-06 1.5 8.077566964285713e-06 1.5 8.078125e-06 0.0 8.082589285714285e-06 0.0 8.08314732142857e-06 1.5 8.095424107142857e-06 1.5 8.095982142857142e-06 0.0 8.100446428571428e-06 0.0 8.101004464285715e-06 1.5 8.11328125e-06 1.5 8.113839285714284e-06 0.0 8.11830357142857e-06 0.0 8.118861607142857e-06 1.5 8.131138392857142e-06 1.5 8.131696428571429e-06 0.0 8.136160714285714e-06 0.0 8.136718749999999e-06 1.5 8.148995535714286e-06 1.5 8.14955357142857e-06 0.0 8.154017857142856e-06 0.0 8.154575892857141e-06 1.5 8.166852678571428e-06 1.5 8.167410714285713e-06 0.0 8.171874999999999e-06 0.0 8.172433035714285e-06 1.5 8.18470982142857e-06 1.5 8.185267857142857e-06 0.0 8.189732142857143e-06 0.0 8.190290178571428e-06 1.5 8.202566964285714e-06 1.5 8.203125e-06 0.0 8.207589285714285e-06 0.0 8.20814732142857e-06 1.5 8.220424107142857e-06 1.5 8.220982142857142e-06 0.0 8.225446428571427e-06 0.0 8.226004464285714e-06 1.5 8.238281249999999e-06 1.5 8.238839285714286e-06 0.0 8.243303571428571e-06 0.0 8.243861607142856e-06 1.5 8.256138392857143e-06 1.5 8.256696428571428e-06 0.0 8.261160714285714e-06 0.0 8.261718749999999e-06 1.5 8.273995535714285e-06 1.5 8.27455357142857e-06 0.0 8.279017857142856e-06 0.0 8.279575892857143e-06 1.5 8.291852678571428e-06 1.5 8.292410714285714e-06 0.0 8.296875e-06 0.0 8.297433035714285e-06 1.5 8.30970982142857e-06 1.5 8.310267857142857e-06 0.0 8.314732142857142e-06 0.0 8.315290178571427e-06 1.5 8.327566964285714e-06 1.5 8.328124999999999e-06 0.0 8.332589285714285e-06 0.0 8.333147321428571e-06 1.5 8.345424107142856e-06 1.5 8.345982142857141e-06 0.0 8.350446428571429e-06 0.0 8.351004464285714e-06 1.5 8.363281249999999e-06 1.5 8.363839285714285e-06 0.0 8.368303571428571e-06 0.0 8.368861607142856e-06 1.5 8.381138392857143e-06 1.5 8.381696428571428e-06 0.0 8.386160714285713e-06 0.0 8.38671875e-06 1.5 8.398995535714285e-06 1.5 8.39955357142857e-06 0.0 8.404017857142856e-06 0.0 8.404575892857142e-06 1.5 8.416852678571427e-06 1.5 8.417410714285714e-06 0.0 8.421875e-06 0.0 8.422433035714285e-06 1.5 8.434709821428571e-06 1.5 8.435267857142856e-06 0.0 8.439732142857142e-06 0.0 8.440290178571429e-06 1.5 8.452566964285714e-06 1.5 8.453124999999999e-06 0.0 8.457589285714284e-06 0.0 8.458147321428571e-06 1.5 8.470424107142856e-06 1.5 8.470982142857143e-06 0.0 8.475446428571428e-06 0.0 8.476004464285713e-06 1.5 8.48828125e-06 1.5 8.488839285714285e-06 0.0 8.49330357142857e-06 0.0 8.493861607142856e-06 1.5 8.506138392857142e-06 1.5 8.506696428571427e-06 0.0 8.511160714285713e-06 0.0 8.51171875e-06 1.5 8.523995535714285e-06 1.5 8.524553571428571e-06 0.0 8.529017857142857e-06 0.0 8.529575892857142e-06 1.5 8.541852678571429e-06 1.5 8.542410714285714e-06 0.0 8.546875e-06 0.0 8.547433035714284e-06 1.5 8.559709821428571e-06 1.5 8.560267857142856e-06 0.0 8.564732142857142e-06 0.0 8.565290178571428e-06 1.5 8.577566964285713e-06 1.5 8.578125e-06 0.0 8.582589285714286e-06 0.0 8.58314732142857e-06 1.5 8.595424107142856e-06 1.5 8.595982142857142e-06 0.0 8.600446428571428e-06 0.0 8.601004464285713e-06 1.5 8.61328125e-06 1.5 8.613839285714285e-06 0.0 8.61830357142857e-06 0.0 8.618861607142857e-06 1.5 8.631138392857142e-06 1.5 8.631696428571427e-06 0.0 8.636160714285714e-06 0.0 8.63671875e-06 1.5 8.648995535714284e-06 1.5 8.649553571428571e-06 0.0 8.654017857142857e-06 0.0 8.654575892857142e-06 1.5 8.666852678571428e-06 1.5 8.667410714285713e-06 0.0 8.671874999999999e-06 0.0 8.672433035714286e-06 1.5 8.68470982142857e-06 1.5 8.685267857142856e-06 0.0 8.689732142857143e-06 0.0 8.690290178571428e-06 1.5 8.702566964285713e-06 1.5 8.703125e-06 0.0 8.707589285714285e-06 0.0 8.70814732142857e-06 1.5 8.720424107142857e-06 1.5 8.720982142857142e-06 0.0 8.725446428571428e-06 0.0 8.726004464285714e-06 1.5 8.73828125e-06 1.5 8.738839285714284e-06 0.0 8.74330357142857e-06 0.0 8.743861607142857e-06 1.5 8.756138392857142e-06 1.5 8.756696428571428e-06 0.0 8.761160714285714e-06 0.0 8.761718749999999e-06 1.5 8.773995535714286e-06 1.5 8.77455357142857e-06 0.0 8.779017857142856e-06 0.0 8.779575892857141e-06 1.5 8.791852678571428e-06 1.5 8.792410714285713e-06 0.0 8.796874999999999e-06 0.0 8.797433035714285e-06 1.5 8.80970982142857e-06 1.5 8.810267857142857e-06 0.0 8.814732142857143e-06 0.0 8.815290178571428e-06 1.5 8.827566964285714e-06 1.5 8.828125e-06 0.0 8.832589285714285e-06 0.0 8.83314732142857e-06 1.5 8.845424107142857e-06 1.5 8.845982142857142e-06 0.0 8.850446428571427e-06 0.0 8.851004464285714e-06 1.5 8.863281249999999e-06 1.5 8.863839285714286e-06 0.0 8.868303571428571e-06 0.0 8.868861607142856e-06 1.5 8.881138392857143e-06 1.5 8.881696428571428e-06 0.0 8.886160714285714e-06 0.0 8.886718749999999e-06 1.5 8.898995535714285e-06 1.5 8.89955357142857e-06 0.0 8.904017857142856e-06 0.0 8.904575892857143e-06 1.5 8.916852678571428e-06 1.5 8.917410714285714e-06 0.0 8.921875e-06 0.0 8.922433035714285e-06 1.5 8.93470982142857e-06 1.5 8.935267857142857e-06 0.0 8.939732142857142e-06 0.0 8.940290178571427e-06 1.5 8.952008928571427e-06 1.5 8.952566964285714e-06 0.0 8.958147321428571e-06 0.0 8.958705357142856e-06 1.5 8.969866071428571e-06 1.5 8.970424107142856e-06 0.0 8.976004464285714e-06 0.0 8.976562499999999e-06 1.5 8.987723214285714e-06 1.5 8.988281249999999e-06 0.0 8.993861607142856e-06 0.0 8.994419642857143e-06 1.5 9.005580357142856e-06 1.5 9.006138392857143e-06 0.0 9.01171875e-06 0.0 9.012276785714285e-06 1.5 9.0234375e-06 1.5 9.023995535714285e-06 0.0 9.029575892857142e-06 0.0 9.030133928571427e-06 1.5 9.041294642857142e-06 1.5 9.041852678571427e-06 0.0 9.047433035714285e-06 0.0 9.047991071428571e-06 1.5 9.059151785714285e-06 1.5 9.059709821428571e-06 0.0 9.065290178571429e-06 0.0 9.065848214285714e-06 1.5 9.077008928571429e-06 1.5 9.077566964285714e-06 0.0 9.083147321428571e-06 0.0 9.083705357142856e-06 1.5 9.094866071428571e-06 1.5 9.095424107142856e-06 0.0 9.101004464285713e-06 0.0 9.1015625e-06 1.5 9.112723214285713e-06 1.5 9.11328125e-06 0.0 9.118861607142856e-06 0.0 9.119419642857142e-06 1.5 9.130580357142857e-06 1.5 9.131138392857142e-06 0.0 9.13671875e-06 0.0 9.137276785714285e-06 1.5 9.1484375e-06 1.5 9.148995535714285e-06 0.0 9.154575892857142e-06 0.0 9.155133928571427e-06 1.5 9.166294642857142e-06 1.5 9.166852678571429e-06 0.0 9.172433035714284e-06 0.0 9.172991071428571e-06 1.5 9.184151785714284e-06 1.5 9.184709821428571e-06 0.0 9.190290178571428e-06 0.0 9.190848214285713e-06 1.5 9.202008928571428e-06 1.5 9.202566964285713e-06 0.0 9.20814732142857e-06 0.0 9.208705357142856e-06 1.5 9.21986607142857e-06 1.5 9.220424107142856e-06 0.0 9.226004464285713e-06 0.0 9.2265625e-06 1.5 9.237723214285713e-06 1.5 9.23828125e-06 0.0 9.243861607142857e-06 0.0 9.244419642857142e-06 1.5 9.255580357142857e-06 1.5 9.256138392857142e-06 0.0 9.26171875e-06 0.0 9.262276785714284e-06 1.5 9.2734375e-06 1.5 9.273995535714284e-06 0.0 9.279575892857142e-06 0.0 9.280133928571428e-06 1.5 9.291294642857142e-06 1.5 9.291852678571428e-06 0.0 9.297433035714286e-06 0.0 9.29799107142857e-06 1.5 9.309151785714286e-06 1.5 9.30970982142857e-06 0.0 9.315290178571428e-06 0.0 9.315848214285713e-06 1.5 9.327008928571428e-06 1.5 9.327566964285713e-06 0.0 9.33314732142857e-06 0.0 9.333705357142857e-06 1.5 9.34486607142857e-06 1.5 9.345424107142857e-06 0.0 9.351004464285714e-06 0.0 9.3515625e-06 1.5 9.362723214285714e-06 1.5 9.36328125e-06 0.0 9.369419642857142e-06 0.0 9.369977678571429e-06 1.5 9.380022321428572e-06 1.5 9.380580357142857e-06 0.0 9.387276785714286e-06 0.0 9.387834821428571e-06 1.5 9.397879464285714e-06 1.5 9.398437499999999e-06 0.0 9.405133928571428e-06 0.0 9.405691964285713e-06 1.5 9.415736607142856e-06 1.5 9.416294642857143e-06 0.0 9.42299107142857e-06 0.0 9.423549107142857e-06 1.5 9.433593749999998e-06 1.5 9.434151785714285e-06 0.0 9.440848214285713e-06 0.0 9.44140625e-06 1.5 9.451450892857143e-06 1.5 9.452008928571428e-06 0.0 9.458705357142857e-06 0.0 9.459263392857142e-06 1.5 9.469308035714285e-06 1.5 9.469866071428572e-06 0.0 9.476562499999999e-06 0.0 9.477120535714286e-06 1.5 9.487165178571427e-06 1.5 9.487723214285714e-06 0.0 9.494419642857141e-06 0.0 9.494977678571428e-06 1.5 9.505022321428571e-06 1.5 9.505580357142856e-06 0.0 9.512276785714285e-06 0.0 9.51283482142857e-06 1.5 9.522879464285713e-06 1.5 9.523437499999999e-06 0.0 9.530133928571428e-06 0.0 9.530691964285713e-06 1.5 9.540736607142856e-06 1.5 9.541294642857143e-06 0.0 9.54799107142857e-06 0.0 9.548549107142857e-06 1.5 9.55859375e-06 1.5 9.559151785714285e-06 0.0 9.565848214285714e-06 0.0 9.56640625e-06 1.5 9.576450892857142e-06 1.5 9.577008928571427e-06 0.0 9.583705357142856e-06 0.0 9.584263392857141e-06 1.5 9.594308035714284e-06 1.5 9.594866071428571e-06 0.0 9.601562499999999e-06 0.0 9.602120535714286e-06 1.5 9.612165178571428e-06 1.5 9.612723214285714e-06 0.0 9.619419642857143e-06 0.0 9.619977678571428e-06 1.5 9.63002232142857e-06 1.5 9.630580357142856e-06 0.0 9.637276785714285e-06 0.0 9.63783482142857e-06 1.5 9.647879464285713e-06 1.5 9.6484375e-06 0.0 9.655133928571427e-06 0.0 9.655691964285714e-06 1.5 9.665736607142857e-06 1.5 9.666294642857142e-06 0.0 9.672991071428571e-06 0.0 9.673549107142856e-06 1.5 9.68359375e-06 1.5 9.684151785714285e-06 0.0 9.690848214285714e-06 0.0 9.691406249999999e-06 1.5 9.701450892857142e-06 1.5 9.702008928571429e-06 0.0 9.708705357142856e-06 0.0 9.709263392857143e-06 1.5 9.718749999999999e-06 1.5 9.719308035714286e-06 0.0 9.727120535714285e-06 0.0 9.72767857142857e-06 1.5 9.736607142857141e-06 1.5 9.737165178571428e-06 0.0 9.744977678571427e-06 0.0 9.745535714285714e-06 1.5 9.754464285714285e-06 1.5 9.75502232142857e-06 0.0 9.762834821428572e-06 0.0 9.763392857142857e-06 1.5 9.772321428571428e-06 1.5 9.772879464285713e-06 0.0 9.780691964285714e-06 0.0 9.781249999999999e-06 1.5 9.79017857142857e-06 1.5 9.790736607142857e-06 0.0 9.798549107142856e-06 0.0 9.799107142857143e-06 1.5 9.808035714285714e-06 1.5 9.808593749999999e-06 0.0 9.816406249999998e-06 0.0 9.816964285714285e-06 1.5 9.825892857142856e-06 1.5 9.826450892857141e-06 0.0 9.834263392857142e-06 0.0 9.834821428571428e-06 1.5 9.843749999999999e-06 1.5 9.844308035714285e-06 0.0 9.852120535714285e-06 0.0 9.85267857142857e-06 1.5 9.861607142857143e-06 1.5 9.862165178571428e-06 0.0 9.869977678571427e-06 0.0 9.870535714285714e-06 1.5 9.879464285714285e-06 1.5 9.88002232142857e-06 0.0 9.887834821428571e-06 0.0 9.888392857142856e-06 1.5 9.897321428571427e-06 1.5 9.897879464285714e-06 0.0 9.905691964285713e-06 0.0 9.906249999999999e-06 1.5 9.915178571428571e-06 1.5 9.915736607142856e-06 0.0 9.923549107142856e-06 0.0 9.924107142857143e-06 1.5 9.933035714285714e-06 1.5 9.933593749999999e-06 0.0 9.94140625e-06 0.0 9.941964285714285e-06 1.5 9.950892857142856e-06 1.5 9.951450892857143e-06 0.0 9.959263392857142e-06 0.0 9.959821428571427e-06 1.5 9.96875e-06 1.5 9.969308035714285e-06 0.0 9.977120535714284e-06 0.0 9.977678571428571e-06 1.5 9.986607142857142e-06 1.5 9.987165178571427e-06 0.0 9.994977678571428e-06 0.0 9.995535714285714e-06 1.5 1.0004464285714285e-05 1.5 1.0005022321428571e-05 0.0 1.001283482142857e-05 0.0 1.0013392857142856e-05 1.5 1.0022321428571427e-05 1.5 1.0022879464285714e-05 0.0 1.0030691964285713e-05 0.0 1.003125e-05 1.5 1.0039620535714284e-05 1.5 1.0040178571428571e-05 0.0 1.0049107142857142e-05 0.0 1.0049665178571427e-05 1.5 1.0057477678571428e-05 1.5 1.0058035714285713e-05 0.0 1.0066964285714285e-05 0.0 1.0067522321428571e-05 1.5 1.007533482142857e-05 1.5 1.0075892857142856e-05 0.0 1.0084821428571429e-05 0.0 1.0085379464285714e-05 1.5 1.0093191964285713e-05 1.5 1.009375e-05 0.0 1.0102678571428571e-05 0.0 1.0103236607142856e-05 1.5 1.0111049107142857e-05 1.5 1.0111607142857142e-05 0.0 1.0120535714285713e-05 0.0 1.012109375e-05 1.5 1.012890625e-05 1.5 1.0129464285714284e-05 0.0 1.0138392857142857e-05 0.0 1.0138950892857142e-05 1.5 1.0146763392857142e-05 1.5 1.0147321428571428e-05 0.0 1.015625e-05 0.0 1.0156808035714285e-05 1.5 1.0164620535714286e-05 1.5 1.016517857142857e-05 0.0 1.0174107142857142e-05 0.0 1.0174665178571429e-05 1.5 1.0182477678571428e-05 1.5 1.0183035714285713e-05 0.0 1.0191964285714284e-05 0.0 1.0192522321428571e-05 1.5 1.020033482142857e-05 1.5 1.0200892857142857e-05 0.0 1.0209821428571428e-05 0.0 1.0210379464285713e-05 1.5 1.0218191964285714e-05 1.5 1.021875e-05 0.0 1.022767857142857e-05 0.0 1.0228236607142856e-05 1.5 1.0236049107142857e-05 1.5 1.0236607142857142e-05 0.0 1.0245535714285713e-05 0.0 1.024609375e-05 1.5 1.0253906249999999e-05 1.5 1.0254464285714286e-05 0.0 1.0263392857142857e-05 0.0 1.0263950892857142e-05 1.5 1.0271763392857143e-05 1.5 1.0272321428571428e-05 0.0 1.028125e-05 0.0 1.0281808035714284e-05 1.5 1.0289620535714285e-05 1.5 1.029017857142857e-05 0.0 1.0299107142857142e-05 0.0 1.0299665178571428e-05 1.5 1.0307477678571428e-05 1.5 1.0308035714285714e-05 0.0 1.0316964285714286e-05 0.0 1.031752232142857e-05 1.5 1.032533482142857e-05 1.5 1.0325892857142857e-05 0.0 1.0334821428571428e-05 0.0 1.0335379464285713e-05 1.5 1.0343191964285714e-05 1.5 1.0343749999999999e-05 0.0 1.035267857142857e-05 0.0 1.0353236607142857e-05 1.5 1.0360491071428571e-05 1.5 1.0361049107142856e-05 0.0 1.037109375e-05 0.0 1.0371651785714284e-05 1.5 1.0378348214285714e-05 1.5 1.0378906249999999e-05 0.0 1.0388950892857142e-05 0.0 1.0389508928571428e-05 1.5 1.0396205357142856e-05 1.5 1.0396763392857143e-05 0.0 1.0406808035714286e-05 0.0 1.040736607142857e-05 1.5 1.04140625e-05 1.5 1.0414620535714285e-05 0.0 1.0424665178571428e-05 0.0 1.0425223214285713e-05 1.5 1.0431919642857142e-05 1.5 1.0432477678571427e-05 0.0 1.044252232142857e-05 0.0 1.0443080357142857e-05 1.5 1.0449776785714285e-05 1.5 1.0450334821428571e-05 0.0 1.0460379464285714e-05 0.0 1.04609375e-05 1.5 1.0467633928571429e-05 1.5 1.0468191964285714e-05 0.0 1.0478236607142857e-05 0.0 1.0478794642857142e-05 1.5 1.0485491071428571e-05 1.5 1.0486049107142856e-05 0.0 1.0496093749999999e-05 0.0 1.0496651785714286e-05 1.5 1.0503348214285713e-05 1.5 1.050390625e-05 0.0 1.0513950892857143e-05 0.0 1.0514508928571428e-05 1.5 1.0521205357142857e-05 1.5 1.0521763392857142e-05 0.0 1.0531808035714285e-05 0.0 1.053236607142857e-05 1.5 1.05390625e-05 1.5 1.0539620535714285e-05 0.0 1.0549665178571428e-05 0.0 1.0550223214285714e-05 1.5 1.0556919642857142e-05 1.5 1.0557477678571429e-05 0.0 1.056752232142857e-05 0.0 1.0568080357142857e-05 1.5 1.0574776785714284e-05 1.5 1.0575334821428571e-05 0.0 1.0585379464285714e-05 0.0 1.0585937499999999e-05 1.5 1.0592633928571428e-05 1.5 1.0593191964285713e-05 0.0 1.0603236607142856e-05 0.0 1.0603794642857141e-05 1.5 1.061049107142857e-05 1.5 1.0611049107142856e-05 0.0 1.0621093749999999e-05 0.0 1.0621651785714285e-05 1.5 1.0628348214285713e-05 1.5 1.062890625e-05 0.0 1.0638950892857143e-05 0.0 1.0639508928571428e-05 1.5 1.0646205357142857e-05 1.5 1.0646763392857142e-05 0.0 1.0656808035714285e-05 0.0 1.065736607142857e-05 1.5 1.06640625e-05 1.5 1.0664620535714284e-05 0.0 1.0674665178571427e-05 0.0 1.0675223214285714e-05 1.5 1.0681919642857141e-05 1.5 1.0682477678571428e-05 0.0 1.0692522321428571e-05 0.0 1.0693080357142856e-05 1.5 1.0699776785714286e-05 1.5 1.070033482142857e-05 0.0 1.0710937499999999e-05 0.0 1.0711495535714285e-05 1.5 1.0717075892857143e-05 1.5 1.0717633928571428e-05 0.0 1.0728794642857143e-05 0.0 1.0729352678571428e-05 1.5 1.0734933035714285e-05 1.5 1.073549107142857e-05 0.0 1.0746651785714285e-05 0.0 1.074720982142857e-05 1.5 1.0752790178571427e-05 1.5 1.0753348214285714e-05 0.0 1.0764508928571427e-05 0.0 1.0765066964285714e-05 1.5 1.0770647321428571e-05 1.5 1.0771205357142856e-05 0.0 1.0782366071428571e-05 0.0 1.0782924107142856e-05 1.5 1.0788504464285714e-05 1.5 1.0789062499999999e-05 0.0 1.0800223214285714e-05 0.0 1.0800781249999999e-05 1.5 1.0806361607142856e-05 1.5 1.0806919642857143e-05 0.0 1.0818080357142856e-05 0.0 1.0818638392857143e-05 1.5 1.0824218749999998e-05 1.5 1.0824776785714285e-05 0.0 1.08359375e-05 0.0 1.0836495535714285e-05 1.5 1.0842075892857142e-05 1.5 1.0842633928571427e-05 0.0 1.0853794642857142e-05 0.0 1.0854352678571427e-05 1.5 1.0859933035714285e-05 1.5 1.086049107142857e-05 0.0 1.0871651785714285e-05 0.0 1.0872209821428571e-05 1.5 1.0877790178571427e-05 1.5 1.0878348214285714e-05 0.0 1.0889508928571429e-05 0.0 1.0890066964285714e-05 1.5 1.0895647321428571e-05 1.5 1.0896205357142856e-05 0.0 1.0907366071428571e-05 0.0 1.0907924107142856e-05 1.5 1.0913504464285713e-05 1.5 1.0914062499999998e-05 0.0 1.0925223214285713e-05 0.0 1.092578125e-05 1.5 1.0931361607142856e-05 1.5 1.0931919642857142e-05 0.0 1.0943080357142856e-05 0.0 1.0943638392857142e-05 1.5 1.094921875e-05 1.5 1.0949776785714285e-05 0.0 1.09609375e-05 0.0 1.0961495535714285e-05 1.5 1.0967075892857142e-05 1.5 1.0967633928571427e-05 0.0 1.0978794642857142e-05 0.0 1.0979352678571427e-05 1.5 1.0984933035714284e-05 1.5 1.0985491071428571e-05 0.0 1.0996651785714284e-05 0.0 1.0997209821428571e-05 1.5 1.1002790178571428e-05 1.5 1.1003348214285713e-05 0.0 1.1014508928571428e-05 0.0 1.1015066964285713e-05 1.5 1.102064732142857e-05 1.5 1.1021205357142856e-05 0.0 1.103236607142857e-05 0.0 1.1032924107142856e-05 1.5 1.1038504464285713e-05 1.5 1.10390625e-05 0.0 1.1050223214285713e-05 0.0 1.105078125e-05 1.5 1.1056361607142857e-05 1.5 1.1056919642857142e-05 0.0 1.1068080357142857e-05 0.0 1.1068638392857142e-05 1.5 1.107421875e-05 1.5 1.1074776785714284e-05 0.0 1.10859375e-05 0.0 1.1086495535714284e-05 1.5 1.1092075892857142e-05 1.5 1.1092633928571428e-05 0.0 1.1103794642857142e-05 0.0 1.1104352678571428e-05 1.5 1.1109933035714286e-05 1.5 1.111049107142857e-05 0.0 1.112220982142857e-05 0.0 1.1122767857142856e-05 1.5 1.1127232142857141e-05 1.5 1.1127790178571428e-05 0.0 1.1140066964285713e-05 0.0 1.1140625e-05 1.5 1.1145089285714285e-05 1.5 1.114564732142857e-05 0.0 1.1157924107142857e-05 0.0 1.1158482142857142e-05 1.5 1.1162946428571428e-05 1.5 1.1163504464285713e-05 0.0 1.117578125e-05 0.0 1.1176339285714284e-05 1.5 1.118080357142857e-05 1.5 1.1181361607142857e-05 0.0 1.1193638392857142e-05 0.0 1.1194196428571428e-05 1.5 1.1198660714285714e-05 1.5 1.1199218749999999e-05 0.0 1.1211495535714286e-05 0.0 1.121205357142857e-05 1.5 1.1216517857142856e-05 1.5 1.1217075892857141e-05 0.0 1.1229352678571428e-05 0.0 1.1229910714285713e-05 1.5 1.1234374999999999e-05 1.5 1.1234933035714285e-05 0.0 1.124720982142857e-05 0.0 1.1247767857142857e-05 1.5 1.1252232142857143e-05 1.5 1.1252790178571428e-05 0.0 1.1265066964285713e-05 0.0 1.1265625e-05 1.5 1.1270089285714285e-05 1.5 1.127064732142857e-05 0.0 1.1282924107142857e-05 0.0 1.1283482142857142e-05 1.5 1.1287946428571427e-05 1.5 1.1288504464285714e-05 0.0 1.1300781249999999e-05 0.0 1.1301339285714286e-05 1.5 1.1305803571428571e-05 1.5 1.1306361607142856e-05 0.0 1.1318638392857141e-05 0.0 1.1319196428571428e-05 1.5 1.1323660714285714e-05 1.5 1.1324218749999999e-05 0.0 1.1336495535714285e-05 0.0 1.133705357142857e-05 1.5 1.1341517857142856e-05 1.5 1.1342075892857143e-05 0.0 1.1354352678571428e-05 0.0 1.1354910714285713e-05 1.5 1.1359375e-05 1.5 1.1359933035714285e-05 0.0 1.137220982142857e-05 0.0 1.1372767857142857e-05 1.5 1.1377232142857142e-05 1.5 1.1377790178571427e-05 0.0 1.1390066964285714e-05 0.0 1.1390624999999999e-05 1.5 1.1395089285714285e-05 1.5 1.1395647321428571e-05 0.0 1.1407924107142856e-05 0.0 1.1408482142857141e-05 1.5 1.1412946428571427e-05 1.5 1.1413504464285714e-05 0.0 1.1425781249999999e-05 0.0 1.1426339285714285e-05 1.5 1.1430803571428571e-05 1.5 1.1431361607142856e-05 0.0 1.1443638392857143e-05 0.0 1.1444196428571428e-05 1.5 1.1448660714285713e-05 1.5 1.1449218749999998e-05 0.0 1.1461495535714285e-05 0.0 1.146205357142857e-05 1.5 1.1466517857142856e-05 1.5 1.1467075892857142e-05 0.0 1.1479352678571427e-05 0.0 1.1479910714285714e-05 1.5 1.1484375e-05 1.5 1.1484933035714285e-05 0.0 1.1497209821428571e-05 0.0 1.1497767857142856e-05 1.5 1.1502232142857142e-05 1.5 1.1502790178571427e-05 0.0 1.1515066964285714e-05 0.0 1.1515624999999999e-05 1.5 1.1520089285714284e-05 1.5 1.1520647321428571e-05 0.0 1.1532924107142856e-05 0.0 1.1533482142857143e-05 1.5 1.1537946428571428e-05 1.5 1.1538504464285713e-05 0.0 1.155078125e-05 0.0 1.1551339285714285e-05 1.5 1.155580357142857e-05 1.5 1.1556361607142856e-05 0.0 1.1568638392857142e-05 0.0 1.1569196428571427e-05 1.5 1.1573660714285713e-05 1.5 1.157421875e-05 0.0 1.1586495535714285e-05 0.0 1.1587053571428571e-05 1.5 1.1591517857142857e-05 1.5 1.1592075892857142e-05 0.0 1.1604352678571427e-05 0.0 1.1604910714285714e-05 1.5 1.1609375e-05 1.5 1.1609933035714284e-05 0.0 1.1622209821428571e-05 0.0 1.1622767857142856e-05 1.5 1.1627232142857142e-05 1.5 1.1627790178571428e-05 0.0 1.1640066964285713e-05 0.0 1.1640624999999998e-05 1.5 1.1645089285714286e-05 1.5 1.164564732142857e-05 0.0 1.1657924107142856e-05 0.0 1.1658482142857142e-05 1.5 1.1662946428571428e-05 1.5 1.1663504464285713e-05 0.0 1.167578125e-05 0.0 1.1676339285714285e-05 1.5 1.168080357142857e-05 1.5 1.1681361607142857e-05 0.0 1.1693638392857142e-05 0.0 1.1694196428571427e-05 1.5 1.1698660714285714e-05 1.5 1.169921875e-05 0.0 1.1711495535714284e-05 0.0 1.1712053571428571e-05 1.5 1.1716517857142857e-05 1.5 1.1717075892857142e-05 0.0 1.1729352678571428e-05 0.0 1.1729910714285713e-05 1.5 1.1734374999999999e-05 1.5 1.1734933035714286e-05 0.0 1.174720982142857e-05 0.0 1.1747767857142856e-05 1.5 1.1752232142857141e-05 1.5 1.1752790178571428e-05 0.0 1.1765066964285713e-05 0.0 1.1765625e-05 1.5 1.1770089285714285e-05 1.5 1.177064732142857e-05 0.0 1.1782924107142857e-05 0.0 1.1783482142857142e-05 1.5 1.1787946428571428e-05 1.5 1.1788504464285713e-05 0.0 1.180078125e-05 0.0 1.1801339285714284e-05 1.5 1.180580357142857e-05 1.5 1.1806361607142857e-05 0.0 1.1818638392857142e-05 0.0 1.1819196428571428e-05 1.5 1.1823660714285714e-05 1.5 1.1824218749999999e-05 0.0 1.1836495535714286e-05 0.0 1.183705357142857e-05 1.5 1.1841517857142856e-05 1.5 1.1842075892857141e-05 0.0 1.1854352678571428e-05 0.0 1.1854910714285713e-05 1.5 1.1859374999999999e-05 1.5 1.1859933035714285e-05 0.0 1.187220982142857e-05 0.0 1.1872767857142857e-05 1.5 1.1877232142857143e-05 1.5 1.1877790178571428e-05 0.0 1.1890066964285714e-05 0.0 1.1890625e-05 1.5 1.1895089285714285e-05 1.5 1.189564732142857e-05 0.0 1.1907924107142857e-05 0.0 1.1908482142857142e-05 1.5 1.1912946428571427e-05 1.5 1.1913504464285714e-05 0.0 1.1925781249999999e-05 0.0 1.1926339285714286e-05 1.5 1.1930803571428571e-05 1.5 1.1931361607142856e-05 0.0 1.1943638392857141e-05 0.0 1.1944196428571428e-05 1.5 1.1948660714285714e-05 1.5 1.1949218749999999e-05 0.0 1.1961495535714285e-05 0.0 1.196205357142857e-05 1.5 1.1966517857142856e-05 1.5 1.1967075892857143e-05 0.0 1.1979352678571428e-05 0.0 1.1979910714285713e-05 1.5 1.1984375e-05 1.5 1.1984933035714285e-05 0.0 1.199720982142857e-05 0.0 1.1997767857142857e-05 1.5 1.2002232142857142e-05 1.5 1.2002790178571427e-05 0.0 1.2015066964285714e-05 0.0 1.2015624999999999e-05 1.5 1.2020089285714285e-05 1.5 1.2020647321428571e-05 0.0 1.2032924107142856e-05 0.0 1.2033482142857141e-05 1.5 1.2037946428571427e-05 1.5 1.2038504464285714e-05 0.0 1.2050781249999999e-05 0.0 1.2051339285714285e-05 1.5 1.2055803571428571e-05 1.5 1.2056361607142856e-05 0.0 1.2068638392857143e-05 0.0 1.2069196428571428e-05 1.5 1.2073660714285713e-05 1.5 1.2074218749999998e-05 0.0 1.2086495535714285e-05 0.0 1.208705357142857e-05 1.5 1.2091517857142856e-05 1.5 1.2092075892857142e-05 0.0 1.2104352678571427e-05 0.0 1.2104910714285714e-05 1.5 1.2109375e-05 1.5 1.2109933035714285e-05 0.0 1.2122209821428571e-05 0.0 1.2122767857142856e-05 1.5 1.2127232142857142e-05 1.5 1.2127790178571427e-05 0.0 1.2140066964285714e-05 0.0 1.2140624999999999e-05 1.5 1.2145089285714284e-05 1.5 1.2145647321428571e-05 0.0 1.2157924107142856e-05 0.0 1.2158482142857143e-05 1.5 1.2162946428571428e-05 1.5 1.2163504464285713e-05 0.0 1.217578125e-05 0.0 1.2176339285714285e-05 1.5 1.218080357142857e-05 1.5 1.2181361607142856e-05 0.0 1.2193638392857142e-05 0.0 1.2194196428571427e-05 1.5 1.2198660714285713e-05 1.5 1.219921875e-05 0.0 1.2211495535714285e-05 0.0 1.2212053571428571e-05 1.5 1.2216517857142857e-05 1.5 1.2217075892857142e-05 0.0 1.2229352678571427e-05 0.0 1.2229910714285714e-05 1.5 1.2234375e-05 1.5 1.2234933035714284e-05 0.0 1.2247209821428571e-05 0.0 1.2247767857142856e-05 1.5 1.2252232142857142e-05 1.5 1.2252790178571428e-05 0.0 1.2265066964285713e-05 0.0 1.2265624999999998e-05 1.5 1.2270089285714286e-05 1.5 1.227064732142857e-05 0.0 1.2282924107142856e-05 0.0 1.2283482142857142e-05 1.5 1.2287946428571428e-05 1.5 1.2288504464285713e-05 0.0 1.230078125e-05 0.0 1.2301339285714285e-05 1.5 1.230580357142857e-05 1.5 1.2306361607142857e-05 0.0 1.2318638392857142e-05 0.0 1.2319196428571427e-05 1.5 1.2323660714285714e-05 1.5 1.232421875e-05 0.0 1.2336495535714284e-05 0.0 1.2337053571428571e-05 1.5 1.2341517857142857e-05 1.5 1.2342075892857142e-05 0.0 1.2354352678571428e-05 0.0 1.2354910714285713e-05 1.5 1.2359374999999999e-05 1.5 1.2359933035714286e-05 0.0 1.237220982142857e-05 0.0 1.2372767857142856e-05 1.5 1.2377232142857141e-05 1.5 1.2377790178571428e-05 0.0 1.2390066964285713e-05 0.0 1.2390625e-05 1.5 1.2395089285714285e-05 1.5 1.239564732142857e-05 0.0 1.2407924107142857e-05 0.0 1.2408482142857142e-05 1.5 1.2412946428571428e-05 1.5 1.2413504464285713e-05 0.0 1.242578125e-05 0.0 1.2426339285714284e-05 1.5 1.243080357142857e-05 1.5 1.2431361607142857e-05 0.0 1.2443638392857142e-05 0.0 1.2444196428571428e-05 1.5 1.2448660714285714e-05 1.5 1.2449218749999999e-05 0.0 1.2461495535714286e-05 0.0 1.246205357142857e-05 1.5 1.2466517857142856e-05 1.5 1.2467075892857141e-05 0.0 1.2479352678571428e-05 0.0 1.2479910714285713e-05 1.5 1.2484374999999999e-05 1.5 1.2484933035714285e-05 0.0 1.249720982142857e-05 0.0 1.2497767857142857e-05 1.5 1.2502232142857143e-05 1.5 1.2502790178571428e-05 0.0 1.2515066964285714e-05 0.0 1.2515625e-05 1.5 1.2520089285714285e-05 1.5 1.252064732142857e-05 0.0 1.2532924107142857e-05 0.0 1.2533482142857142e-05 1.5 1.2537946428571427e-05 1.5 1.2538504464285714e-05 0.0 1.2550781249999999e-05 0.0 1.2551339285714286e-05 1.5 1.2555803571428571e-05 1.5 1.2556361607142856e-05 0.0 1.2568638392857141e-05 0.0 1.2569196428571428e-05 1.5 1.2573660714285714e-05 1.5 1.2574218749999999e-05 0.0 1.2586495535714285e-05 0.0 1.258705357142857e-05 1.5 1.2591517857142856e-05 1.5 1.2592075892857143e-05 0.0 1.2604352678571428e-05 0.0 1.2604910714285713e-05 1.5 1.2609375e-05 1.5 1.2609933035714285e-05 0.0 1.262220982142857e-05 0.0 1.2622767857142857e-05 1.5 1.2627232142857142e-05 1.5 1.2627790178571427e-05 0.0 1.2640066964285714e-05 0.0 1.2640624999999999e-05 1.5 1.2645089285714285e-05 1.5 1.2645647321428571e-05 0.0 1.2657924107142856e-05 0.0 1.2658482142857141e-05 1.5 1.2662946428571427e-05 1.5 1.2663504464285714e-05 0.0 1.2675781249999999e-05 0.0 1.2676339285714285e-05 1.5 1.2680803571428571e-05 1.5 1.2681361607142856e-05 0.0 1.2693638392857143e-05 0.0 1.2694196428571428e-05 1.5 1.2698660714285713e-05 1.5 1.269921875e-05 0.0 1.2711495535714285e-05 0.0 1.271205357142857e-05 1.5 1.2716517857142856e-05 1.5 1.2717075892857142e-05 0.0 1.2729352678571427e-05 0.0 1.2729910714285714e-05 1.5 1.2734375e-05 1.5 1.2734933035714285e-05 0.0 1.2747209821428571e-05 0.0 1.2747767857142856e-05 1.5 1.2752232142857142e-05 1.5 1.2752790178571427e-05 0.0 1.2765066964285714e-05 0.0 1.2765624999999999e-05 1.5 1.2770089285714284e-05 1.5 1.2770647321428571e-05 0.0 1.2782924107142856e-05 0.0 1.2783482142857143e-05 1.5 1.2787946428571428e-05 1.5 1.2788504464285713e-05 0.0 1.280078125e-05 0.0 1.2801339285714285e-05 1.5 1.280580357142857e-05 1.5 1.2806361607142856e-05 0.0 1.2818638392857142e-05 0.0 1.2819196428571427e-05 1.5 1.2823660714285713e-05 1.5 1.282421875e-05 0.0 1.2836495535714285e-05 0.0 1.2837053571428571e-05 1.5 1.2841517857142857e-05 1.5 1.2842075892857142e-05 0.0 1.2854352678571427e-05 0.0 1.2854910714285714e-05 1.5 1.2859375e-05 1.5 1.2859933035714284e-05 0.0 1.2872209821428571e-05 0.0 1.2872767857142856e-05 1.5 1.2877232142857141e-05 1.5 1.2877790178571428e-05 0.0 1.2890066964285713e-05 0.0 1.2890624999999998e-05 1.5 1.2895089285714286e-05 1.5 1.289564732142857e-05 0.0 1.2907924107142855e-05 0.0 1.2908482142857142e-05 1.5 1.2912946428571428e-05 1.5 1.2913504464285713e-05 0.0 1.292578125e-05 0.0 1.2926339285714285e-05 1.5 1.293080357142857e-05 1.5 1.2931361607142857e-05 0.0 1.2943638392857142e-05 0.0 1.2944196428571427e-05 1.5 1.2948660714285714e-05 1.5 1.294921875e-05 0.0 1.2961495535714284e-05 0.0 1.2962053571428571e-05 1.5 1.2967075892857142e-05 1.5 1.2967633928571428e-05 0.0 1.2978794642857141e-05 0.0 1.2979352678571428e-05 1.5 1.2984933035714286e-05 1.5 1.298549107142857e-05 0.0 1.2996651785714285e-05 0.0 1.299720982142857e-05 1.5 1.3002790178571428e-05 1.5 1.3003348214285713e-05 0.0 1.3014508928571428e-05 0.0 1.3015066964285713e-05 1.5 1.302064732142857e-05 1.5 1.3021205357142857e-05 0.0 1.303236607142857e-05 0.0 1.3032924107142857e-05 1.5 1.3038504464285713e-05 1.5 1.30390625e-05 0.0 1.3050223214285714e-05 0.0 1.305078125e-05 1.5 1.3056361607142857e-05 1.5 1.3056919642857142e-05 0.0 1.3068080357142856e-05 0.0 1.3068638392857141e-05 1.5 1.3074218749999999e-05 1.5 1.3074776785714284e-05 0.0 1.3085937499999999e-05 0.0 1.3086495535714286e-05 1.5 1.3092075892857141e-05 1.5 1.3092633928571428e-05 0.0 1.3103794642857141e-05 0.0 1.3104352678571428e-05 1.5 1.3109933035714285e-05 1.5 1.311049107142857e-05 0.0 1.3121651785714285e-05 0.0 1.312220982142857e-05 1.5 1.3127790178571428e-05 1.5 1.3128348214285713e-05 0.0 1.3139508928571427e-05 0.0 1.3140066964285714e-05 1.5 1.314564732142857e-05 1.5 1.3146205357142857e-05 0.0 1.315736607142857e-05 0.0 1.3157924107142856e-05 1.5 1.3163504464285714e-05 1.5 1.3164062499999999e-05 0.0 1.3175223214285714e-05 0.0 1.3175781249999999e-05 1.5 1.3181361607142856e-05 1.5 1.3181919642857141e-05 0.0 1.3193080357142856e-05 0.0 1.3193638392857141e-05 1.5 1.3199218749999999e-05 1.5 1.3199776785714285e-05 0.0 1.3210937499999998e-05 0.0 1.3211495535714285e-05 1.5 1.3217075892857143e-05 1.5 1.3217633928571428e-05 0.0 1.3228794642857142e-05 0.0 1.3229352678571427e-05 1.5 1.3234933035714285e-05 1.5 1.323549107142857e-05 0.0 1.3246651785714285e-05 0.0 1.324720982142857e-05 1.5 1.3252790178571427e-05 1.5 1.3253348214285714e-05 0.0 1.3264508928571427e-05 0.0 1.3265066964285714e-05 1.5 1.3270647321428571e-05 1.5 1.3271205357142856e-05 0.0 1.3282366071428571e-05 0.0 1.3282924107142856e-05 1.5 1.3288504464285714e-05 1.5 1.3289062499999999e-05 0.0 1.3300223214285713e-05 0.0 1.3300781249999998e-05 1.5 1.3306361607142856e-05 1.5 1.3306919642857143e-05 0.0 1.3318080357142856e-05 0.0 1.3318638392857142e-05 1.5 1.332421875e-05 1.5 1.3324776785714285e-05 0.0 1.33359375e-05 0.0 1.3336495535714285e-05 1.5 1.3342075892857142e-05 1.5 1.3342633928571427e-05 0.0 1.3353794642857142e-05 0.0 1.3354352678571427e-05 1.5 1.3359933035714285e-05 1.5 1.3360491071428571e-05 0.0 1.3371651785714284e-05 0.0 1.3372209821428571e-05 1.5 1.3378348214285714e-05 1.5 1.3378906249999999e-05 0.0 1.3388950892857142e-05 0.0 1.3389508928571428e-05 1.5 1.3396205357142856e-05 1.5 1.3396763392857143e-05 0.0 1.3406808035714284e-05 0.0 1.340736607142857e-05 1.5 1.3414062499999998e-05 1.5 1.3414620535714285e-05 0.0 1.3424665178571428e-05 0.0 1.3425223214285713e-05 1.5 1.3431919642857142e-05 1.5 1.3432477678571427e-05 0.0 1.344252232142857e-05 0.0 1.3443080357142855e-05 1.5 1.3449776785714285e-05 1.5 1.345033482142857e-05 0.0 1.3460379464285713e-05 0.0 1.34609375e-05 1.5 1.3467633928571427e-05 1.5 1.3468191964285714e-05 0.0 1.3478236607142857e-05 0.0 1.3478794642857142e-05 1.5 1.3485491071428571e-05 1.5 1.3486049107142856e-05 0.0 1.3496093749999999e-05 0.0 1.3496651785714284e-05 1.5 1.3503348214285713e-05 1.5 1.3503906249999998e-05 0.0 1.3513950892857141e-05 0.0 1.3514508928571428e-05 1.5 1.3521205357142856e-05 1.5 1.3521763392857142e-05 0.0 1.3531808035714285e-05 0.0 1.353236607142857e-05 1.5 1.35390625e-05 1.5 1.3539620535714285e-05 0.0 1.3549665178571428e-05 0.0 1.3550223214285713e-05 1.5 1.3556919642857142e-05 1.5 1.3557477678571427e-05 0.0 1.356752232142857e-05 0.0 1.3568080357142857e-05 1.5 1.3574776785714284e-05 1.5 1.3575334821428571e-05 0.0 1.3585379464285714e-05 0.0 1.3585937499999999e-05 1.5 1.3592633928571428e-05 1.5 1.3593191964285713e-05 0.0 1.3603236607142856e-05 0.0 1.3603794642857141e-05 1.5 1.361049107142857e-05 1.5 1.3611049107142856e-05 0.0 1.3621093749999999e-05 0.0 1.3621651785714285e-05 1.5 1.3628348214285713e-05 1.5 1.362890625e-05 0.0 1.3638950892857143e-05 0.0 1.3639508928571428e-05 1.5 1.3646205357142857e-05 1.5 1.3646763392857142e-05 0.0 1.3656808035714285e-05 0.0 1.365736607142857e-05 1.5 1.36640625e-05 1.5 1.3664620535714284e-05 0.0 1.3674665178571427e-05 0.0 1.3675223214285714e-05 1.5 1.3681919642857142e-05 1.5 1.3682477678571428e-05 0.0 1.369252232142857e-05 0.0 1.3693080357142856e-05 1.5 1.3699776785714284e-05 1.5 1.370033482142857e-05 0.0 1.3710379464285714e-05 0.0 1.3710937499999999e-05 1.5 1.3717633928571428e-05 1.5 1.3718191964285713e-05 0.0 1.3727678571428571e-05 0.0 1.3728236607142856e-05 1.5 1.3736049107142857e-05 1.5 1.3736607142857142e-05 0.0 1.3745535714285713e-05 0.0 1.3746093749999998e-05 1.5 1.375390625e-05 1.5 1.3754464285714284e-05 0.0 1.3763392857142856e-05 0.0 1.3763950892857142e-05 1.5 1.3771763392857142e-05 1.5 1.3772321428571428e-05 0.0 1.378125e-05 0.0 1.3781808035714285e-05 1.5 1.3789620535714284e-05 1.5 1.379017857142857e-05 0.0 1.3799107142857142e-05 0.0 1.3799665178571427e-05 1.5 1.3807477678571428e-05 1.5 1.3808035714285713e-05 0.0 1.3816964285714284e-05 0.0 1.3817522321428571e-05 1.5 1.382533482142857e-05 1.5 1.3825892857142855e-05 0.0 1.3834821428571428e-05 0.0 1.3835379464285713e-05 1.5 1.3843191964285713e-05 1.5 1.384375e-05 0.0 1.385267857142857e-05 0.0 1.3853236607142856e-05 1.5 1.3861049107142857e-05 1.5 1.3861607142857142e-05 0.0 1.3870535714285713e-05 0.0 1.387109375e-05 1.5 1.3878906249999999e-05 1.5 1.3879464285714284e-05 0.0 1.3888392857142857e-05 0.0 1.3888950892857142e-05 1.5 1.3896763392857141e-05 1.5 1.3897321428571428e-05 0.0 1.390625e-05 0.0 1.3906808035714284e-05 1.5 1.3914620535714285e-05 1.5 1.391517857142857e-05 0.0 1.3924107142857142e-05 0.0 1.3924665178571428e-05 1.5 1.3932477678571428e-05 1.5 1.3933035714285713e-05 0.0 1.3941964285714286e-05 0.0 1.394252232142857e-05 1.5 1.395033482142857e-05 1.5 1.3950892857142857e-05 0.0 1.3959821428571428e-05 0.0 1.3960379464285713e-05 1.5 1.3968191964285714e-05 1.5 1.3968749999999999e-05 0.0 1.397767857142857e-05 0.0 1.3978236607142857e-05 1.5 1.3986049107142856e-05 1.5 1.3986607142857141e-05 0.0 1.3995535714285713e-05 0.0 1.399609375e-05 1.5 1.4003906249999999e-05 1.5 1.4004464285714285e-05 0.0 1.4013392857142857e-05 0.0 1.4013950892857142e-05 1.5 1.4021763392857143e-05 1.5 1.4022321428571428e-05 0.0 1.4031249999999999e-05 0.0 1.4031808035714284e-05 1.5 1.4039620535714285e-05 1.5 1.404017857142857e-05 0.0 1.4048549107142856e-05 0.0 1.4049107142857141e-05 1.5 1.4058035714285714e-05 1.5 1.4058593749999999e-05 0.0 1.4066406249999998e-05 0.0 1.4066964285714285e-05 1.5 1.4075892857142856e-05 1.5 1.4076450892857141e-05 0.0 1.4084263392857142e-05 0.0 1.4084821428571428e-05 1.5 1.4093749999999999e-05 1.5 1.4094308035714285e-05 0.0 1.4102120535714285e-05 0.0 1.410267857142857e-05 1.5 1.4111607142857141e-05 1.5 1.4112165178571428e-05 0.0 1.4119977678571427e-05 0.0 1.4120535714285714e-05 1.5 1.4129464285714285e-05 1.5 1.413002232142857e-05 0.0 1.4137834821428571e-05 0.0 1.4138392857142856e-05 1.5 1.4147321428571427e-05 1.5 1.4147879464285714e-05 0.0 1.4155691964285713e-05 0.0 1.4156249999999999e-05 1.5 1.416517857142857e-05 1.5 1.4165736607142856e-05 0.0 1.4173549107142856e-05 0.0 1.4174107142857143e-05 1.5 1.4183035714285714e-05 1.5 1.4183593749999999e-05 0.0 1.419140625e-05 0.0 1.4191964285714285e-05 1.5 1.4200892857142856e-05 1.5 1.4201450892857141e-05 0.0 1.4209263392857142e-05 0.0 1.4209821428571427e-05 1.5 1.4218749999999998e-05 1.5 1.4219308035714285e-05 0.0 1.4227120535714284e-05 0.0 1.4227678571428571e-05 1.5 1.4236607142857142e-05 1.5 1.4237165178571427e-05 0.0 1.4244977678571427e-05 0.0 1.4245535714285714e-05 1.5 1.4254464285714285e-05 1.5 1.425502232142857e-05 0.0 1.426283482142857e-05 0.0 1.4263392857142856e-05 1.5 1.4272321428571427e-05 1.5 1.4272879464285714e-05 0.0 1.4280691964285713e-05 0.0 1.4281249999999998e-05 1.5 1.4290178571428571e-05 1.5 1.4290736607142856e-05 0.0 1.4298549107142855e-05 0.0 1.4299107142857142e-05 1.5 1.4308035714285713e-05 1.5 1.4308593749999998e-05 0.0 1.431640625e-05 0.0 1.4316964285714284e-05 1.5 1.4325892857142856e-05 1.5 1.4326450892857142e-05 0.0 1.4334263392857142e-05 0.0 1.4334821428571427e-05 1.5 1.434375e-05 1.5 1.4344308035714285e-05 0.0 1.4352120535714284e-05 0.0 1.435267857142857e-05 1.5 1.4361607142857142e-05 1.5 1.4362165178571427e-05 0.0 1.4369419642857141e-05 0.0 1.4369977678571428e-05 1.5 1.4380022321428571e-05 1.5 1.4380580357142856e-05 0.0 1.4387276785714285e-05 0.0 1.438783482142857e-05 1.5 1.4397879464285713e-05 1.5 1.4398437499999998e-05 0.0 1.4405133928571428e-05 0.0 1.4405691964285713e-05 1.5 1.4415736607142856e-05 1.5 1.4416294642857142e-05 0.0 1.442299107142857e-05 0.0 1.4423549107142857e-05 1.5 1.443359375e-05 1.5 1.4434151785714285e-05 0.0 1.4440848214285714e-05 0.0 1.4441406249999999e-05 1.5 1.4451450892857142e-05 1.5 1.4452008928571427e-05 0.0 1.4458705357142856e-05 0.0 1.4459263392857141e-05 1.5 1.4469308035714284e-05 1.5 1.4469866071428571e-05 0.0 1.4476562499999999e-05 0.0 1.4477120535714285e-05 1.5 1.4487165178571427e-05 1.5 1.4487723214285713e-05 0.0 1.4494419642857141e-05 0.0 1.4494977678571428e-05 1.5 1.450502232142857e-05 1.5 1.4505580357142856e-05 0.0 1.4512276785714285e-05 0.0 1.451283482142857e-05 1.5 1.4522879464285713e-05 1.5 1.4523437499999998e-05 0.0 1.4530133928571427e-05 0.0 1.4530691964285714e-05 1.5 1.4540736607142855e-05 1.5 1.4541294642857142e-05 0.0 1.454799107142857e-05 0.0 1.4548549107142856e-05 1.5 1.455859375e-05 1.5 1.4559151785714284e-05 0.0 1.4565848214285714e-05 0.0 1.4566406249999999e-05 1.5 1.4576450892857142e-05 1.5 1.4577008928571427e-05 0.0 1.4583705357142856e-05 0.0 1.4584263392857141e-05 1.5 1.4594308035714284e-05 1.5 1.459486607142857e-05 0.0 1.4601562499999998e-05 0.0 1.4602120535714285e-05 1.5 1.4612165178571428e-05 1.5 1.4612723214285713e-05 0.0 1.4619419642857142e-05 0.0 1.4619977678571427e-05 1.5 1.463002232142857e-05 1.5 1.4630580357142855e-05 0.0 1.4637276785714285e-05 0.0 1.463783482142857e-05 1.5 1.4647879464285713e-05 1.5 1.46484375e-05 0.0 1.4655133928571427e-05 0.0 1.4655691964285714e-05 1.5 1.4665736607142857e-05 1.5 1.4666294642857142e-05 0.0 1.4672991071428571e-05 0.0 1.4673549107142856e-05 1.5 1.4683593749999999e-05 1.5 1.4684151785714284e-05 0.0 1.4690848214285713e-05 0.0 1.4691406249999998e-05 1.5 1.4701450892857141e-05 1.5 1.4702008928571428e-05 0.0 1.4708705357142856e-05 0.0 1.4709263392857142e-05 1.5 1.471986607142857e-05 1.5 1.4720424107142856e-05 0.0 1.4726004464285713e-05 0.0 1.47265625e-05 1.5 1.4737723214285713e-05 1.5 1.473828125e-05 0.0 1.4743861607142857e-05 0.0 1.4744419642857142e-05 1.5 1.4755580357142857e-05 1.5 1.4756138392857142e-05 0.0 1.476171875e-05 0.0 1.4762276785714284e-05 1.5 1.4773437499999999e-05 1.5 1.4773995535714284e-05 0.0 1.4779575892857142e-05 0.0 1.4780133928571428e-05 1.5 1.4791294642857141e-05 1.5 1.4791852678571428e-05 0.0 1.4797433035714284e-05 0.0 1.479799107142857e-05 1.5 1.4809151785714285e-05 1.5 1.480970982142857e-05 0.0 1.4815290178571428e-05 0.0 1.4815848214285713e-05 1.5 1.4827008928571428e-05 1.5 1.4827566964285713e-05 0.0 1.483314732142857e-05 0.0 1.4833705357142855e-05 1.5 1.484486607142857e-05 1.5 1.4845424107142857e-05 0.0 1.4851004464285713e-05 0.0 1.48515625e-05 1.5 1.4862723214285712e-05 1.5 1.486328125e-05 0.0 1.4868861607142857e-05 0.0 1.4869419642857142e-05 1.5 1.4880580357142856e-05 1.5 1.4881138392857141e-05 0.0 1.4886718749999999e-05 0.0 1.4887276785714284e-05 1.5 1.4898437499999999e-05 1.5 1.4898995535714284e-05 0.0 1.4904575892857141e-05 0.0 1.4905133928571428e-05 1.5 1.4916294642857141e-05 1.5 1.4916852678571428e-05 0.0 1.4922433035714285e-05 0.0 1.492299107142857e-05 1.5 1.4934151785714285e-05 1.5 1.493470982142857e-05 0.0 1.4940290178571428e-05 0.0 1.4940848214285713e-05 1.5 1.4952008928571427e-05 1.5 1.4952566964285712e-05 0.0 1.495814732142857e-05 0.0 1.4958705357142857e-05 1.5 1.496986607142857e-05 1.5 1.4970424107142857e-05 0.0 1.4976004464285714e-05 0.0 1.4976562499999999e-05 1.5 1.4987723214285714e-05 1.5 1.4988281249999999e-05 0.0 1.4993861607142856e-05 0.0 1.4994419642857141e-05 1.5 1.5005580357142856e-05 1.5 1.5006138392857141e-05 0.0 1.5011718749999999e-05 0.0 1.5012276785714285e-05 1.5 1.5023437499999998e-05 1.5 1.5023995535714285e-05 0.0 1.5029575892857143e-05 0.0 1.5030133928571428e-05 1.5 1.5041294642857142e-05 1.5 1.5041852678571427e-05 0.0 1.5047433035714285e-05 0.0 1.504799107142857e-05 1.5 1.5059151785714285e-05 1.5 1.505970982142857e-05 0.0 1.5065290178571427e-05 0.0 1.5065848214285714e-05 1.5 1.5077008928571427e-05 1.5 1.5077566964285714e-05 0.0 1.508314732142857e-05 0.0 1.5083705357142856e-05 1.5 1.5094866071428571e-05 1.5 1.5095424107142856e-05 0.0 1.5101004464285714e-05 0.0 1.5101562499999999e-05 1.5 1.5112723214285713e-05 1.5 1.5113281249999998e-05 0.0 1.5118861607142856e-05 0.0 1.5119419642857141e-05 1.5 1.5131138392857142e-05 1.5 1.5131696428571428e-05 0.0 1.5136160714285713e-05 0.0 1.5136718749999998e-05 1.5 1.5148995535714285e-05 1.5 1.514955357142857e-05 0.0 1.5154017857142855e-05 0.0 1.5154575892857142e-05 1.5 1.5166852678571427e-05 1.5 1.5167410714285714e-05 0.0 1.5171875e-05 0.0 1.5172433035714285e-05 1.5 1.5184709821428571e-05 1.5 1.5185267857142856e-05 0.0 1.5189732142857142e-05 0.0 1.5190290178571427e-05 1.5 1.5202566964285713e-05 1.5 1.5203124999999999e-05 0.0 1.5207589285714284e-05 0.0 1.5208147321428571e-05 1.5 1.5220424107142856e-05 1.5 1.5220982142857143e-05 0.0 1.5225446428571428e-05 0.0 1.5226004464285713e-05 1.5 1.5238281249999998e-05 1.5 1.5238839285714285e-05 0.0 1.524330357142857e-05 0.0 1.5243861607142856e-05 1.5 1.5256138392857142e-05 1.5 1.5256696428571427e-05 0.0 1.5261160714285713e-05 0.0 1.526171875e-05 1.5 1.5273995535714284e-05 1.5 1.527455357142857e-05 0.0 1.5279017857142855e-05 0.0 1.5279575892857142e-05 1.5 1.5291852678571427e-05 1.5 1.5292410714285714e-05 0.0 1.5296874999999997e-05 0.0 1.5297433035714284e-05 1.5 1.530970982142857e-05 1.5 1.5310267857142856e-05 0.0 1.5314732142857143e-05 0.0 1.5315290178571427e-05 1.5 1.5327566964285715e-05 1.5 1.5328124999999998e-05 0.0 1.5332589285714285e-05 0.0 1.533314732142857e-05 1.5 1.5345424107142857e-05 1.5 1.534598214285714e-05 0.0 1.5350446428571428e-05 0.0 1.5351004464285715e-05 1.5 1.536328125e-05 1.5 1.5363839285714286e-05 0.0 1.536830357142857e-05 0.0 1.5368861607142857e-05 1.5 1.5381138392857142e-05 1.5 1.538169642857143e-05 0.0 1.5386160714285712e-05 0.0 1.538671875e-05 1.5 1.5398995535714284e-05 1.5 1.539955357142857e-05 0.0 1.5404017857142855e-05 0.0 1.540457589285714e-05 1.5 1.5416852678571426e-05 1.5 1.5417410714285713e-05 0.0 1.5421875e-05 0.0 1.5422433035714284e-05 1.5 1.543470982142857e-05 1.5 1.5435267857142856e-05 0.0 1.5439732142857143e-05 0.0 1.5440290178571426e-05 1.5 1.5452566964285714e-05 1.5 1.5453124999999998e-05 0.0 1.5457589285714285e-05 0.0 1.5458147321428572e-05 1.5 1.5470424107142857e-05 1.5 1.547098214285714e-05 0.0 1.5475446428571427e-05 0.0 1.5476004464285714e-05 1.5 1.548828125e-05 1.5 1.5488839285714286e-05 0.0 1.549330357142857e-05 0.0 1.5493861607142857e-05 1.5 1.550613839285714e-05 1.5 1.5506696428571428e-05 0.0 1.5511160714285712e-05 0.0 1.551171875e-05 1.5 1.5523995535714284e-05 1.5 1.552455357142857e-05 0.0 1.5529017857142854e-05 0.0 1.552957589285714e-05 1.5 1.5541852678571426e-05 1.5 1.5542410714285713e-05 0.0 1.5546875e-05 0.0 1.5547433035714283e-05 1.5 1.5559709821428572e-05 1.5 1.5560267857142855e-05 0.0 1.5564732142857142e-05 0.0 1.5565290178571426e-05 1.5 1.5577566964285714e-05 1.5 1.5578124999999997e-05 0.0 1.5582589285714285e-05 0.0 1.558314732142857e-05 1.5 1.5595424107142856e-05 1.5 1.5595982142857143e-05 0.0 1.5600446428571427e-05 0.0 1.5601004464285714e-05 1.5 1.561328125e-05 1.5 1.5613839285714286e-05 0.0 1.561830357142857e-05 0.0 1.5618861607142856e-05 1.5 1.563113839285714e-05 1.5 1.5631696428571428e-05 0.0 1.5636160714285712e-05 0.0 1.563671875e-05 1.5 1.5648995535714283e-05 1.5 1.564955357142857e-05 0.0 1.5654017857142857e-05 0.0 1.565457589285714e-05 1.5 1.566685267857143e-05 1.5 1.5667410714285712e-05 0.0 1.5671875e-05 0.0 1.5672433035714283e-05 1.5 1.568470982142857e-05 1.5 1.5685267857142855e-05 0.0 1.5689732142857142e-05 0.0 1.569029017857143e-05 1.5 1.5702566964285714e-05 1.5 1.5703125e-05 0.0 1.5707589285714284e-05 0.0 1.570814732142857e-05 1.5 1.5720424107142856e-05 1.5 1.5720982142857143e-05 0.0 1.5725446428571427e-05 0.0 1.5726004464285713e-05 1.5 1.573828125e-05 1.5 1.5738839285714285e-05 0.0 1.574330357142857e-05 0.0 1.5743861607142856e-05 1.5 1.575613839285714e-05 1.5 1.5756696428571427e-05 0.0 1.5761160714285715e-05 0.0 1.5761718749999998e-05 1.5 1.5773995535714283e-05 1.5 1.577455357142857e-05 0.0 1.5779017857142857e-05 0.0 1.577957589285714e-05 1.5 1.579185267857143e-05 1.5 1.5792410714285712e-05 0.0 1.5796875e-05 0.0 1.5797433035714286e-05 1.5 1.580970982142857e-05 1.5 1.5810267857142854e-05 0.0 1.5814732142857142e-05 0.0 1.581529017857143e-05 1.5 1.5827566964285713e-05 1.5 1.5828125e-05 0.0 1.5832589285714284e-05 0.0 1.583314732142857e-05 1.5 1.5845424107142856e-05 1.5 1.5845982142857143e-05 0.0 1.5850446428571426e-05 0.0 1.5851004464285713e-05 1.5 1.5863281249999998e-05 1.5 1.5863839285714285e-05 0.0 1.586830357142857e-05 0.0 1.5868861607142855e-05 1.5 1.588113839285714e-05 1.5 1.5881696428571427e-05 0.0 1.5886160714285714e-05 0.0 1.5886718749999998e-05 1.5 1.5898995535714286e-05 1.5 1.589955357142857e-05 0.0 1.5904017857142857e-05 0.0 1.590457589285714e-05 1.5 1.591685267857143e-05 1.5 1.5917410714285712e-05 0.0 1.5921875e-05 0.0 1.5922433035714286e-05 1.5 1.593470982142857e-05 1.5 1.5935267857142858e-05 0.0 1.593973214285714e-05 0.0 1.5940290178571428e-05 1.5 1.5952566964285713e-05 1.5 1.5953125e-05 0.0 1.5957589285714284e-05 0.0 1.595814732142857e-05 1.5 1.5970424107142855e-05 1.5 1.5970982142857142e-05 0.0 1.5975446428571426e-05 0.0 1.5976004464285713e-05 1.5 1.5988281249999998e-05 1.5 1.5988839285714284e-05 0.0 1.5993303571428572e-05 0.0 1.5993861607142855e-05 1.5 1.600613839285714e-05 1.5 1.6006696428571427e-05 0.0 1.6011160714285714e-05 0.0 1.6011718749999997e-05 1.5 1.6023995535714286e-05 1.5 1.602455357142857e-05 0.0 1.6029017857142856e-05 0.0 1.6029575892857143e-05 1.5 1.6041852678571428e-05 1.5 1.604241071428571e-05 0.0 1.6046875e-05 0.0 1.6047433035714285e-05 1.5 1.605970982142857e-05 1.5 1.6060267857142857e-05 0.0 1.606473214285714e-05 0.0 1.6065290178571428e-05 1.5 1.6077566964285713e-05 1.5 1.6078125e-05 0.0 1.6082589285714283e-05 0.0 1.608314732142857e-05 1.5 1.6095424107142855e-05 1.5 1.6095982142857142e-05 0.0 1.610044642857143e-05 0.0 1.6101004464285712e-05 1.5 1.6113281249999997e-05 1.5 1.6113839285714284e-05 0.0 1.611830357142857e-05 0.0 1.6118861607142855e-05 1.5 1.6131138392857143e-05 1.5 1.6131696428571426e-05 0.0 1.6136160714285714e-05 0.0 1.613671875e-05 1.5 1.6148995535714285e-05 1.5 1.614955357142857e-05 0.0 1.6154017857142856e-05 0.0 1.6154575892857143e-05 1.5 1.6166852678571428e-05 1.5 1.6167410714285714e-05 0.0 1.6171875e-05 0.0 1.6172433035714285e-05 1.5 1.618470982142857e-05 1.5 1.6185267857142857e-05 0.0 1.618973214285714e-05 0.0 1.6190290178571427e-05 1.5 1.6202566964285712e-05 1.5 1.6203125e-05 0.0 1.6207589285714283e-05 0.0 1.620814732142857e-05 1.5 1.6220424107142855e-05 1.5 1.622098214285714e-05 0.0 1.622544642857143e-05 0.0 1.6226004464285712e-05 1.5 1.623828125e-05 1.5 1.6238839285714284e-05 0.0 1.624330357142857e-05 0.0 1.6243861607142854e-05 1.5 1.6256138392857143e-05 1.5 1.6256696428571426e-05 0.0 1.6261160714285713e-05 0.0 1.626171875e-05 1.5 1.6273995535714285e-05 1.5 1.6274553571428572e-05 0.0 1.6279017857142856e-05 0.0 1.6279575892857142e-05 1.5 1.6291852678571427e-05 1.5 1.6292410714285714e-05 0.0 1.6296874999999998e-05 0.0 1.6297433035714285e-05 1.5 1.630970982142857e-05 1.5 1.6310267857142856e-05 0.0 1.631473214285714e-05 0.0 1.6315290178571427e-05 1.5 1.6327566964285712e-05 1.5 1.6328125e-05 0.0 1.6332589285714286e-05 0.0 1.633314732142857e-05 1.5 1.6345424107142854e-05 1.5 1.634598214285714e-05 0.0 1.635044642857143e-05 0.0 1.6351004464285712e-05 1.5 1.636328125e-05 1.5 1.6363839285714283e-05 0.0 1.636830357142857e-05 0.0 1.6368861607142857e-05 1.5 1.6381138392857142e-05 1.5 1.6381696428571426e-05 0.0 1.6386160714285713e-05 0.0 1.638671875e-05 1.5 1.6398995535714285e-05 1.5 1.639955357142857e-05 0.0 1.6404017857142855e-05 0.0 1.6404575892857142e-05 1.5 1.6416852678571427e-05 1.5 1.6417410714285714e-05 0.0 1.6421874999999998e-05 0.0 1.6422433035714284e-05 1.5 1.643470982142857e-05 1.5 1.6435267857142856e-05 0.0 1.643973214285714e-05 0.0 1.6440290178571427e-05 1.5 1.645256696428571e-05 1.5 1.6453125e-05 0.0 1.6457589285714286e-05 0.0 1.645814732142857e-05 1.5 1.6470424107142857e-05 1.5 1.647098214285714e-05 0.0 1.6475446428571428e-05 0.0 1.6476004464285715e-05 1.5 1.648828125e-05 1.5 1.6488839285714283e-05 0.0 1.649330357142857e-05 0.0 1.6493861607142857e-05 1.5 1.6506138392857142e-05 1.5 1.650669642857143e-05 0.0 1.6511160714285713e-05 0.0 1.651171875e-05 1.5 1.6523995535714284e-05 1.5 1.652455357142857e-05 0.0 1.6529017857142855e-05 0.0 1.6529575892857142e-05 1.5 1.6541852678571427e-05 1.5 1.6542410714285713e-05 0.0 1.6546874999999997e-05 0.0 1.6547433035714284e-05 1.5 1.655970982142857e-05 1.5 1.6560267857142856e-05 0.0 1.6564732142857143e-05 0.0 1.6565290178571426e-05 1.5 1.6577566964285715e-05 1.5 1.6578124999999998e-05 0.0 1.6582589285714285e-05 0.0 1.658314732142857e-05 1.5 1.6595424107142857e-05 1.5 1.659598214285714e-05 0.0 1.6600446428571428e-05 0.0 1.6601004464285714e-05 1.5 1.661328125e-05 1.5 1.6613839285714286e-05 0.0 1.661830357142857e-05 0.0 1.6618861607142857e-05 1.5 1.663113839285714e-05 1.5 1.663169642857143e-05 0.0 1.6636160714285712e-05 0.0 1.663671875e-05 1.5 1.6648995535714284e-05 1.5 1.664955357142857e-05 0.0 1.6654017857142855e-05 0.0 1.665457589285714e-05 1.5 1.6666852678571426e-05 1.5 1.6667410714285713e-05 0.0 1.6671875e-05 0.0 1.6672433035714284e-05 1.5 1.668470982142857e-05 1.5 1.6685267857142855e-05 0.0 1.6689732142857143e-05 0.0 1.6690290178571426e-05 1.5 1.6702566964285714e-05 1.5 1.6703124999999998e-05 0.0 1.6707589285714285e-05 0.0 1.6708147321428572e-05 1.5 1.6720424107142857e-05 1.5 1.672098214285714e-05 0.0 1.6725446428571427e-05 0.0 1.6726004464285714e-05 1.5 1.673828125e-05 1.5 1.6738839285714286e-05 0.0 1.674330357142857e-05 0.0 1.6743861607142856e-05 1.5 1.675613839285714e-05 1.5 1.6756696428571428e-05 0.0 1.6761160714285712e-05 0.0 1.676171875e-05 1.5 1.6773995535714284e-05 1.5 1.677455357142857e-05 0.0 1.6779017857142854e-05 0.0 1.677957589285714e-05 1.5 1.6791852678571426e-05 1.5 1.6792410714285713e-05 0.0 1.6796875e-05 0.0 1.6797433035714283e-05 1.5 1.680970982142857e-05 1.5 1.6810267857142855e-05 0.0 1.6814732142857142e-05 0.0 1.6815290178571426e-05 1.5 1.6827566964285714e-05 1.5 1.6828124999999997e-05 0.0 1.6832589285714285e-05 0.0 1.683314732142857e-05 1.5 1.6845424107142856e-05 1.5 1.6845982142857143e-05 0.0 1.6850446428571427e-05 0.0 1.6851004464285714e-05 1.5 1.686328125e-05 1.5 1.6863839285714285e-05 0.0 1.686830357142857e-05 0.0 1.6868861607142856e-05 1.5 1.688113839285714e-05 1.5 1.6881696428571428e-05 0.0 1.688616071428571e-05 0.0 1.688671875e-05 1.5 1.6898995535714283e-05 1.5 1.689955357142857e-05 0.0 1.6904017857142857e-05 0.0 1.690457589285714e-05 1.5 1.691685267857143e-05 1.5 1.6917410714285712e-05 0.0 1.6921875e-05 0.0 1.6922433035714283e-05 1.5 1.693470982142857e-05 1.5 1.6935267857142855e-05 0.0 1.6939732142857142e-05 0.0 1.694029017857143e-05 1.5 1.6952566964285714e-05 1.5 1.6953125e-05 0.0 1.6957589285714284e-05 0.0 1.695814732142857e-05 1.5 1.6970424107142856e-05 1.5 1.6970982142857143e-05 0.0 1.6976004464285713e-05 0.0 1.69765625e-05 1.5 1.698772321428571e-05 1.5 1.698828125e-05 0.0 1.6993861607142856e-05 0.0 1.6994419642857142e-05 1.5 1.7005580357142857e-05 1.5 1.700613839285714e-05 0.0 1.7011718749999998e-05 0.0 1.7012276785714285e-05 1.5 1.70234375e-05 1.5 1.7023995535714283e-05 0.0 1.702957589285714e-05 0.0 1.7030133928571427e-05 1.5 1.7041294642857142e-05 1.5 1.704185267857143e-05 0.0 1.7047433035714286e-05 0.0 1.704799107142857e-05 1.5 1.7059151785714284e-05 1.5 1.705970982142857e-05 0.0 1.706529017857143e-05 0.0 1.7065848214285712e-05 1.5 1.7077008928571427e-05 1.5 1.7077566964285713e-05 0.0 1.708314732142857e-05 0.0 1.7083705357142857e-05 1.5 1.709486607142857e-05 1.5 1.7095424107142856e-05 0.0 1.7101004464285713e-05 0.0 1.71015625e-05 1.5 1.7112723214285715e-05 1.5 1.7113281249999998e-05 0.0 1.7118861607142855e-05 0.0 1.7119419642857142e-05 1.5 1.7130580357142857e-05 1.5 1.713113839285714e-05 0.0 1.7136718749999998e-05 0.0 1.7137276785714284e-05 1.5 1.71484375e-05 1.5 1.7148995535714286e-05 0.0 1.715457589285714e-05 0.0 1.7155133928571427e-05 1.5 1.716629464285714e-05 1.5 1.716685267857143e-05 0.0 1.7172433035714286e-05 0.0 1.717299107142857e-05 1.5 1.7184151785714284e-05 1.5 1.718470982142857e-05 0.0 1.7190290178571428e-05 0.0 1.719084821428571e-05 1.5 1.7202008928571426e-05 1.5 1.7202566964285713e-05 0.0 1.720814732142857e-05 0.0 1.7208705357142857e-05 1.5 1.721986607142857e-05 1.5 1.7220424107142855e-05 0.0 1.7226004464285713e-05 0.0 1.72265625e-05 1.5 1.7237723214285714e-05 1.5 1.7238281249999998e-05 0.0 1.7243861607142855e-05 0.0 1.7244419642857142e-05 1.5 1.7255580357142857e-05 1.5 1.725613839285714e-05 0.0 1.7261718749999997e-05 0.0 1.7262276785714284e-05 1.5 1.72734375e-05 1.5 1.7273995535714286e-05 0.0 1.7279575892857143e-05 0.0 1.7280133928571426e-05 1.5 1.729129464285714e-05 1.5 1.7291852678571428e-05 0.0 1.7297433035714285e-05 0.0 1.729799107142857e-05 1.5 1.7309151785714284e-05 1.5 1.730970982142857e-05 0.0 1.7315290178571428e-05 0.0 1.7315848214285714e-05 1.5 1.7327008928571426e-05 1.5 1.7327566964285713e-05 0.0 1.733314732142857e-05 0.0 1.7333705357142857e-05 1.5 1.734486607142857e-05 1.5 1.7345424107142855e-05 0.0 1.7351004464285712e-05 0.0 1.73515625e-05 1.5 1.7362723214285714e-05 1.5 1.7363281249999997e-05 0.0 1.7368861607142855e-05 0.0 1.736941964285714e-05 1.5 1.7380580357142856e-05 1.5 1.7381138392857143e-05 0.0 1.738671875e-05 0.0 1.7387276785714284e-05 1.5 1.7397879464285712e-05 1.5 1.73984375e-05 0.0 1.7405133928571426e-05 0.0 1.7405691964285713e-05 1.5 1.7415736607142857e-05 1.5 1.741629464285714e-05 0.0 1.7422991071428572e-05 0.0 1.7423549107142855e-05 1.5 1.743359375e-05 1.5 1.7434151785714283e-05 0.0 1.7440848214285714e-05 0.0 1.7441406249999997e-05 1.5 1.7451450892857142e-05 1.5 1.745200892857143e-05 0.0 1.7458705357142856e-05 0.0 1.7459263392857143e-05 1.5 1.7469308035714284e-05 1.5 1.746986607142857e-05 0.0 1.74765625e-05 0.0 1.7477120535714286e-05 1.5 1.7487165178571427e-05 1.5 1.7487723214285714e-05 0.0 1.749441964285714e-05 0.0 1.7494977678571428e-05 1.5 1.750502232142857e-05 1.5 1.7505580357142856e-05 0.0 1.7512276785714283e-05 0.0 1.751283482142857e-05 1.5 1.752287946428571e-05 1.5 1.7523437499999998e-05 0.0 1.7530133928571426e-05 0.0 1.7530691964285712e-05 1.5 1.7540736607142857e-05 1.5 1.754129464285714e-05 0.0 1.754799107142857e-05 0.0 1.7548549107142855e-05 1.5 1.755859375e-05 1.5 1.7559151785714283e-05 0.0 1.7565848214285714e-05 0.0 1.7566406249999997e-05 1.5 1.7576450892857142e-05 1.5 1.757700892857143e-05 0.0 1.7583705357142856e-05 0.0 1.7584263392857143e-05 1.5 1.7594308035714284e-05 1.5 1.759486607142857e-05 0.0 1.76015625e-05 0.0 1.7602120535714285e-05 1.5 1.7612165178571426e-05 1.5 1.7612723214285713e-05 0.0 1.761941964285714e-05 0.0 1.7619977678571427e-05 1.5 1.763002232142857e-05 1.5 1.7630580357142856e-05 0.0 1.7637276785714283e-05 0.0 1.763783482142857e-05 1.5 1.7647879464285714e-05 1.5 1.7648437499999998e-05 0.0 1.765513392857143e-05 0.0 1.7655691964285712e-05 1.5 1.7665736607142857e-05 1.5 1.766629464285714e-05 0.0 1.767299107142857e-05 0.0 1.7673549107142854e-05 1.5 1.768359375e-05 1.5 1.7684151785714286e-05 0.0 1.7690848214285713e-05 0.0 1.769140625e-05 1.5 1.770145089285714e-05 1.5 1.7702008928571428e-05 0.0 1.7708705357142856e-05 0.0 1.7709263392857142e-05 1.5 1.7719308035714284e-05 1.5 1.771986607142857e-05 0.0 1.7726562499999998e-05 0.0 1.7727120535714285e-05 1.5 1.7736607142857143e-05 1.5 1.7737165178571426e-05 0.0 1.7744977678571427e-05 0.0 1.7745535714285714e-05 1.5 1.7754464285714285e-05 1.5 1.7755022321428572e-05 0.0 1.776283482142857e-05 0.0 1.7763392857142856e-05 1.5 1.7772321428571427e-05 1.5 1.7772879464285714e-05 0.0 1.7780691964285712e-05 0.0 1.778125e-05 1.5 1.779017857142857e-05 1.5 1.7790736607142856e-05 0.0 1.7798549107142857e-05 0.0 1.779910714285714e-05 1.5 1.7808035714285712e-05 1.5 1.780859375e-05 0.0 1.781640625e-05 0.0 1.7816964285714283e-05 1.5 1.7825892857142854e-05 1.5 1.782645089285714e-05 0.0 1.7834263392857142e-05 0.0 1.783482142857143e-05 1.5 1.784375e-05 1.5 1.7844308035714283e-05 0.0 1.7852120535714284e-05 0.0 1.785267857142857e-05 1.5 1.7861607142857142e-05 1.5 1.7862165178571426e-05 0.0 1.7869977678571427e-05 0.0 1.7870535714285714e-05 1.5 1.7879464285714285e-05 1.5 1.788002232142857e-05 0.0 1.788783482142857e-05 0.0 1.7888392857142856e-05 1.5 1.7897321428571427e-05 1.5 1.7897879464285714e-05 0.0 1.790569196428571e-05 0.0 1.7906249999999998e-05 1.5 1.791517857142857e-05 1.5 1.7915736607142856e-05 0.0 1.7923549107142857e-05 0.0 1.792410714285714e-05 1.5 1.793303571428571e-05 1.5 1.793359375e-05 0.0 1.794140625e-05 0.0 1.7941964285714283e-05 1.5 1.7950892857142857e-05 1.5 1.795145089285714e-05 0.0 1.7959263392857142e-05 0.0 1.795982142857143e-05 1.5 1.796875e-05 1.5 1.7969308035714283e-05 0.0 1.7977120535714284e-05 0.0 1.797767857142857e-05 1.5 1.7986607142857142e-05 1.5 1.798716517857143e-05 0.0 1.7994977678571426e-05 0.0 1.7995535714285713e-05 1.5 1.8004464285714284e-05 1.5 1.800502232142857e-05 0.0 1.801283482142857e-05 0.0 1.8013392857142856e-05 1.5 1.8022321428571427e-05 1.5 1.8022879464285713e-05 0.0 1.8030691964285714e-05 0.0 1.8031249999999998e-05 1.5 1.804017857142857e-05 1.5 1.8040736607142856e-05 0.0 1.8048549107142857e-05 0.0 1.804910714285714e-05 1.5 1.8057477678571428e-05 1.5 1.805803571428571e-05 0.0 1.8066964285714286e-05 0.0 1.806752232142857e-05 1.5 1.807533482142857e-05 1.5 1.8075892857142857e-05 0.0 1.8084821428571428e-05 0.0 1.808537946428571e-05 1.5 1.8093191964285713e-05 1.5 1.809375e-05 0.0 1.810267857142857e-05 0.0 1.8103236607142857e-05 1.5 1.8111049107142855e-05 1.5 1.811160714285714e-05 0.0 1.8120535714285713e-05 0.0 1.812109375e-05 1.5 1.8128906249999997e-05 1.5 1.8129464285714284e-05 0.0 1.8138392857142855e-05 0.0 1.8138950892857142e-05 1.5 1.8146763392857143e-05 1.5 1.8147321428571426e-05 0.0 1.8156249999999997e-05 0.0 1.8156808035714284e-05 1.5 1.8164620535714285e-05 1.5 1.816517857142857e-05 0.0 1.8174107142857143e-05 0.0 1.8174665178571427e-05 1.5 1.8182477678571428e-05 1.5 1.8183035714285714e-05 0.0 1.8191964285714286e-05 0.0 1.819252232142857e-05 1.5 1.820033482142857e-05 1.5 1.8200892857142857e-05 0.0 1.8209821428571428e-05 0.0 1.8210379464285715e-05 1.5 1.8218191964285712e-05 1.5 1.821875e-05 0.0 1.822767857142857e-05 0.0 1.8228236607142857e-05 1.5 1.8236049107142855e-05 1.5 1.823660714285714e-05 0.0 1.8245535714285712e-05 0.0 1.824609375e-05 1.5 1.825390625e-05 1.5 1.8254464285714284e-05 0.0 1.8263392857142855e-05 0.0 1.826395089285714e-05 1.5 1.8271763392857143e-05 1.5 1.8272321428571426e-05 0.0 1.8281249999999997e-05 0.0 1.8281808035714284e-05 1.5 1.8289620535714285e-05 1.5 1.829017857142857e-05 0.0 1.8299107142857143e-05 0.0 1.8299665178571426e-05 1.5 1.8307477678571427e-05 1.5 1.8308035714285714e-05 0.0 1.8316964285714285e-05 0.0 1.831752232142857e-05 1.5 1.832533482142857e-05 1.5 1.8325892857142856e-05 0.0 1.8334821428571427e-05 0.0 1.8335379464285714e-05 1.5 1.8343191964285712e-05 1.5 1.834375e-05 0.0 1.835267857142857e-05 0.0 1.8353236607142857e-05 1.5 1.8361049107142854e-05 1.5 1.836160714285714e-05 0.0 1.8370535714285712e-05 0.0 1.837109375e-05 1.5 1.837890625e-05 1.5 1.8379464285714283e-05 0.0 1.838895089285714e-05 0.0 1.8389508928571428e-05 1.5 1.8396205357142855e-05 1.5 1.8396763392857142e-05 0.0 1.8406808035714284e-05 0.0 1.840736607142857e-05 1.5 1.8414062499999998e-05 1.5 1.8414620535714285e-05 0.0 1.8424665178571426e-05 0.0 1.8425223214285713e-05 1.5 1.843191964285714e-05 1.5 1.8432477678571427e-05 0.0 1.844252232142857e-05 0.0 1.8443080357142855e-05 1.5 1.8449776785714286e-05 1.5 1.845033482142857e-05 0.0 1.8460379464285714e-05 0.0 1.8460937499999997e-05 1.5 1.8467633928571428e-05 1.5 1.846819196428571e-05 0.0 1.8478236607142856e-05 0.0 1.8478794642857143e-05 1.5 1.848549107142857e-05 1.5 1.8486049107142857e-05 0.0 1.849609375e-05 0.0 1.8496651785714285e-05 1.5 1.8503348214285713e-05 1.5 1.850390625e-05 0.0 1.851395089285714e-05 0.0 1.8514508928571428e-05 1.5 1.8521205357142855e-05 1.5 1.8521763392857142e-05 0.0 1.8531808035714283e-05 0.0 1.853236607142857e-05 1.5 1.8539062499999997e-05 1.5 1.8539620535714284e-05 0.0 1.854966517857143e-05 0.0 1.8550223214285712e-05 1.5 1.8556919642857143e-05 1.5 1.8557477678571427e-05 0.0 1.856752232142857e-05 0.0 1.8568080357142855e-05 1.5 1.8574776785714285e-05 1.5 1.857533482142857e-05 0.0 1.8585379464285714e-05 0.0 1.85859375e-05 1.5 1.8592633928571428e-05 1.5 1.8593191964285715e-05 0.0 1.8603236607142856e-05 0.0 1.8603794642857143e-05 1.5 1.861049107142857e-05 1.5 1.8611049107142857e-05 0.0 1.8621093749999998e-05 0.0 1.8621651785714285e-05 1.5 1.8628348214285712e-05 1.5 1.862890625e-05 0.0 1.863895089285714e-05 0.0 1.8639508928571427e-05 1.5 1.8646205357142855e-05 1.5 1.864676339285714e-05 0.0 1.8656808035714283e-05 0.0 1.865736607142857e-05 1.5 1.8664062499999997e-05 1.5 1.8664620535714284e-05 0.0 1.867466517857143e-05 0.0 1.8675223214285712e-05 1.5 1.8681919642857143e-05 1.5 1.8682477678571426e-05 0.0 1.869252232142857e-05 0.0 1.8693080357142854e-05 1.5 1.8699776785714285e-05 1.5 1.870033482142857e-05 0.0 1.8710379464285713e-05 0.0 1.87109375e-05 1.5 1.8717633928571427e-05 1.5 1.8718191964285714e-05 0.0 1.8728794642857142e-05 0.0 1.8729352678571426e-05 1.5 1.8734933035714283e-05 1.5 1.873549107142857e-05 0.0 1.8746651785714285e-05 0.0 1.874720982142857e-05 1.5 1.875279017857143e-05 1.5 1.8753348214285712e-05 0.0 1.8764508928571427e-05 0.0 1.8765066964285714e-05 1.5 1.877064732142857e-05 1.5 1.8771205357142854e-05 0.0 1.878236607142857e-05 0.0 1.8782924107142856e-05 1.5 1.8788504464285713e-05 1.5 1.87890625e-05 0.0 1.880022321428571e-05 0.0 1.880078125e-05 1.5 1.8806361607142856e-05 1.5 1.8806919642857142e-05 0.0 1.8818080357142857e-05 0.0 1.881863839285714e-05 1.5 1.8824218749999998e-05 1.5 1.8824776785714285e-05 0.0 1.88359375e-05 0.0 1.8836495535714283e-05 1.5 1.884207589285714e-05 1.5 1.8842633928571427e-05 0.0 1.8853794642857142e-05 0.0 1.885435267857143e-05 1.5 1.8859933035714283e-05 1.5 1.886049107142857e-05 0.0 1.8871651785714284e-05 0.0 1.887220982142857e-05 1.5 1.887779017857143e-05 1.5 1.8878348214285712e-05 0.0 1.8889508928571427e-05 0.0 1.8890066964285713e-05 1.5 1.889564732142857e-05 1.5 1.8896205357142857e-05 0.0 1.890736607142857e-05 0.0 1.8907924107142856e-05 1.5 1.8913504464285713e-05 1.5 1.89140625e-05 0.0 1.8925223214285715e-05 0.0 1.8925781249999998e-05 1.5 1.8931361607142855e-05 1.5 1.8931919642857142e-05 0.0 1.8943080357142857e-05 0.0 1.894363839285714e-05 1.5 1.8949218749999998e-05 1.5 1.8949776785714284e-05 0.0 1.89609375e-05 0.0 1.8961495535714286e-05 1.5 1.896707589285714e-05 1.5 1.8967633928571427e-05 0.0 1.897879464285714e-05 0.0 1.897935267857143e-05 1.5 1.8984933035714286e-05 1.5 1.898549107142857e-05 0.0 1.8996651785714284e-05 0.0 1.899720982142857e-05 1.5 1.9002790178571428e-05 1.5 1.900334821428571e-05 0.0 1.9014508928571426e-05 0.0 1.9015066964285713e-05 1.5 1.902064732142857e-05 1.5 1.9021205357142857e-05 0.0 1.903236607142857e-05 0.0 1.9032924107142855e-05 1.5 1.9038504464285713e-05 1.5 1.90390625e-05 0.0 1.9050223214285714e-05 0.0 1.9050781249999998e-05 1.5 1.9056361607142855e-05 1.5 1.9056919642857142e-05 0.0 1.9068080357142857e-05 0.0 1.906863839285714e-05 1.5 1.9074218749999997e-05 1.5 1.9074776785714284e-05 0.0 1.90859375e-05 0.0 1.9086495535714286e-05 1.5 1.9092075892857143e-05 1.5 1.9092633928571426e-05 0.0 1.910379464285714e-05 0.0 1.9104352678571428e-05 1.5 1.9109933035714285e-05 1.5 1.911049107142857e-05 0.0 1.9121651785714284e-05 0.0 1.912220982142857e-05 1.5 1.9127790178571428e-05 1.5 1.9128348214285714e-05 0.0 1.9139508928571426e-05 0.0 1.9140066964285713e-05 1.5 1.9145089285714283e-05 1.5 1.914564732142857e-05 0.0 1.9157924107142855e-05 0.0 1.9158482142857142e-05 1.5 1.9162946428571426e-05 1.5 1.9163504464285712e-05 0.0 1.9175781249999997e-05 0.0 1.9176339285714284e-05 1.5 1.918080357142857e-05 1.5 1.9181361607142855e-05 0.0 1.9193638392857143e-05 0.0 1.9194196428571426e-05 1.5 1.9198660714285714e-05 1.5 1.9199218749999997e-05 0.0 1.9211495535714285e-05 0.0 1.921205357142857e-05 1.5 1.9216517857142856e-05 1.5 1.9217075892857143e-05 0.0 1.9229352678571428e-05 0.0 1.9229910714285714e-05 1.5 1.9234374999999998e-05 1.5 1.9234933035714285e-05 0.0 1.924720982142857e-05 0.0 1.9247767857142857e-05 1.5 1.925223214285714e-05 1.5 1.9252790178571427e-05 0.0 1.9265066964285712e-05 0.0 1.9265625e-05 1.5 1.9270089285714283e-05 1.5 1.927064732142857e-05 0.0 1.9282924107142855e-05 0.0 1.928348214285714e-05 1.5 1.928794642857143e-05 1.5 1.9288504464285712e-05 0.0 1.9300781249999997e-05 0.0 1.9301339285714284e-05 1.5 1.930580357142857e-05 1.5 1.9306361607142854e-05 0.0 1.9318638392857143e-05 0.0 1.9319196428571426e-05 1.5 1.9323660714285713e-05 1.5 1.932421875e-05 0.0 1.9336495535714285e-05 0.0 1.9337053571428572e-05 1.5 1.9341517857142856e-05 1.5 1.9342075892857142e-05 0.0 1.9354352678571427e-05 0.0 1.9354910714285714e-05 1.5 1.9359374999999998e-05 1.5 1.9359933035714285e-05 0.0 1.937220982142857e-05 0.0 1.9372767857142856e-05 1.5 1.937723214285714e-05 1.5 1.9377790178571427e-05 0.0 1.9390066964285712e-05 0.0 1.9390625e-05 1.5 1.9395089285714286e-05 1.5 1.939564732142857e-05 0.0 1.9407924107142854e-05 0.0 1.940848214285714e-05 1.5 1.9412946428571428e-05 1.5 1.941350446428571e-05 0.0 1.942578125e-05 0.0 1.9426339285714283e-05 1.5 1.943080357142857e-05 1.5 1.9431361607142857e-05 0.0 1.9443638392857142e-05 0.0 1.9444196428571426e-05 1.5 1.9448660714285713e-05 1.5 1.944921875e-05 0.0 1.9461495535714285e-05 0.0 1.946205357142857e-05 1.5 1.9466517857142855e-05 1.5 1.9467075892857142e-05 0.0 1.9479352678571427e-05 0.0 1.9479910714285714e-05 1.5 1.9484374999999998e-05 1.5 1.9484933035714284e-05 0.0 1.949720982142857e-05 0.0 1.9497767857142856e-05 1.5 1.950223214285714e-05 1.5 1.9502790178571427e-05 0.0 1.951506696428571e-05 0.0 1.9515625e-05 1.5 1.9520089285714286e-05 1.5 1.952064732142857e-05 0.0 1.9532924107142857e-05 0.0 1.953348214285714e-05 1.5 1.9537946428571428e-05 1.5 1.953850446428571e-05 0.0 1.955078125e-05 0.0 1.9551339285714283e-05 1.5 1.955580357142857e-05 1.5 1.9556361607142857e-05 0.0 1.9568638392857142e-05 0.0 1.956919642857143e-05 1.5 1.9573660714285713e-05 1.5 1.957421875e-05 0.0 1.9586495535714284e-05 0.0 1.958705357142857e-05 1.5 1.9591517857142855e-05 1.5 1.959207589285714e-05 0.0 1.9604352678571427e-05 0.0 1.9604910714285713e-05 1.5 1.9609374999999997e-05 1.5 1.9609933035714284e-05 0.0 1.962220982142857e-05 0.0 1.9622767857142856e-05 1.5 1.9627232142857143e-05 1.5 1.9627790178571426e-05 0.0 1.964006696428571e-05 0.0 1.9640624999999998e-05 1.5 1.9645089285714285e-05 1.5 1.964564732142857e-05 0.0 1.9657924107142857e-05 0.0 1.965848214285714e-05 1.5 1.9662946428571428e-05 1.5 1.9663504464285714e-05 0.0 1.967578125e-05 0.0 1.9676339285714283e-05 1.5 1.968080357142857e-05 1.5 1.9681361607142857e-05 0.0 1.969363839285714e-05 0.0 1.969419642857143e-05 1.5 1.9698660714285712e-05 1.5 1.969921875e-05 0.0 1.9711495535714284e-05 0.0 1.971205357142857e-05 1.5 1.9716517857142855e-05 1.5 1.971707589285714e-05 0.0 1.9729352678571426e-05 0.0 1.9729910714285713e-05 1.5 1.9734375e-05 1.5 1.9734933035714284e-05 0.0 1.974720982142857e-05 0.0 1.9747767857142855e-05 1.5 1.9752232142857143e-05 1.5 1.9752790178571426e-05 0.0 1.9765066964285714e-05 0.0 1.9765624999999998e-05 1.5 1.9770089285714285e-05 1.5 1.977064732142857e-05 0.0 1.9782924107142857e-05 0.0 1.978348214285714e-05 1.5 1.9787946428571427e-05 1.5 1.9788504464285714e-05 0.0 1.980078125e-05 0.0 1.9801339285714286e-05 1.5 1.980580357142857e-05 1.5 1.9806361607142856e-05 0.0 1.981863839285714e-05 0.0 1.9819196428571428e-05 1.5 1.9823660714285712e-05 1.5 1.982421875e-05 0.0 1.9836495535714284e-05 0.0 1.983705357142857e-05 1.5 1.9841517857142854e-05 1.5 1.984207589285714e-05 0.0 1.9854352678571426e-05 0.0 1.9854910714285713e-05 1.5 1.9859375e-05 1.5 1.9859933035714283e-05 0.0 1.987220982142857e-05 0.0 1.9872767857142855e-05 1.5 1.9877232142857142e-05 1.5 1.9877790178571426e-05 0.0 1.9890066964285714e-05 0.0 1.9890624999999997e-05 1.5 1.9895089285714285e-05 1.5 1.989564732142857e-05 0.0 1.9907924107142856e-05 0.0 1.9908482142857143e-05 1.5 1.9912946428571427e-05 1.5 1.9913504464285714e-05 0.0 1.992578125e-05 0.0 1.9926339285714285e-05 1.5 1.993080357142857e-05 1.5 1.9931361607142856e-05 0.0 1.994363839285714e-05 0.0 1.9944196428571428e-05 1.5 1.994866071428571e-05 1.5 1.9949218749999998e-05 0.0 1.9961495535714283e-05 0.0 1.996205357142857e-05 1.5 1.9966517857142857e-05 1.5 1.996707589285714e-05 0.0 1.9979352678571426e-05 0.0 1.9979910714285712e-05 1.5 1.9984375e-05 1.5 1.9984933035714283e-05 0.0 1.999720982142857e-05 0.0 1.9997767857142855e-05 1.5 2.0002232142857142e-05 1.5 2.000279017857143e-05 0.0 2.0015066964285714e-05 0.0 2.0015624999999997e-05 1.5 2.0020089285714284e-05 1.5 2.002064732142857e-05 0.0 2.0032924107142856e-05 0.0 2.0033482142857143e-05 1.5 2.0037946428571427e-05 1.5 2.0038504464285713e-05 0.0 2.0050781249999998e-05 0.0 2.0051339285714285e-05 1.5 2.005580357142857e-05 1.5 2.0056361607142856e-05 0.0 2.006863839285714e-05 0.0 2.0069196428571427e-05 1.5 2.007366071428571e-05 1.5 2.0074218749999998e-05 0.0 2.0086495535714283e-05 0.0 2.008705357142857e-05 1.5 2.0091517857142857e-05 1.5 2.009207589285714e-05 0.0 2.010435267857143e-05 0.0 2.0104910714285712e-05 1.5 2.0109375e-05 1.5 2.0109933035714283e-05 0.0 2.012220982142857e-05 0.0 2.0122767857142854e-05 1.5 2.012723214285714e-05 1.5 2.0127790178571428e-05 0.0 2.0140066964285713e-05 0.0 2.0140625e-05 1.5 2.0145089285714284e-05 1.5 2.014564732142857e-05 0.0 2.0157924107142856e-05 0.0 2.0158482142857142e-05 1.5 2.0162946428571426e-05 1.5 2.0163504464285713e-05 0.0 2.0175781249999998e-05 0.0 2.0176339285714285e-05 1.5 2.018080357142857e-05 1.5 2.0181361607142855e-05 0.0 2.019363839285714e-05 0.0 2.0194196428571427e-05 1.5 2.0198660714285714e-05 1.5 2.0199218749999998e-05 0.0 2.0211495535714286e-05 0.0 2.021205357142857e-05 1.5 2.0216517857142857e-05 1.5 2.021707589285714e-05 0.0 2.0229352678571428e-05 0.0 2.022991071428571e-05 1.5 2.0234375e-05 1.5 2.0234933035714286e-05 0.0 2.024720982142857e-05 0.0 2.0247767857142857e-05 1.5 2.025223214285714e-05 1.5 2.0252790178571428e-05 0.0 2.0265066964285713e-05 0.0 2.0265625e-05 1.5 2.0270089285714284e-05 1.5 2.027064732142857e-05 0.0 2.0282924107142855e-05 0.0 2.0283482142857142e-05 1.5 2.0287946428571426e-05 1.5 2.0288504464285713e-05 0.0 2.0300781249999998e-05 0.0 2.0301339285714284e-05 1.5 2.030580357142857e-05 1.5 2.0306361607142855e-05 0.0 2.031863839285714e-05 0.0 2.0319196428571427e-05 1.5 2.0323660714285714e-05 1.5 2.0324218749999997e-05 0.0 2.0336495535714286e-05 0.0 2.033705357142857e-05 1.5 2.0341517857142856e-05 1.5 2.0342075892857143e-05 0.0 2.0354352678571428e-05 0.0 2.035491071428571e-05 1.5 2.0359375e-05 1.5 2.0359933035714285e-05 0.0 2.037220982142857e-05 0.0 2.0372767857142857e-05 1.5 2.037723214285714e-05 1.5 2.0377790178571428e-05 0.0 2.0390066964285713e-05 0.0 2.0390625e-05 1.5 2.0395089285714283e-05 1.5 2.039564732142857e-05 0.0 2.0407924107142855e-05 0.0 2.040848214285714e-05 1.5 2.0412946428571425e-05 1.5 2.0413504464285712e-05 0.0 2.0425781249999997e-05 0.0 2.0426339285714284e-05 1.5 2.043080357142857e-05 1.5 2.0431361607142855e-05 0.0 2.0443638392857143e-05 0.0 2.0444196428571426e-05 1.5 2.0448660714285714e-05 1.5 2.0449218749999997e-05 0.0 2.0461495535714285e-05 0.0 2.046205357142857e-05 1.5 2.0466517857142856e-05 1.5 2.0467075892857143e-05 0.0 2.0479352678571428e-05 0.0 2.0479910714285714e-05 1.5 2.0484374999999998e-05 1.5 2.0484933035714285e-05 0.0 2.049720982142857e-05 0.0 2.0497767857142857e-05 1.5 2.050223214285714e-05 1.5 2.0502790178571427e-05 0.0 2.0515066964285712e-05 0.0 2.0515625e-05 1.5 2.0520089285714283e-05 1.5 2.052064732142857e-05 0.0 2.0532924107142854e-05 0.0 2.053348214285714e-05 1.5 2.053794642857143e-05 1.5 2.0538504464285712e-05 0.0 2.055078125e-05 0.0 2.0551339285714284e-05 1.5 2.055580357142857e-05 1.5 2.0556361607142854e-05 0.0 2.0568638392857143e-05 0.0 2.0569196428571426e-05 1.5 2.0573660714285713e-05 1.5 2.057421875e-05 0.0 2.0586495535714285e-05 0.0 2.058705357142857e-05 1.5 2.0591517857142855e-05 1.5 2.0592075892857142e-05 0.0 2.0604352678571427e-05 0.0 2.0604910714285714e-05 1.5 2.0609374999999998e-05 1.5 2.0609933035714285e-05 0.0 2.062220982142857e-05 0.0 2.0622767857142856e-05 1.5 2.062723214285714e-05 1.5 2.0627790178571427e-05 0.0 2.0640066964285712e-05 0.0 2.0640625e-05 1.5 2.0645089285714286e-05 1.5 2.064564732142857e-05 0.0 2.0657924107142854e-05 0.0 2.065848214285714e-05 1.5 2.0662946428571428e-05 1.5 2.066350446428571e-05 0.0 2.067578125e-05 0.0 2.0676339285714283e-05 1.5 2.068080357142857e-05 1.5 2.0681361607142857e-05 0.0 2.0693638392857142e-05 0.0 2.0694196428571426e-05 1.5 2.0698660714285713e-05 1.5 2.069921875e-05 0.0 2.0711495535714284e-05 0.0 2.071205357142857e-05 1.5 2.0716517857142855e-05 1.5 2.0717075892857142e-05 0.0 2.0729352678571427e-05 0.0 2.0729910714285714e-05 1.5 2.0734374999999997e-05 1.5 2.0734933035714284e-05 0.0 2.074720982142857e-05 0.0 2.0747767857142856e-05 1.5 2.075223214285714e-05 1.5 2.0752790178571427e-05 0.0 2.076506696428571e-05 0.0 2.0765624999999998e-05 1.5 2.0770089285714285e-05 1.5 2.077064732142857e-05 0.0 2.0782924107142857e-05 0.0 2.078348214285714e-05 1.5 2.0787946428571428e-05 1.5 2.078850446428571e-05 0.0 2.080078125e-05 0.0 2.0801339285714283e-05 1.5 2.080580357142857e-05 1.5 2.0806361607142857e-05 0.0 2.0818638392857142e-05 0.0 2.081919642857143e-05 1.5 2.0823660714285712e-05 1.5 2.082421875e-05 0.0 2.0836495535714284e-05 0.0 2.083705357142857e-05 1.5 2.0841517857142855e-05 1.5 2.084207589285714e-05 0.0 2.0854352678571426e-05 0.0 2.0854910714285713e-05 1.5 2.0859374999999997e-05 1.5 2.0859933035714284e-05 0.0 2.087220982142857e-05 0.0 2.0872767857142856e-05 1.5 2.0877232142857143e-05 1.5 2.0877790178571426e-05 0.0 2.089006696428571e-05 0.0 2.0890624999999998e-05 1.5 2.0895089285714285e-05 1.5 2.089564732142857e-05 0.0 2.0907924107142857e-05 0.0 2.090848214285714e-05 1.5 2.0912946428571427e-05 1.5 2.0913504464285714e-05 0.0 2.092578125e-05 0.0 2.0926339285714283e-05 1.5 2.093080357142857e-05 1.5 2.0931361607142857e-05 0.0 2.094363839285714e-05 0.0 2.0944196428571428e-05 1.5 2.0948660714285712e-05 1.5 2.094921875e-05 0.0 2.0961495535714284e-05 0.0 2.096205357142857e-05 1.5 2.0966517857142854e-05 1.5 2.096707589285714e-05 0.0 2.0979352678571426e-05 0.0 2.0979910714285713e-05 1.5 2.0984375e-05 1.5 2.0984933035714284e-05 0.0 2.0996651785714285e-05 0.0 2.099720982142857e-05 1.5 2.1002790178571426e-05 1.5 2.1003348214285713e-05 0.0 2.1014508928571427e-05 0.0 2.1015066964285714e-05 1.5 2.102064732142857e-05 1.5 2.1021205357142855e-05 0.0 2.103236607142857e-05 0.0 2.1032924107142856e-05 1.5 2.1038504464285714e-05 1.5 2.1039062499999997e-05 0.0 2.1050223214285712e-05 0.0 2.105078125e-05 1.5 2.1056361607142856e-05 1.5 2.1056919642857143e-05 0.0 2.1068080357142854e-05 0.0 2.106863839285714e-05 1.5 2.107421875e-05 1.5 2.1074776785714285e-05 0.0 2.10859375e-05 0.0 2.1086495535714283e-05 1.5 2.109207589285714e-05 1.5 2.1092633928571428e-05 0.0 2.1103794642857142e-05 0.0 2.1104352678571426e-05 1.5 2.1109933035714283e-05 1.5 2.111049107142857e-05 0.0 2.1121651785714285e-05 0.0 2.112220982142857e-05 1.5 2.1127790178571425e-05 1.5 2.1128348214285712e-05 0.0 2.1139508928571427e-05 0.0 2.1140066964285714e-05 1.5 2.114564732142857e-05 1.5 2.1146205357142855e-05 0.0 2.115736607142857e-05 0.0 2.1157924107142856e-05 1.5 2.1163504464285714e-05 1.5 2.1164062499999997e-05 0.0 2.1175223214285712e-05 0.0 2.117578125e-05 1.5 2.1181361607142856e-05 1.5 2.1181919642857143e-05 0.0 2.1193080357142854e-05 0.0 2.119363839285714e-05 1.5 2.1199218749999998e-05 1.5 2.1199776785714285e-05 0.0 2.12109375e-05 0.0 2.1211495535714283e-05 1.5 2.121707589285714e-05 1.5 2.1217633928571427e-05 0.0 2.1228794642857142e-05 0.0 2.1229352678571425e-05 1.5 2.1234933035714283e-05 1.5 2.123549107142857e-05 0.0 2.1246651785714284e-05 0.0 2.124720982142857e-05 1.5 2.125279017857143e-05 1.5 2.1253348214285712e-05 0.0 2.1264508928571427e-05 0.0 2.1265066964285713e-05 1.5 2.127064732142857e-05 1.5 2.1271205357142854e-05 0.0 2.128236607142857e-05 0.0 2.1282924107142856e-05 1.5 2.1288504464285713e-05 1.5 2.12890625e-05 0.0 2.130022321428571e-05 0.0 2.1300781249999998e-05 1.5 2.1306361607142856e-05 1.5 2.1306919642857142e-05 0.0 2.1318080357142857e-05 0.0 2.131863839285714e-05 1.5 2.1324218749999998e-05 1.5 2.1324776785714285e-05 0.0 2.13359375e-05 0.0 2.1336495535714283e-05 1.5 2.134207589285714e-05 1.5 2.1342633928571427e-05 0.0 2.1353794642857142e-05 0.0 2.135435267857143e-05 1.5 2.1359933035714286e-05 1.5 2.136049107142857e-05 0.0 2.1371651785714284e-05 0.0 2.137220982142857e-05 1.5 2.1377790178571428e-05 1.5 2.137834821428571e-05 0.0 2.1389508928571426e-05 0.0 2.1390066964285713e-05 1.5 2.139564732142857e-05 1.5 2.1396205357142857e-05 0.0 2.1406808035714285e-05 0.0 2.140736607142857e-05 1.5 2.14140625e-05 1.5 2.1414620535714283e-05 0.0 2.1424665178571428e-05 0.0 2.1425223214285714e-05 1.5 2.1431919642857142e-05 1.5 2.143247767857143e-05 0.0 2.144252232142857e-05 0.0 2.1443080357142857e-05 1.5 2.1449776785714284e-05 1.5 2.145033482142857e-05 0.0 2.1460379464285712e-05 0.0 2.14609375e-05 1.5 2.1467633928571427e-05 1.5 2.1468191964285713e-05 0.0 2.1478236607142855e-05 0.0 2.147879464285714e-05 1.5 2.148549107142857e-05 1.5 2.1486049107142856e-05 0.0 2.1496093749999997e-05 0.0 2.1496651785714284e-05 1.5 2.150334821428571e-05 1.5 2.1503906249999998e-05 0.0 2.1513950892857143e-05 0.0 2.1514508928571426e-05 1.5 2.1521205357142857e-05 1.5 2.152176339285714e-05 0.0 2.1531808035714285e-05 0.0 2.153236607142857e-05 1.5 2.15390625e-05 1.5 2.1539620535714283e-05 0.0 2.1549665178571427e-05 0.0 2.1550223214285714e-05 1.5 2.155691964285714e-05 1.5 2.155747767857143e-05 0.0 2.156752232142857e-05 0.0 2.1568080357142856e-05 1.5 2.1574776785714284e-05 1.5 2.157533482142857e-05 0.0 2.1585379464285712e-05 0.0 2.15859375e-05 1.5 2.1592633928571426e-05 1.5 2.1593191964285713e-05 0.0 2.1603236607142854e-05 0.0 2.160379464285714e-05 1.5 2.161049107142857e-05 1.5 2.1611049107142855e-05 0.0 2.162109375e-05 0.0 2.1621651785714283e-05 1.5 2.1628348214285714e-05 1.5 2.1628906249999998e-05 0.0 2.1638950892857142e-05 0.0 2.1639508928571426e-05 1.5 2.1646205357142857e-05 1.5 2.164676339285714e-05 0.0 2.1656808035714285e-05 0.0 2.165736607142857e-05 1.5 2.16640625e-05 1.5 2.1664620535714286e-05 0.0 2.1674665178571427e-05 0.0 2.1675223214285714e-05 1.5 2.168191964285714e-05 1.5 2.1682477678571428e-05 0.0 2.169252232142857e-05 0.0 2.1693080357142856e-05 1.5 2.1699776785714284e-05 1.5 2.170033482142857e-05 0.0 2.171037946428571e-05 0.0 2.17109375e-05 1.5 2.1717633928571426e-05 1.5 2.1718191964285713e-05 0.0 2.1728236607142854e-05 0.0 2.172879464285714e-05 1.5 2.1735491071428568e-05 1.5 2.1736049107142855e-05 0.0 2.174609375e-05 0.0 2.1746651785714283e-05 1.5 2.1753906249999997e-05 1.5 2.1754464285714284e-05 0.0 2.1763392857142855e-05 0.0 2.1763950892857142e-05 1.5 2.1771763392857143e-05 1.5 2.1772321428571426e-05 0.0 2.1781249999999997e-05 0.0 2.1781808035714284e-05 1.5 2.1789620535714285e-05 1.5 2.179017857142857e-05 0.0 2.179910714285714e-05 0.0 2.1799665178571427e-05 1.5 2.1807477678571428e-05 1.5 2.1808035714285714e-05 0.0 2.1816964285714286e-05 0.0 2.181752232142857e-05 1.5 2.182533482142857e-05 1.5 2.1825892857142857e-05 0.0 2.1834821428571428e-05 0.0 2.183537946428571e-05 1.5 2.1843191964285712e-05 1.5 2.184375e-05 0.0 2.185267857142857e-05 0.0 2.1853236607142857e-05 1.5 2.1861049107142855e-05 1.5 2.186160714285714e-05 0.0 2.1870535714285713e-05 0.0 2.187109375e-05 1.5 2.1878906249999997e-05 1.5 2.1879464285714284e-05 0.0 2.1888392857142855e-05 0.0 2.188895089285714e-05 1.5 2.1896763392857143e-05 1.5 2.1897321428571426e-05 0.0 2.1906249999999997e-05 0.0 2.1906808035714284e-05 1.5 2.1914620535714285e-05 1.5 2.191517857142857e-05 0.0 2.1924107142857143e-05 0.0 2.1924665178571426e-05 1.5 2.1932477678571427e-05 1.5 2.1933035714285714e-05 0.0 2.1941964285714285e-05 0.0 2.194252232142857e-05 1.5 2.195033482142857e-05 1.5 2.1950892857142856e-05 0.0 2.1959821428571428e-05 0.0 2.1960379464285714e-05 1.5 2.1968191964285712e-05 1.5 2.196875e-05 0.0 2.197767857142857e-05 0.0 2.1978236607142857e-05 1.5 2.1986049107142854e-05 1.5 2.198660714285714e-05 0.0 2.1995535714285712e-05 0.0 2.199609375e-05 1.5 2.200390625e-05 1.5 2.2004464285714283e-05 0.0 2.2013392857142854e-05 0.0 2.201395089285714e-05 1.5 2.2021763392857142e-05 1.5 2.2022321428571426e-05 0.0 2.2031249999999997e-05 0.0 2.2031808035714284e-05 1.5 2.2039620535714285e-05 1.5 2.204017857142857e-05 0.0 2.2049107142857143e-05 0.0 2.2049665178571426e-05 1.5 2.2057477678571427e-05 1.5 2.2058035714285714e-05 0.0 2.2066964285714285e-05 0.0 2.2067522321428568e-05 1.5 2.2075892857142856e-05 1.5 2.2076450892857143e-05 0.0 2.208426339285714e-05 0.0 2.2084821428571427e-05 1.5 2.209375e-05 1.5 2.2094308035714285e-05 0.0 2.2102120535714283e-05 0.0 2.210267857142857e-05 1.5 2.211160714285714e-05 1.5 2.2112165178571427e-05 0.0 2.211997767857143e-05 0.0 2.2120535714285712e-05 1.5 2.2129464285714283e-05 1.5 2.213002232142857e-05 0.0 2.213783482142857e-05 0.0 2.2138392857142854e-05 1.5 2.214732142857143e-05 1.5 2.2147879464285712e-05 0.0 2.2155691964285713e-05 0.0 2.215625e-05 1.5 2.216517857142857e-05 1.5 2.2165736607142854e-05 0.0 2.2173549107142855e-05 0.0 2.2174107142857142e-05 1.5 2.2183035714285713e-05 1.5 2.218359375e-05 0.0 2.2191406249999998e-05 0.0 2.2191964285714284e-05 1.5 2.2200892857142856e-05 1.5 2.2201450892857142e-05 0.0 2.220926339285714e-05 0.0 2.2209821428571427e-05 1.5 2.2218749999999998e-05 1.5 2.2219308035714285e-05 0.0 2.2227120535714286e-05 0.0 2.222767857142857e-05 1.5 2.223660714285714e-05 1.5 2.2237165178571427e-05 0.0 2.2244977678571428e-05 0.0 2.224553571428571e-05 1.5 2.2254464285714283e-05 1.5 2.225502232142857e-05 0.0 2.226283482142857e-05 0.0 2.2263392857142857e-05 1.5 2.227232142857143e-05 1.5 2.2272879464285712e-05 0.0 2.2280691964285713e-05 0.0 2.228125e-05 1.5 2.229017857142857e-05 1.5 2.2290736607142854e-05 0.0 2.2298549107142855e-05 0.0 2.2299107142857142e-05 1.5 2.2308035714285713e-05 1.5 2.230859375e-05 0.0 2.2316406249999997e-05 0.0 2.2316964285714284e-05 1.5 2.2325892857142855e-05 1.5 2.2326450892857142e-05 0.0 2.233426339285714e-05 0.0 2.2334821428571426e-05 1.5 2.2343749999999998e-05 1.5 2.2344308035714284e-05 0.0 2.2352120535714285e-05 0.0 2.235267857142857e-05 1.5 2.236160714285714e-05 1.5 2.2362165178571427e-05 0.0 2.2369977678571428e-05 0.0 2.237053571428571e-05 1.5 2.2379464285714286e-05 1.5 2.238002232142857e-05 0.0 2.238783482142857e-05 0.0 2.2388392857142857e-05 1.5 2.239787946428571e-05 1.5 2.2398437499999998e-05 0.0 2.2405133928571426e-05 0.0 2.2405691964285712e-05 1.5 2.2415736607142857e-05 1.5 2.241629464285714e-05 0.0 2.242299107142857e-05 0.0 2.2423549107142855e-05 1.5 2.243359375e-05 1.5 2.2434151785714283e-05 0.0 2.2440848214285714e-05 0.0 2.2441406249999997e-05 1.5 2.2451450892857142e-05 1.5 2.245200892857143e-05 0.0 2.2458705357142856e-05 0.0 2.2459263392857143e-05 1.5 2.2469308035714284e-05 1.5 2.246986607142857e-05 0.0 2.24765625e-05 0.0 2.2477120535714285e-05 1.5 2.2487165178571426e-05 1.5 2.2487723214285713e-05 0.0 2.249441964285714e-05 0.0 2.2494977678571427e-05 1.5 2.250502232142857e-05 1.5 2.2505580357142855e-05 0.0 2.2512276785714283e-05 0.0 2.251283482142857e-05 1.5 2.252287946428571e-05 1.5 2.2523437499999998e-05 0.0 2.2530133928571425e-05 0.0 2.2530691964285712e-05 1.5 2.2540736607142857e-05 1.5 2.254129464285714e-05 0.0 2.254799107142857e-05 0.0 2.2548549107142854e-05 1.5 2.255859375e-05 1.5 2.2559151785714286e-05 0.0 2.2565848214285713e-05 0.0 2.256640625e-05 1.5 2.257645089285714e-05 1.5 2.2577008928571428e-05 0.0 2.2583705357142856e-05 0.0 2.2584263392857142e-05 1.5 2.2594308035714284e-05 1.5 2.259486607142857e-05 0.0 2.2601562499999998e-05 0.0 2.2602120535714285e-05 1.5 2.2612165178571426e-05 1.5 2.2612723214285713e-05 0.0 2.261941964285714e-05 0.0 2.2619977678571427e-05 1.5 2.263002232142857e-05 1.5 2.2630580357142855e-05 0.0 2.2637276785714283e-05 0.0 2.263783482142857e-05 1.5 2.2647879464285714e-05 1.5 2.2648437499999997e-05 0.0 2.265513392857143e-05 0.0 2.265569196428571e-05 1.5 2.2665736607142856e-05 1.5 2.266629464285714e-05 0.0 2.267299107142857e-05 0.0 2.2673549107142854e-05 1.5 2.268359375e-05 1.5 2.2684151785714285e-05 0.0 2.2690848214285713e-05 0.0 2.269140625e-05 1.5 2.270145089285714e-05 1.5 2.2702008928571428e-05 0.0 2.2708705357142855e-05 0.0 2.2709263392857142e-05 1.5 2.2719308035714283e-05 1.5 2.271986607142857e-05 0.0 2.2726562499999998e-05 0.0 2.2727120535714284e-05 1.5 2.2737165178571426e-05 1.5 2.2737723214285712e-05 0.0 2.2743861607142857e-05 0.0 2.274441964285714e-05 1.5 2.2755580357142855e-05 1.5 2.275613839285714e-05 0.0 2.276171875e-05 0.0 2.2762276785714286e-05 1.5 2.2773437499999997e-05 1.5 2.2773995535714284e-05 0.0 2.277957589285714e-05 0.0 2.2780133928571428e-05 1.5 2.2791294642857143e-05 1.5 2.2791852678571426e-05 0.0 2.2797433035714284e-05 0.0 2.279799107142857e-05 1.5 2.2809151785714285e-05 1.5 2.280970982142857e-05 0.0 2.2815290178571426e-05 0.0 2.2815848214285713e-05 1.5 2.2827008928571427e-05 1.5 2.2827566964285714e-05 0.0 2.2833147321428568e-05 0.0 2.2833705357142855e-05 1.5 2.284486607142857e-05 1.5 2.2845424107142856e-05 0.0 2.2851004464285714e-05 0.0 2.2851562499999997e-05 1.5 2.2862723214285712e-05 1.5 2.286328125e-05 0.0 2.2868861607142856e-05 0.0 2.286941964285714e-05 1.5 2.2880580357142854e-05 1.5 2.288113839285714e-05 0.0 2.288671875e-05 0.0 2.2887276785714285e-05 1.5 2.2898437499999997e-05 1.5 2.2898995535714283e-05 0.0 2.290457589285714e-05 0.0 2.2905133928571428e-05 1.5 2.2916294642857142e-05 1.5 2.2916852678571426e-05 0.0 2.2922433035714283e-05 0.0 2.292299107142857e-05 1.5 2.2934151785714285e-05 1.5 2.2934709821428568e-05 0.0 2.2940290178571426e-05 0.0 2.2940848214285712e-05 1.5 2.2952008928571427e-05 1.5 2.2952566964285714e-05 0.0 2.295814732142857e-05 0.0 2.2958705357142855e-05 1.5 2.296986607142857e-05 1.5 2.2970424107142856e-05 0.0 2.2976004464285714e-05 0.0 2.2976562499999997e-05 1.5 2.2987723214285712e-05 1.5 2.298828125e-05 0.0 2.2993861607142856e-05 0.0 2.2994419642857143e-05 1.5 2.3005580357142854e-05 1.5 2.300613839285714e-05 0.0 2.3011718749999998e-05 0.0 2.3012276785714285e-05 1.5 2.30234375e-05 1.5 2.3023995535714283e-05 0.0 2.302957589285714e-05 0.0 2.3030133928571427e-05 1.5 2.3041294642857142e-05 1.5 2.3041852678571425e-05 0.0 2.3047433035714283e-05 0.0 2.304799107142857e-05 1.5 2.3059151785714284e-05 1.5 2.305970982142857e-05 0.0 2.306529017857143e-05 0.0 2.3065848214285712e-05 1.5 2.3077008928571427e-05 1.5 2.3077566964285713e-05 0.0 2.308314732142857e-05 0.0 2.3083705357142854e-05 1.5 2.309486607142857e-05 1.5 2.3095424107142856e-05 0.0 2.3101004464285713e-05 0.0 2.31015625e-05 1.5 2.311272321428571e-05 1.5 2.3113281249999998e-05 0.0 2.3118861607142856e-05 0.0 2.3119419642857142e-05 1.5 2.3130580357142857e-05 1.5 2.313113839285714e-05 0.0 2.3136718749999998e-05 0.0 2.3137276785714285e-05 1.5 2.31484375e-05 1.5 2.3148995535714283e-05 0.0 2.3154017857142857e-05 0.0 2.315457589285714e-05 1.5 2.316685267857143e-05 1.5 2.3167410714285712e-05 0.0 2.3171875e-05 0.0 2.3172433035714282e-05 1.5 2.318470982142857e-05 1.5 2.3185267857142854e-05 0.0 2.318973214285714e-05 0.0 2.3190290178571428e-05 1.5 2.3202566964285713e-05 1.5 2.3203125e-05 0.0 2.3207589285714284e-05 0.0 2.320814732142857e-05 1.5 2.3220424107142855e-05 1.5 2.3220982142857142e-05 0.0 2.3225446428571426e-05 0.0 2.3226004464285713e-05 1.5 2.3238281249999998e-05 1.5 2.3238839285714285e-05 0.0 2.324330357142857e-05 0.0 2.3243861607142855e-05 1.5 2.325613839285714e-05 1.5 2.3256696428571427e-05 0.0 2.3261160714285714e-05 0.0 2.3261718749999997e-05 1.5 2.3273995535714282e-05 1.5 2.327455357142857e-05 0.0 2.3279017857142856e-05 0.0 2.327957589285714e-05 1.5 2.3291852678571428e-05 1.5 2.329241071428571e-05 0.0 2.3296875e-05 0.0 2.3297433035714286e-05 1.5 2.330970982142857e-05 1.5 2.3310267857142854e-05 0.0 2.331473214285714e-05 0.0 2.3315290178571428e-05 1.5 2.3327566964285713e-05 1.5 2.3328125e-05 0.0 2.3332589285714283e-05 0.0 2.333314732142857e-05 1.5 2.3345424107142855e-05 1.5 2.3345982142857142e-05 0.0 2.3350446428571426e-05 0.0 2.3351004464285712e-05 1.5 2.3363281249999997e-05 1.5 2.3363839285714284e-05 0.0 2.336830357142857e-05 0.0 2.3368861607142855e-05 1.5 2.338113839285714e-05 1.5 2.3381696428571426e-05 0.0 2.3386160714285714e-05 0.0 2.3386718749999997e-05 1.5 2.3398995535714285e-05 1.5 2.339955357142857e-05 0.0 2.3404017857142856e-05 0.0 2.3404575892857143e-05 1.5 2.3416852678571428e-05 1.5 2.341741071428571e-05 0.0 2.3421875e-05 0.0 2.3422433035714285e-05 1.5 2.343470982142857e-05 1.5 2.3435267857142857e-05 0.0 2.343973214285714e-05 0.0 2.3440290178571427e-05 1.5 2.3452566964285712e-05 1.5 2.3453125e-05 0.0 2.3457589285714283e-05 0.0 2.345814732142857e-05 1.5 2.3470424107142855e-05 1.5 2.347098214285714e-05 0.0 2.3475446428571425e-05 0.0 2.3476004464285712e-05 1.5 2.3488281249999997e-05 1.5 2.3488839285714284e-05 0.0 2.349330357142857e-05 0.0 2.3493861607142854e-05 1.5 2.3506138392857143e-05 1.5 2.3506696428571426e-05 0.0 2.3511160714285713e-05 0.0 2.3511718749999997e-05 1.5 2.3523995535714285e-05 1.5 2.352455357142857e-05 0.0 2.3529017857142856e-05 0.0 2.3529575892857142e-05 1.5 2.3541852678571427e-05 1.5 2.3542410714285714e-05 0.0 2.3546874999999998e-05 0.0 2.3547433035714285e-05 1.5 2.355970982142857e-05 1.5 2.3560267857142857e-05 0.0 2.356473214285714e-05 0.0 2.3565290178571427e-05 1.5 2.3577566964285712e-05 1.5 2.3578125e-05 0.0 2.3582589285714283e-05 0.0 2.358314732142857e-05 1.5 2.3595424107142854e-05 1.5 2.359598214285714e-05 0.0 2.360044642857143e-05 0.0 2.3601004464285712e-05 1.5 2.3613281249999997e-05 1.5 2.3613839285714283e-05 0.0 2.361830357142857e-05 0.0 2.3618861607142854e-05 1.5 2.3631138392857142e-05 1.5 2.3631696428571426e-05 0.0 2.3636160714285713e-05 0.0 2.363671875e-05 1.5 2.3648995535714285e-05 1.5 2.3649553571428568e-05 0.0 2.3654017857142855e-05 0.0 2.3654575892857142e-05 1.5 2.3666852678571427e-05 1.5 2.3667410714285714e-05 0.0 2.3671874999999998e-05 0.0 2.3672433035714284e-05 1.5 2.368470982142857e-05 1.5 2.3685267857142856e-05 0.0 2.368973214285714e-05 0.0 2.3690290178571427e-05 1.5 2.3702566964285712e-05 1.5 2.3703125e-05 0.0 2.3707589285714282e-05 0.0 2.370814732142857e-05 1.5 2.3720424107142854e-05 1.5 2.372098214285714e-05 0.0 2.3725446428571428e-05 0.0 2.372600446428571e-05 1.5 2.373828125e-05 1.5 2.3738839285714283e-05 0.0 2.374330357142857e-05 0.0 2.3743861607142854e-05 1.5 2.3756138392857142e-05 1.5 2.3756696428571425e-05 0.0 2.3761160714285713e-05 0.0 2.376171875e-05 1.5 2.3773995535714284e-05 1.5 2.377455357142857e-05 0.0 2.3779017857142855e-05 0.0 2.3779575892857142e-05 1.5 2.3791852678571427e-05 1.5 2.3792410714285713e-05 0.0 2.3796874999999997e-05 0.0 2.3797433035714284e-05 1.5 2.380970982142857e-05 1.5 2.3810267857142856e-05 0.0 2.381473214285714e-05 0.0 2.3815290178571426e-05 1.5 2.382756696428571e-05 1.5 2.3828124999999998e-05 0.0 2.3832589285714285e-05 0.0 2.383314732142857e-05 1.5 2.3845424107142857e-05 1.5 2.384598214285714e-05 0.0 2.3850446428571428e-05 0.0 2.385100446428571e-05 1.5 2.386328125e-05 1.5 2.3863839285714283e-05 0.0 2.386830357142857e-05 0.0 2.3868861607142857e-05 1.5 2.3881138392857142e-05 1.5 2.388169642857143e-05 0.0 2.3886160714285712e-05 0.0 2.388671875e-05 1.5 2.3898995535714284e-05 1.5 2.389955357142857e-05 0.0 2.3904017857142855e-05 0.0 2.390457589285714e-05 1.5 2.3916852678571426e-05 1.5 2.3917410714285713e-05 0.0 2.3921874999999997e-05 0.0 2.3922433035714284e-05 1.5 2.393470982142857e-05 1.5 2.3935267857142855e-05 0.0 2.3939732142857143e-05 0.0 2.3940290178571426e-05 1.5 2.395256696428571e-05 1.5 2.3953124999999998e-05 0.0 2.3957589285714285e-05 0.0 2.395814732142857e-05 1.5 2.3970424107142857e-05 1.5 2.397098214285714e-05 0.0 2.3975446428571427e-05 0.0 2.3976004464285714e-05 1.5 2.398828125e-05 1.5 2.3988839285714282e-05 0.0 2.399330357142857e-05 0.0 2.3993861607142856e-05 1.5 2.400613839285714e-05 1.5 2.4006696428571428e-05 0.0 2.4011160714285712e-05 0.0 2.401171875e-05 1.5 2.4023995535714284e-05 1.5 2.402455357142857e-05 0.0 2.4029017857142854e-05 0.0 2.402957589285714e-05 1.5 2.4041852678571426e-05 1.5 2.4042410714285713e-05 0.0 2.4046874999999997e-05 0.0 2.4047433035714283e-05 1.5 2.405970982142857e-05 1.5 2.4060267857142855e-05 0.0 2.4064732142857142e-05 0.0 2.4065290178571426e-05 1.5 2.4077566964285714e-05 1.5 2.4078124999999997e-05 0.0 2.4082589285714285e-05 0.0 2.4083147321428568e-05 1.5 2.4095424107142856e-05 1.5 2.409598214285714e-05 0.0 2.4100446428571427e-05 0.0 2.4101004464285714e-05 1.5 2.411328125e-05 1.5 2.4113839285714285e-05 0.0 2.411830357142857e-05 0.0 2.4118861607142856e-05 1.5 2.413113839285714e-05 1.5 2.4131696428571428e-05 0.0 2.413616071428571e-05 0.0 2.413671875e-05 1.5 2.4148995535714283e-05 1.5 2.414955357142857e-05 0.0 2.4154017857142854e-05 0.0 2.415457589285714e-05 1.5 2.4166852678571426e-05 1.5 2.4167410714285712e-05 0.0 2.4171875e-05 0.0 2.4172433035714283e-05 1.5 2.418470982142857e-05 1.5 2.4185267857142855e-05 0.0 2.4189732142857142e-05 0.0 2.4190290178571425e-05 1.5 2.4202566964285714e-05 1.5 2.4203124999999997e-05 0.0 2.4207589285714284e-05 0.0 2.420814732142857e-05 1.5 2.4220424107142856e-05 1.5 2.4220982142857143e-05 0.0 2.4225446428571427e-05 0.0 2.4226004464285713e-05 1.5 2.423828125e-05 1.5 2.4238839285714285e-05 0.0 2.424330357142857e-05 0.0 2.4243861607142856e-05 1.5 2.425613839285714e-05 1.5 2.4256696428571427e-05 0.0 2.426116071428571e-05 0.0 2.4261718749999998e-05 1.5 2.4273995535714283e-05 1.5 2.427455357142857e-05 0.0 2.4279017857142857e-05 0.0 2.427957589285714e-05 1.5 2.4291852678571425e-05 1.5 2.4292410714285712e-05 0.0 2.4296875e-05 0.0 2.4297433035714283e-05 1.5 2.430970982142857e-05 1.5 2.4310267857142854e-05 0.0 2.431473214285714e-05 0.0 2.431529017857143e-05 1.5 2.4327566964285713e-05 1.5 2.4328124999999997e-05 0.0 2.4332589285714284e-05 0.0 2.433314732142857e-05 1.5 2.4345424107142856e-05 1.5 2.4345982142857142e-05 0.0 2.4350446428571426e-05 0.0 2.4351004464285713e-05 1.5 2.4363281249999998e-05 1.5 2.4363839285714285e-05 0.0 2.436830357142857e-05 0.0 2.4368861607142855e-05 1.5 2.438113839285714e-05 1.5 2.4381696428571427e-05 0.0 2.438616071428571e-05 0.0 2.4386718749999998e-05 1.5 2.4398995535714283e-05 1.5 2.439955357142857e-05 0.0 2.4404017857142857e-05 0.0 2.440457589285714e-05 1.5 2.441685267857143e-05 1.5 2.4417410714285712e-05 0.0 2.4421875e-05 0.0 2.4422433035714282e-05 1.5 2.443470982142857e-05 1.5 2.4435267857142854e-05 0.0 2.443973214285714e-05 0.0 2.4440290178571428e-05 1.5 2.4452566964285713e-05 1.5 2.4453125e-05 0.0 2.4457589285714284e-05 0.0 2.445814732142857e-05 1.5 2.4470424107142855e-05 1.5 2.4470982142857142e-05 0.0 2.4475446428571426e-05 0.0 2.4476004464285713e-05 1.5 2.4488281249999998e-05 1.5 2.4488839285714284e-05 0.0 2.4493303571428568e-05 0.0 2.4493861607142855e-05 1.5 2.450613839285714e-05 1.5 2.4506696428571427e-05 0.0 2.4511160714285714e-05 0.0 2.4511718749999997e-05 1.5 2.4523995535714282e-05 1.5 2.452455357142857e-05 0.0 2.4529017857142856e-05 0.0 2.452957589285714e-05 1.5 2.4541852678571428e-05 1.5 2.454241071428571e-05 0.0 2.4546875e-05 0.0 2.4547433035714285e-05 1.5 2.455970982142857e-05 1.5 2.4560267857142854e-05 0.0 2.456473214285714e-05 0.0 2.4565290178571428e-05 1.5 2.4577566964285713e-05 1.5 2.4578125e-05 0.0 2.4582589285714283e-05 0.0 2.458314732142857e-05 1.5 2.4595424107142855e-05 1.5 2.4595982142857142e-05 0.0 2.4600446428571426e-05 0.0 2.4601004464285712e-05 1.5 2.4613281249999997e-05 1.5 2.4613839285714284e-05 0.0 2.461830357142857e-05 0.0 2.4618861607142855e-05 1.5 2.463113839285714e-05 1.5 2.4631696428571426e-05 0.0 2.4636160714285714e-05 0.0 2.4636718749999997e-05 1.5 2.4648995535714285e-05 1.5 2.464955357142857e-05 0.0 2.4654017857142856e-05 0.0 2.4654575892857143e-05 1.5 2.4666852678571428e-05 1.5 2.466741071428571e-05 0.0 2.4671874999999998e-05 0.0 2.4672433035714285e-05 1.5 2.468470982142857e-05 1.5 2.4685267857142857e-05 0.0 2.468973214285714e-05 0.0 2.4690290178571427e-05 1.5 2.4702566964285712e-05 1.5 2.4703125e-05 0.0 2.4707589285714283e-05 0.0 2.470814732142857e-05 1.5 2.4720424107142855e-05 1.5 2.472098214285714e-05 0.0 2.4725446428571425e-05 0.0 2.4726004464285712e-05 1.5 2.4738281249999997e-05 1.5 2.4738839285714284e-05 0.0 2.474330357142857e-05 0.0 2.4743861607142854e-05 1.5 2.4756138392857143e-05 1.5 2.4756696428571426e-05 0.0 2.4761160714285713e-05 0.0 2.4761718749999997e-05 1.5 2.4773995535714285e-05 1.5 2.477455357142857e-05 0.0 2.4779017857142856e-05 0.0 2.4779575892857142e-05 1.5 2.4791852678571427e-05 1.5 2.4792410714285714e-05 0.0 2.4796874999999998e-05 0.0 2.4797433035714285e-05 1.5 2.480970982142857e-05 1.5 2.4810267857142856e-05 0.0 2.481473214285714e-05 0.0 2.4815290178571427e-05 1.5 2.4827566964285712e-05 1.5 2.4828125e-05 0.0 2.4832589285714283e-05 0.0 2.483314732142857e-05 1.5 2.4845424107142854e-05 1.5 2.484598214285714e-05 0.0 2.485044642857143e-05 0.0 2.485100446428571e-05 1.5 2.4863281249999997e-05 1.5 2.4863839285714283e-05 0.0 2.486830357142857e-05 0.0 2.4868861607142854e-05 1.5 2.4881138392857142e-05 1.5 2.4881696428571426e-05 0.0 2.4886160714285713e-05 0.0 2.488671875e-05 1.5 2.4898995535714285e-05 1.5 2.4899553571428568e-05 0.0 2.4904017857142855e-05 0.0 2.4904575892857142e-05 1.5 2.4916852678571427e-05 1.5 2.4917410714285714e-05 0.0 2.4921874999999998e-05 0.0 2.4922433035714284e-05 1.5 2.493470982142857e-05 1.5 2.4935267857142856e-05 0.0 2.493973214285714e-05 0.0 2.4940290178571427e-05 1.5 2.495256696428571e-05 1.5 2.4953125e-05 0.0 2.4957589285714282e-05 0.0 2.495814732142857e-05 1.5 2.4970424107142854e-05 1.5 2.497098214285714e-05 0.0 2.4975446428571428e-05 0.0 2.497600446428571e-05 1.5 2.498828125e-05 1.5 2.4988839285714283e-05 0.0 2.499330357142857e-05 0.0 2.4993861607142857e-05 1.5 2.5005580357142855e-05 1.5 2.5006138392857142e-05 0.0 2.501171875e-05 0.0 2.5012276785714283e-05 1.5 2.5023437499999998e-05 1.5 2.5023995535714284e-05 0.0 2.502957589285714e-05 0.0 2.503013392857143e-05 1.5 2.504129464285714e-05 1.5 2.5041852678571427e-05 0.0 2.5047433035714284e-05 0.0 2.504799107142857e-05 1.5 2.5059151785714286e-05 1.5 2.505970982142857e-05 0.0 2.5065290178571426e-05 0.0 2.5065848214285713e-05 1.5 2.5077008928571428e-05 1.5 2.507756696428571e-05 0.0 2.508314732142857e-05 0.0 2.5083705357142855e-05 1.5 2.509486607142857e-05 1.5 2.5095424107142857e-05 0.0 2.510100446428571e-05 0.0 2.5101562499999998e-05 1.5 2.5112723214285713e-05 1.5 2.511328125e-05 0.0 2.5118861607142857e-05 0.0 2.511941964285714e-05 1.5 2.5130580357142855e-05 1.5 2.513113839285714e-05 0.0 2.513671875e-05 0.0 2.5137276785714282e-05 1.5 2.5148437499999997e-05 1.5 2.5148995535714284e-05 0.0 2.515457589285714e-05 0.0 2.5155133928571428e-05 1.5 2.516629464285714e-05 1.5 2.5166852678571426e-05 0.0 2.5172433035714284e-05 0.0 2.517299107142857e-05 1.5 2.5184151785714285e-05 1.5 2.518470982142857e-05 0.0 2.5190290178571426e-05 0.0 2.5190848214285713e-05 1.5 2.5202008928571428e-05 1.5 2.520256696428571e-05 0.0 2.520814732142857e-05 0.0 2.5208705357142855e-05 1.5 2.521986607142857e-05 1.5 2.5220424107142857e-05 0.0 2.5226004464285714e-05 0.0 2.5226562499999997e-05 1.5 2.5237723214285712e-05 1.5 2.523828125e-05 0.0 2.5243861607142856e-05 0.0 2.524441964285714e-05 1.5 2.5255580357142855e-05 1.5 2.525613839285714e-05 0.0 2.526171875e-05 0.0 2.5262276785714285e-05 1.5 2.5273437499999997e-05 1.5 2.5273995535714284e-05 0.0 2.527957589285714e-05 0.0 2.5280133928571428e-05 1.5 2.5291294642857143e-05 1.5 2.5291852678571426e-05 0.0 2.5297433035714283e-05 0.0 2.529799107142857e-05 1.5 2.5309151785714285e-05 1.5 2.5309709821428568e-05 0.0 2.5315290178571426e-05 0.0 2.5315848214285712e-05 1.5 2.5327008928571427e-05 1.5 2.5327566964285714e-05 0.0 2.5333147321428568e-05 0.0 2.5333705357142855e-05 1.5 2.534486607142857e-05 1.5 2.5345424107142856e-05 0.0 2.5351004464285714e-05 0.0 2.5351562499999997e-05 1.5 2.5362723214285712e-05 1.5 2.536328125e-05 0.0 2.5368861607142856e-05 0.0 2.536941964285714e-05 1.5 2.5380580357142854e-05 1.5 2.538113839285714e-05 0.0 2.538671875e-05 0.0 2.5387276785714285e-05 1.5 2.53984375e-05 1.5 2.5398995535714283e-05 0.0 2.540457589285714e-05 0.0 2.5405133928571427e-05 1.5 2.5415736607142855e-05 1.5 2.5416294642857142e-05 0.0 2.542299107142857e-05 0.0 2.5423549107142856e-05 1.5 2.5433593749999998e-05 1.5 2.5434151785714285e-05 0.0 2.5440848214285712e-05 0.0 2.544140625e-05 1.5 2.545145089285714e-05 1.5 2.5452008928571427e-05 0.0 2.5458705357142854e-05 0.0 2.545926339285714e-05 1.5 2.5469308035714282e-05 1.5 2.546986607142857e-05 0.0 2.5476562499999997e-05 0.0 2.5477120535714283e-05 1.5 2.5487165178571428e-05 1.5 2.548772321428571e-05 0.0 2.5494419642857142e-05 0.0 2.5494977678571426e-05 1.5 2.550502232142857e-05 1.5 2.5505580357142854e-05 0.0 2.5512276785714285e-05 0.0 2.5512834821428568e-05 1.5 2.5522879464285713e-05 1.5 2.55234375e-05 0.0 2.5530133928571427e-05 0.0 2.5530691964285714e-05 1.5 2.5540736607142855e-05 1.5 2.5541294642857142e-05 0.0 2.554799107142857e-05 0.0 2.5548549107142856e-05 1.5 2.5558593749999997e-05 1.5 2.5559151785714284e-05 0.0 2.556584821428571e-05 0.0 2.556640625e-05 1.5 2.557645089285714e-05 1.5 2.5577008928571426e-05 0.0 2.5583705357142854e-05 0.0 2.558426339285714e-05 1.5 2.5594308035714285e-05 1.5 2.559486607142857e-05 0.0 2.56015625e-05 0.0 2.5602120535714283e-05 1.5 2.5612165178571428e-05 1.5 2.561272321428571e-05 0.0 2.5619419642857142e-05 0.0 2.5619977678571425e-05 1.5 2.563002232142857e-05 1.5 2.5630580357142857e-05 0.0 2.5637276785714284e-05 0.0 2.563783482142857e-05 1.5 2.5647879464285712e-05 1.5 2.56484375e-05 0.0 2.5655133928571427e-05 0.0 2.5655691964285713e-05 1.5 2.5665736607142855e-05 1.5 2.566629464285714e-05 0.0 2.567299107142857e-05 0.0 2.5673549107142856e-05 1.5 2.5683593749999997e-05 1.5 2.5684151785714284e-05 0.0 2.569084821428571e-05 0.0 2.5691406249999998e-05 1.5 2.570145089285714e-05 1.5 2.5702008928571426e-05 0.0 2.5708705357142854e-05 0.0 2.570926339285714e-05 1.5 2.5719308035714285e-05 1.5 2.571986607142857e-05 0.0 2.57265625e-05 0.0 2.5727120535714283e-05 1.5 2.5737165178571427e-05 1.5 2.573772321428571e-05 0.0 2.5744419642857142e-05 0.0 2.5744977678571425e-05 1.5 2.575502232142857e-05 1.5 2.5755580357142856e-05 0.0 2.576283482142857e-05 0.0 2.5763392857142854e-05 1.5 2.5772321428571425e-05 1.5 2.5772879464285712e-05 0.0 2.5780691964285713e-05 0.0 2.5781249999999996e-05 1.5 2.579017857142857e-05 1.5 2.5790736607142854e-05 0.0 2.5798549107142855e-05 0.0 2.5799107142857142e-05 1.5 2.5808035714285713e-05 1.5 2.5808593749999997e-05 0.0 2.5816406249999998e-05 0.0 2.5816964285714285e-05 1.5 2.5825892857142856e-05 1.5 2.5826450892857142e-05 0.0 2.583426339285714e-05 0.0 2.5834821428571427e-05 1.5 2.5843749999999998e-05 1.5 2.5844308035714285e-05 0.0 2.5852120535714282e-05 0.0 2.585267857142857e-05 1.5 2.586160714285714e-05 1.5 2.5862165178571427e-05 0.0 2.5869977678571428e-05 0.0 2.587053571428571e-05 1.5 2.5879464285714283e-05 1.5 2.588002232142857e-05 0.0 2.588783482142857e-05 0.0 2.5888392857142854e-05 1.5 2.589732142857143e-05 1.5 2.5897879464285712e-05 0.0 2.5905691964285713e-05 0.0 2.590625e-05 1.5 2.591517857142857e-05 1.5 2.5915736607142854e-05 0.0 2.5923549107142855e-05 0.0 2.5924107142857142e-05 1.5 2.5933035714285713e-05 1.5 2.593359375e-05 0.0 2.5941406249999997e-05 0.0 2.5941964285714284e-05 1.5 2.5950892857142855e-05 1.5 2.5951450892857142e-05 0.0 2.595926339285714e-05 0.0 2.5959821428571426e-05 1.5 2.5968749999999998e-05 1.5 2.5969308035714284e-05 0.0 2.5977120535714285e-05 0.0 2.597767857142857e-05 1.5 2.598660714285714e-05 1.5 2.5987165178571427e-05 0.0 2.5994977678571428e-05 0.0 2.599553571428571e-05 1.5 2.6004464285714282e-05 1.5 2.600502232142857e-05 0.0 2.601283482142857e-05 0.0 2.6013392857142857e-05 1.5 2.6022321428571428e-05 1.5 2.602287946428571e-05 0.0 2.6030691964285712e-05 0.0 2.603125e-05 1.5 2.604017857142857e-05 1.5 2.6040736607142854e-05 0.0 2.6048549107142855e-05 0.0 2.604910714285714e-05 1.5 2.6058035714285713e-05 1.5 2.605859375e-05 0.0 2.6066406249999997e-05 0.0 2.6066964285714284e-05 1.5 2.6075892857142855e-05 1.5 2.6076450892857142e-05 0.0 2.6084821428571426e-05 0.0 2.6085379464285713e-05 1.5 2.6093191964285714e-05 1.5 2.6093749999999997e-05 0.0 2.610267857142857e-05 0.0 2.6103236607142855e-05 1.5 2.6111049107142856e-05 1.5 2.611160714285714e-05 0.0 2.612053571428571e-05 0.0 2.6121093749999998e-05 1.5 2.612890625e-05 1.5 2.6129464285714285e-05 0.0 2.6138392857142856e-05 0.0 2.613895089285714e-05 1.5 2.614676339285714e-05 1.5 2.6147321428571428e-05 0.0 2.615625e-05 0.0 2.6156808035714282e-05 1.5 2.6164620535714283e-05 1.5 2.616517857142857e-05 0.0 2.617410714285714e-05 0.0 2.6174665178571428e-05 1.5 2.6182477678571426e-05 1.5 2.6183035714285712e-05 0.0 2.6191964285714283e-05 0.0 2.619252232142857e-05 1.5 2.6200334821428568e-05 1.5 2.6200892857142855e-05 0.0 2.6209821428571426e-05 0.0 2.6210379464285713e-05 1.5 2.6218191964285714e-05 1.5 2.6218749999999997e-05 0.0 2.6227678571428568e-05 0.0 2.6228236607142855e-05 1.5 2.6236049107142856e-05 1.5 2.6236607142857143e-05 0.0 2.6245535714285714e-05 0.0 2.6246093749999997e-05 1.5 2.6253906249999998e-05 1.5 2.6254464285714285e-05 0.0 2.6263392857142856e-05 0.0 2.626395089285714e-05 1.5 2.627176339285714e-05 1.5 2.6272321428571427e-05 0.0 2.628125e-05 0.0 2.6281808035714285e-05 1.5 2.6289620535714283e-05 1.5 2.629017857142857e-05 0.0 2.629910714285714e-05 0.0 2.6299665178571428e-05 1.5 2.6307477678571425e-05 1.5 2.6308035714285712e-05 0.0 2.6316964285714283e-05 0.0 2.631752232142857e-05 1.5 2.632533482142857e-05 1.5 2.6325892857142854e-05 0.0 2.6334821428571425e-05 0.0 2.6335379464285712e-05 1.5 2.6343191964285713e-05 1.5 2.6343749999999997e-05 0.0 2.635267857142857e-05 0.0 2.6353236607142855e-05 1.5 2.6361049107142856e-05 1.5 2.6361607142857142e-05 0.0 2.6370535714285713e-05 0.0 2.6371093749999997e-05 1.5 2.6378906249999998e-05 1.5 2.6379464285714285e-05 0.0 2.6388392857142856e-05 0.0 2.6388950892857143e-05 1.5 2.639676339285714e-05 1.5 2.6397321428571427e-05 0.0 2.6406808035714285e-05 0.0 2.6407366071428568e-05 1.5 2.64140625e-05 1.5 2.6414620535714283e-05 0.0 2.6424665178571427e-05 0.0 2.6425223214285714e-05 1.5 2.643191964285714e-05 1.5 2.6432477678571428e-05 0.0 2.644252232142857e-05 0.0 2.6443080357142856e-05 1.5 2.6449776785714284e-05 1.5 2.645033482142857e-05 0.0 2.6460379464285712e-05 0.0 2.64609375e-05 1.5 2.6467633928571426e-05 1.5 2.6468191964285713e-05 0.0 2.6478236607142854e-05 0.0 2.647879464285714e-05 1.5 2.648549107142857e-05 1.5 2.6486049107142855e-05 0.0 2.6496093749999996e-05 0.0 2.6496651785714283e-05 1.5 2.650334821428571e-05 1.5 2.6503906249999998e-05 0.0 2.6513950892857142e-05 0.0 2.6514508928571426e-05 1.5 2.6521205357142856e-05 1.5 2.652176339285714e-05 0.0 2.6531808035714285e-05 0.0 2.6532366071428568e-05 1.5 2.65390625e-05 1.5 2.6539620535714282e-05 0.0 2.6549665178571427e-05 0.0 2.6550223214285714e-05 1.5 2.655691964285714e-05 1.5 2.6557477678571428e-05 0.0 2.656752232142857e-05 0.0 2.6568080357142856e-05 1.5 2.6574776785714283e-05 1.5 2.657533482142857e-05 0.0 2.658537946428571e-05 0.0 2.6585937499999998e-05 1.5 2.6592633928571426e-05 1.5 2.6593191964285713e-05 0.0 2.6603236607142854e-05 0.0 2.660379464285714e-05 1.5 2.6610491071428568e-05 1.5 2.6611049107142855e-05 0.0 2.662109375e-05 0.0 2.6621651785714283e-05 1.5 2.6628348214285714e-05 1.5 2.6628906249999997e-05 0.0 2.6638950892857142e-05 0.0 2.6639508928571425e-05 1.5 2.6646205357142856e-05 1.5 2.664676339285714e-05 0.0 2.6656808035714284e-05 0.0 2.665736607142857e-05 1.5 2.66640625e-05 1.5 2.6664620535714285e-05 0.0 2.6674665178571426e-05 0.0 2.6675223214285713e-05 1.5 2.668191964285714e-05 1.5 2.6682477678571428e-05 0.0 2.669252232142857e-05 0.0 2.6693080357142856e-05 1.5 2.6699776785714283e-05 1.5 2.670033482142857e-05 0.0 2.671037946428571e-05 0.0 2.6710937499999998e-05 1.5 2.6717633928571425e-05 1.5 2.6718191964285712e-05 0.0 2.6728236607142857e-05 0.0 2.672879464285714e-05 1.5 2.673549107142857e-05 1.5 2.6736049107142854e-05 0.0 2.674609375e-05 0.0 2.6746651785714283e-05 1.5 2.6752790178571427e-05 1.5 2.6753348214285713e-05 0.0 2.6764508928571428e-05 0.0 2.676506696428571e-05 1.5 2.677064732142857e-05 1.5 2.6771205357142856e-05 0.0 2.678236607142857e-05 0.0 2.6782924107142854e-05 1.5 2.678850446428571e-05 1.5 2.6789062499999998e-05 0.0 2.6800223214285713e-05 0.0 2.680078125e-05 1.5 2.6806361607142854e-05 1.5 2.680691964285714e-05 0.0 2.6818080357142855e-05 0.0 2.6818638392857142e-05 1.5 2.682421875e-05 1.5 2.6824776785714283e-05 0.0 2.6835937499999998e-05 0.0 2.6836495535714284e-05 1.5 2.6842075892857142e-05 1.5 2.6842633928571425e-05 0.0 2.685379464285714e-05 0.0 2.6854352678571427e-05 1.5 2.6859933035714284e-05 1.5 2.686049107142857e-05 0.0 2.6871651785714282e-05 0.0 2.687220982142857e-05 1.5 2.6877790178571426e-05 1.5 2.6878348214285713e-05 0.0 2.6889508928571428e-05 0.0 2.689006696428571e-05 1.5 2.689564732142857e-05 1.5 2.6896205357142855e-05 0.0 2.690736607142857e-05 0.0 2.6907924107142854e-05 1.5 2.691350446428571e-05 1.5 2.6914062499999998e-05 0.0 2.6925223214285713e-05 0.0 2.692578125e-05 1.5 2.6931361607142857e-05 1.5 2.693191964285714e-05 0.0 2.6943080357142855e-05 0.0 2.694363839285714e-05 1.5 2.694921875e-05 1.5 2.6949776785714282e-05 0.0 2.6960937499999997e-05 0.0 2.6961495535714284e-05 1.5 2.696707589285714e-05 1.5 2.6967633928571428e-05 0.0 2.697879464285714e-05 0.0 2.6979352678571426e-05 1.5 2.6984933035714284e-05 1.5 2.698549107142857e-05 0.0 2.6996651785714285e-05 0.0 2.699720982142857e-05 1.5 2.7002790178571426e-05 1.5 2.7003348214285713e-05 0.0 2.7014508928571428e-05 0.0 2.701506696428571e-05 1.5 2.702064732142857e-05 1.5 2.7021205357142855e-05 0.0 2.703236607142857e-05 0.0 2.7032924107142857e-05 1.5 2.7038504464285714e-05 1.5 2.7039062499999997e-05 0.0 2.7050223214285712e-05 0.0 2.705078125e-05 1.5 2.7056361607142856e-05 1.5 2.705691964285714e-05 0.0 2.7068080357142855e-05 0.0 2.706863839285714e-05 1.5 2.707421875e-05 1.5 2.7074776785714285e-05 0.0 2.7085937499999997e-05 0.0 2.7086495535714284e-05 1.5 2.709207589285714e-05 1.5 2.7092633928571428e-05 0.0 2.7103794642857143e-05 0.0 2.7104352678571426e-05 1.5 2.7109933035714283e-05 1.5 2.711049107142857e-05 0.0 2.7121651785714285e-05 0.0 2.7122209821428568e-05 1.5 2.7127790178571426e-05 1.5 2.7128348214285712e-05 0.0 2.7139508928571427e-05 0.0 2.7140066964285714e-05 1.5 2.7145647321428568e-05 1.5 2.7146205357142855e-05 0.0 2.715736607142857e-05 0.0 2.7157924107142856e-05 1.5 2.7163504464285714e-05 1.5 2.7164062499999997e-05 0.0 2.717578125e-05 0.0 2.7176339285714285e-05 1.5 2.718080357142857e-05 1.5 2.7181361607142856e-05 0.0 2.719363839285714e-05 0.0 2.7194196428571428e-05 1.5 2.719866071428571e-05 1.5 2.719921875e-05 0.0 2.7211495535714283e-05 0.0 2.721205357142857e-05 1.5 2.7216517857142854e-05 1.5 2.721707589285714e-05 0.0 2.7229352678571426e-05 0.0 2.7229910714285712e-05 1.5 2.7234375e-05 1.5 2.7234933035714283e-05 0.0 2.7247209821428568e-05 0.0 2.7247767857142855e-05 1.5 2.7252232142857142e-05 1.5 2.7252790178571425e-05 0.0 2.7265066964285714e-05 0.0 2.7265624999999997e-05 1.5 2.7270089285714284e-05 1.5 2.727064732142857e-05 0.0 2.7282924107142856e-05 0.0 2.728348214285714e-05 1.5 2.7287946428571427e-05 1.5 2.7288504464285713e-05 0.0 2.7300781249999998e-05 0.0 2.7301339285714285e-05 1.5 2.730580357142857e-05 1.5 2.7306361607142856e-05 0.0 2.731863839285714e-05 0.0 2.7319196428571427e-05 1.5 2.732366071428571e-05 1.5 2.7324218749999998e-05 0.0 2.7336495535714283e-05 0.0 2.733705357142857e-05 1.5 2.7341517857142854e-05 1.5 2.734207589285714e-05 0.0 2.7354352678571425e-05 0.0 2.7354910714285712e-05 1.5 2.7359375e-05 1.5 2.7359933035714283e-05 0.0 2.737220982142857e-05 0.0 2.7372767857142854e-05 1.5 2.737723214285714e-05 1.5 2.7377790178571425e-05 0.0 2.7390066964285713e-05 0.0 2.7390624999999997e-05 1.5 2.7395089285714284e-05 1.5 2.739564732142857e-05 0.0 2.7407924107142856e-05 0.0 2.7408482142857142e-05 1.5 2.7412946428571426e-05 1.5 2.7413504464285713e-05 0.0 2.7425781249999998e-05 0.0 2.7426339285714285e-05 1.5 2.743080357142857e-05 1.5 2.7431361607142855e-05 0.0 2.744363839285714e-05 0.0 2.7444196428571427e-05 1.5 2.744866071428571e-05 1.5 2.7449218749999998e-05 0.0 2.7461495535714283e-05 0.0 2.746205357142857e-05 1.5 2.7466517857142857e-05 1.5 2.746707589285714e-05 0.0 2.7479352678571428e-05 0.0 2.747991071428571e-05 1.5 2.7484375e-05 1.5 2.7484933035714282e-05 0.0 2.749720982142857e-05 0.0 2.7497767857142854e-05 1.5 2.750223214285714e-05 1.5 2.7502790178571428e-05 0.0 2.7515066964285713e-05 0.0 2.7515625e-05 1.5 2.7520089285714284e-05 1.5 2.752064732142857e-05 0.0 2.7532924107142855e-05 0.0 2.7533482142857142e-05 1.5 2.7537946428571426e-05 1.5 2.7538504464285713e-05 0.0 2.7550781249999998e-05 0.0 2.7551339285714284e-05 1.5 2.7555803571428568e-05 1.5 2.7556361607142855e-05 0.0 2.756863839285714e-05 0.0 2.7569196428571427e-05 1.5 2.7573660714285714e-05 1.5 2.7574218749999997e-05 0.0 2.7586495535714282e-05 0.0 2.758705357142857e-05 1.5 2.7591517857142856e-05 1.5 2.759207589285714e-05 0.0 2.7604352678571428e-05 0.0 2.760491071428571e-05 1.5 2.7609375e-05 1.5 2.7609933035714285e-05 0.0 2.762220982142857e-05 0.0 2.7622767857142854e-05 1.5 2.762723214285714e-05 1.5 2.7627790178571428e-05 0.0 2.7640066964285713e-05 0.0 2.7640625e-05 1.5 2.7645089285714283e-05 1.5 2.764564732142857e-05 0.0 2.7657924107142855e-05 0.0 2.765848214285714e-05 1.5 2.7662946428571426e-05 1.5 2.7663504464285712e-05 0.0 2.7675781249999997e-05 0.0 2.7676339285714284e-05 1.5 2.7680803571428568e-05 1.5 2.7681361607142855e-05 0.0 2.769363839285714e-05 0.0 2.7694196428571426e-05 1.5 2.7698660714285714e-05 1.5 2.7699218749999997e-05 0.0 2.7711495535714285e-05 0.0 2.771205357142857e-05 1.5 2.7716517857142856e-05 1.5 2.771707589285714e-05 0.0 2.7729352678571428e-05 0.0 2.772991071428571e-05 1.5 2.7734374999999998e-05 1.5 2.7734933035714285e-05 0.0 2.774720982142857e-05 0.0 2.7747767857142857e-05 1.5 2.775223214285714e-05 1.5 2.7752790178571427e-05 0.0 2.7765066964285712e-05 0.0 2.7765625e-05 1.5 2.7770089285714283e-05 1.5 2.777064732142857e-05 0.0 2.7782924107142855e-05 0.0 2.778348214285714e-05 1.5 2.7787946428571425e-05 1.5 2.7788504464285712e-05 0.0 2.7800781249999997e-05 0.0 2.7801339285714284e-05 1.5 2.780580357142857e-05 1.5 2.7806361607142854e-05 0.0 2.781863839285714e-05 0.0 2.7819196428571426e-05 1.5 2.7823660714285713e-05 1.5 2.7824218749999997e-05 0.0 2.7836495535714285e-05 0.0 2.7837053571428568e-05 1.5 2.7841517857142856e-05 1.5 2.7842075892857142e-05 0.0 2.7854352678571427e-05 0.0 2.7854910714285714e-05 1.5 2.7859374999999998e-05 1.5 2.7859933035714285e-05 0.0 2.787220982142857e-05 0.0 2.7872767857142856e-05 1.5 2.787723214285714e-05 1.5 2.7877790178571427e-05 0.0 2.7890066964285712e-05 0.0 2.7890625e-05 1.5 2.7895089285714283e-05 1.5 2.789564732142857e-05 0.0 2.7907924107142854e-05 0.0 2.790848214285714e-05 1.5 2.7912946428571428e-05 1.5 2.791350446428571e-05 0.0 2.7925781249999997e-05 0.0 2.7926339285714283e-05 1.5 2.793080357142857e-05 1.5 2.7931361607142854e-05 0.0 2.7943638392857142e-05 0.0 2.7944196428571426e-05 1.5 2.7948660714285713e-05 1.5 2.794921875e-05 0.0 2.7961495535714285e-05 0.0 2.7962053571428568e-05 1.5 2.7966517857142855e-05 1.5 2.7967075892857142e-05 0.0 2.7979352678571427e-05 0.0 2.7979910714285714e-05 1.5 2.7984374999999998e-05 1.5 2.7984933035714284e-05 0.0 2.799720982142857e-05 0.0 2.7997767857142856e-05 1.5 2.800223214285714e-05 1.5 2.8002790178571427e-05 0.0 2.801506696428571e-05 0.0 2.8015624999999998e-05 1.5 2.8020089285714282e-05 1.5 2.802064732142857e-05 0.0 2.8032924107142854e-05 0.0 2.803348214285714e-05 1.5 2.8037946428571428e-05 1.5 2.803850446428571e-05 0.0 2.805078125e-05 0.0 2.8051339285714283e-05 1.5 2.805580357142857e-05 1.5 2.8056361607142854e-05 0.0 2.8068638392857142e-05 0.0 2.8069196428571425e-05 1.5 2.8073660714285713e-05 1.5 2.807421875e-05 0.0 2.8086495535714284e-05 0.0 2.808705357142857e-05 1.5 2.8091517857142855e-05 1.5 2.809207589285714e-05 0.0 2.8104352678571427e-05 0.0 2.8104910714285713e-05 1.5 2.8109374999999997e-05 1.5 2.8109933035714284e-05 0.0 2.812220982142857e-05 0.0 2.8122767857142856e-05 1.5 2.812723214285714e-05 1.5 2.8127790178571426e-05 0.0 2.814006696428571e-05 0.0 2.8140624999999998e-05 1.5 2.8145089285714285e-05 1.5 2.814564732142857e-05 0.0 2.8157924107142853e-05 0.0 2.815848214285714e-05 1.5 2.8162946428571428e-05 1.5 2.816350446428571e-05 0.0 2.817578125e-05 0.0 2.8176339285714283e-05 1.5 2.818080357142857e-05 1.5 2.8181361607142857e-05 0.0 2.819363839285714e-05 0.0 2.8194196428571425e-05 1.5 2.8198660714285712e-05 1.5 2.819921875e-05 0.0 2.8211495535714284e-05 0.0 2.821205357142857e-05 1.5 2.8216517857142854e-05 1.5 2.821707589285714e-05 0.0 2.8229352678571426e-05 0.0 2.8229910714285713e-05 1.5 2.8234374999999997e-05 1.5 2.8234933035714284e-05 0.0 2.824720982142857e-05 0.0 2.8247767857142855e-05 1.5 2.8252232142857143e-05 1.5 2.8252790178571426e-05 0.0 2.826506696428571e-05 0.0 2.8265624999999998e-05 1.5 2.8270089285714285e-05 1.5 2.8270647321428568e-05 0.0 2.8282924107142857e-05 0.0 2.828348214285714e-05 1.5 2.8287946428571427e-05 1.5 2.8288504464285714e-05 0.0 2.830078125e-05 0.0 2.8301339285714282e-05 1.5 2.830580357142857e-05 1.5 2.8306361607142856e-05 0.0 2.831863839285714e-05 0.0 2.8319196428571428e-05 1.5 2.8323660714285712e-05 1.5 2.832421875e-05 0.0 2.8336495535714283e-05 0.0 2.833705357142857e-05 1.5 2.8341517857142854e-05 1.5 2.834207589285714e-05 0.0 2.8354352678571426e-05 0.0 2.8354910714285713e-05 1.5 2.8359374999999996e-05 1.5 2.8359933035714283e-05 0.0 2.8372209821428568e-05 0.0 2.8372767857142855e-05 1.5 2.8377232142857142e-05 1.5 2.8377790178571426e-05 0.0 2.8390066964285714e-05 0.0 2.8390624999999997e-05 1.5 2.8395089285714284e-05 1.5 2.8395647321428568e-05 0.0 2.8407924107142856e-05 0.0 2.840848214285714e-05 1.5 2.8412946428571427e-05 1.5 2.8413504464285714e-05 0.0 2.842578125e-05 0.0 2.8426339285714285e-05 1.5 2.843080357142857e-05 1.5 2.8431361607142856e-05 0.0 2.844363839285714e-05 0.0 2.8444196428571428e-05 1.5 2.844866071428571e-05 1.5 2.8449218749999998e-05 0.0 2.8461495535714283e-05 0.0 2.846205357142857e-05 1.5 2.8466517857142854e-05 1.5 2.846707589285714e-05 0.0 2.8479352678571425e-05 0.0 2.8479910714285712e-05 1.5 2.8484375e-05 1.5 2.8484933035714283e-05 0.0 2.8497209821428568e-05 0.0 2.8497767857142855e-05 1.5 2.8502232142857142e-05 1.5 2.8502790178571425e-05 0.0 2.8515066964285713e-05 0.0 2.8515624999999997e-05 1.5 2.8520089285714284e-05 1.5 2.852064732142857e-05 0.0 2.8532924107142856e-05 0.0 2.853348214285714e-05 1.5 2.8537946428571426e-05 1.5 2.8538504464285713e-05 0.0 2.8550781249999998e-05 0.0 2.8551339285714285e-05 1.5 2.855580357142857e-05 1.5 2.8556361607142856e-05 0.0 2.856863839285714e-05 0.0 2.8569196428571427e-05 1.5 2.857366071428571e-05 1.5 2.8574218749999998e-05 0.0 2.8586495535714283e-05 0.0 2.858705357142857e-05 1.5 2.8591517857142853e-05 1.5 2.859207589285714e-05 0.0 2.8604352678571425e-05 0.0 2.8604910714285712e-05 1.5 2.8609375e-05 1.5 2.8609933035714283e-05 0.0 2.862220982142857e-05 0.0 2.8622767857142854e-05 1.5 2.862723214285714e-05 1.5 2.8627790178571425e-05 0.0 2.8640066964285713e-05 0.0 2.8640624999999997e-05 1.5 2.8645089285714284e-05 1.5 2.864564732142857e-05 0.0 2.8657924107142855e-05 0.0 2.8658482142857142e-05 1.5 2.8662946428571426e-05 1.5 2.8663504464285713e-05 0.0 2.8675781249999998e-05 0.0 2.8676339285714285e-05 1.5 2.868080357142857e-05 1.5 2.8681361607142855e-05 0.0 2.869363839285714e-05 0.0 2.8694196428571427e-05 1.5 2.869866071428571e-05 1.5 2.8699218749999998e-05 0.0 2.8711495535714282e-05 0.0 2.871205357142857e-05 1.5 2.8716517857142856e-05 1.5 2.871707589285714e-05 0.0 2.8729352678571428e-05 0.0 2.872991071428571e-05 1.5 2.8734375e-05 1.5 2.8734933035714282e-05 0.0 2.874720982142857e-05 0.0 2.8747767857142854e-05 1.5 2.875223214285714e-05 1.5 2.8752790178571428e-05 0.0 2.8765066964285713e-05 0.0 2.8765625e-05 1.5 2.8770089285714283e-05 1.5 2.877064732142857e-05 0.0 2.8782924107142855e-05 0.0 2.8783482142857142e-05 1.5 2.8787946428571426e-05 1.5 2.8788504464285713e-05 0.0 2.8800781249999997e-05 0.0 2.8801339285714284e-05 1.5 2.8805803571428568e-05 1.5 2.8806361607142855e-05 0.0 2.881863839285714e-05 0.0 2.8819196428571427e-05 1.5 2.8823660714285714e-05 1.5 2.8824218749999997e-05 0.0 2.8836495535714282e-05 0.0 2.883705357142857e-05 1.5 2.8841517857142856e-05 1.5 2.884207589285714e-05 0.0 2.8854352678571428e-05 0.0 2.885491071428571e-05 1.5 2.8859375e-05 1.5 2.8859933035714285e-05 0.0 2.887220982142857e-05 0.0 2.8872767857142853e-05 1.5 2.887723214285714e-05 1.5 2.8877790178571428e-05 0.0 2.8890066964285712e-05 0.0 2.8890625e-05 1.5 2.8895089285714283e-05 1.5 2.889564732142857e-05 0.0 2.8907924107142855e-05 0.0 2.890848214285714e-05 1.5 2.8912946428571425e-05 1.5 2.8913504464285712e-05 0.0 2.8925781249999997e-05 0.0 2.8926339285714284e-05 1.5 2.8930803571428568e-05 1.5 2.8931361607142854e-05 0.0 2.894363839285714e-05 0.0 2.8944196428571426e-05 1.5 2.8948660714285713e-05 1.5 2.8949218749999997e-05 0.0 2.8961495535714285e-05 0.0 2.896205357142857e-05 1.5 2.8966517857142856e-05 1.5 2.896707589285714e-05 0.0 2.8979352678571427e-05 0.0 2.897991071428571e-05 1.5 2.8984374999999998e-05 1.5 2.8984933035714285e-05 0.0 2.899720982142857e-05 0.0 2.8997767857142857e-05 1.5 2.900223214285714e-05 1.5 2.9002790178571427e-05 0.0 2.9014508928571425e-05 0.0 2.9015066964285712e-05 1.5 2.902064732142857e-05 1.5 2.9021205357142856e-05 0.0 2.9032366071428568e-05 0.0 2.9032924107142854e-05 1.5 2.9038504464285712e-05 1.5 2.90390625e-05 0.0 2.9050223214285713e-05 0.0 2.9050781249999997e-05 1.5 2.9056361607142854e-05 1.5 2.905691964285714e-05 0.0 2.9068080357142856e-05 0.0 2.9068638392857142e-05 1.5 2.9074218749999996e-05 1.5 2.9074776785714283e-05 0.0 2.9085937499999998e-05 0.0 2.9086495535714285e-05 1.5 2.9092075892857142e-05 1.5 2.9092633928571426e-05 0.0 2.910379464285714e-05 0.0 2.9104352678571427e-05 1.5 2.9109933035714285e-05 1.5 2.9110491071428568e-05 0.0 2.9121651785714283e-05 0.0 2.912220982142857e-05 1.5 2.9127790178571427e-05 1.5 2.9128348214285714e-05 0.0 2.9139508928571425e-05 0.0 2.9140066964285712e-05 1.5 2.914564732142857e-05 1.5 2.9146205357142856e-05 0.0 2.915736607142857e-05 0.0 2.9157924107142854e-05 1.5 2.916350446428571e-05 1.5 2.9164062499999998e-05 0.0 2.9175223214285713e-05 0.0 2.9175781249999996e-05 1.5 2.9181361607142854e-05 1.5 2.918191964285714e-05 0.0 2.9193080357142855e-05 0.0 2.9193638392857142e-05 1.5 2.919921875e-05 1.5 2.9199776785714283e-05 0.0 2.9210937499999998e-05 0.0 2.9211495535714284e-05 1.5 2.9217075892857142e-05 1.5 2.9217633928571425e-05 0.0 2.922879464285714e-05 0.0 2.9229352678571427e-05 1.5 2.9234933035714284e-05 1.5 2.923549107142857e-05 0.0 2.9246651785714282e-05 0.0 2.924720982142857e-05 1.5 2.9252790178571426e-05 1.5 2.9253348214285713e-05 0.0 2.9264508928571428e-05 0.0 2.926506696428571e-05 1.5 2.927064732142857e-05 1.5 2.9271205357142856e-05 0.0 2.928236607142857e-05 0.0 2.9282924107142854e-05 1.5 2.928850446428571e-05 1.5 2.9289062499999998e-05 0.0 2.9300223214285713e-05 0.0 2.930078125e-05 1.5 2.9306361607142853e-05 1.5 2.930691964285714e-05 0.0 2.9318080357142855e-05 0.0 2.9318638392857142e-05 1.5 2.932421875e-05 1.5 2.9324776785714283e-05 0.0 2.9335937499999997e-05 0.0 2.9336495535714284e-05 1.5 2.934207589285714e-05 1.5 2.9342633928571425e-05 0.0 2.935379464285714e-05 0.0 2.9354352678571426e-05 1.5 2.9359933035714284e-05 1.5 2.936049107142857e-05 0.0 2.9371651785714282e-05 0.0 2.937220982142857e-05 1.5 2.9377790178571426e-05 1.5 2.9378348214285713e-05 0.0 2.9389508928571428e-05 0.0 2.939006696428571e-05 1.5 2.939564732142857e-05 1.5 2.9396205357142855e-05 0.0 2.940736607142857e-05 0.0 2.9407924107142853e-05 1.5 2.941350446428571e-05 1.5 2.9414062499999998e-05 0.0 2.9425223214285712e-05 0.0 2.942578125e-05 1.5 2.943191964285714e-05 1.5 2.9432477678571427e-05 0.0 2.9442522321428568e-05 0.0 2.9443080357142855e-05 1.5 2.9449776785714282e-05 1.5 2.945033482142857e-05 0.0 2.9460379464285714e-05 0.0 2.9460937499999997e-05 1.5 2.9467633928571428e-05 1.5 2.946819196428571e-05 0.0 2.9478236607142856e-05 0.0 2.947879464285714e-05 1.5 2.948549107142857e-05 1.5 2.9486049107142854e-05 0.0 2.9496093749999998e-05 0.0 2.9496651785714285e-05 1.5 2.9503348214285713e-05 1.5 2.950390625e-05 0.0 2.951395089285714e-05 0.0 2.9514508928571427e-05 1.5 2.9521205357142855e-05 1.5 2.952176339285714e-05 0.0 2.9531808035714283e-05 0.0 2.953236607142857e-05 1.5 2.9539062499999997e-05 1.5 2.9539620535714284e-05 0.0 2.9549665178571425e-05 0.0 2.9550223214285712e-05 1.5 2.955691964285714e-05 1.5 2.9557477678571426e-05 0.0 2.956752232142857e-05 0.0 2.9568080357142854e-05 1.5 2.9574776785714285e-05 1.5 2.957533482142857e-05 0.0 2.9585379464285713e-05 0.0 2.9585937499999997e-05 1.5 2.9592633928571428e-05 1.5 2.959319196428571e-05 0.0 2.9603236607142856e-05 0.0 2.9603794642857142e-05 1.5 2.961049107142857e-05 1.5 2.9611049107142857e-05 0.0 2.9621093749999998e-05 0.0 2.9621651785714285e-05 1.5 2.9628348214285712e-05 1.5 2.962890625e-05 0.0 2.963895089285714e-05 0.0 2.9639508928571427e-05 1.5 2.9646205357142855e-05 1.5 2.964676339285714e-05 0.0 2.9656808035714283e-05 0.0 2.965736607142857e-05 1.5 2.9664062499999997e-05 1.5 2.9664620535714284e-05 0.0 2.9674665178571425e-05 0.0 2.967522321428571e-05 1.5 2.968191964285714e-05 1.5 2.9682477678571426e-05 0.0 2.969252232142857e-05 0.0 2.9693080357142854e-05 1.5 2.9699776785714285e-05 1.5 2.9700334821428568e-05 0.0 2.9710379464285713e-05 0.0 2.9710937499999996e-05 1.5 2.9717633928571427e-05 1.5 2.971819196428571e-05 0.0 2.9728236607142855e-05 0.0 2.9728794642857142e-05 1.5 2.973549107142857e-05 1.5 2.9736049107142856e-05 0.0 2.9746093749999998e-05 0.0 2.9746651785714284e-05 1.5 2.9753348214285712e-05 1.5 2.975390625e-05 0.0 2.976395089285714e-05 0.0 2.9764508928571427e-05 1.5 2.9771205357142854e-05 1.5 2.977176339285714e-05 0.0 2.978125e-05 0.0 2.9781808035714282e-05 1.5 2.9789620535714283e-05 1.5 2.979017857142857e-05 0.0 2.979910714285714e-05 0.0 2.9799665178571428e-05 1.5 2.9807477678571426e-05 1.5 2.9808035714285712e-05 0.0 2.9816964285714283e-05 0.0 2.981752232142857e-05 1.5 2.9825334821428568e-05 1.5 2.9825892857142855e-05 0.0 2.9834821428571426e-05 0.0 2.9835379464285713e-05 1.5 2.9843191964285714e-05 1.5 2.9843749999999997e-05 0.0 2.9852678571428568e-05 0.0 2.9853236607142855e-05 1.5 2.9861049107142856e-05 1.5 2.986160714285714e-05 0.0 2.9870535714285714e-05 0.0 2.9871093749999997e-05 1.5 2.9878906249999998e-05 1.5 2.9879464285714285e-05 0.0 2.9888392857142856e-05 0.0 2.988895089285714e-05 1.5 2.989676339285714e-05 1.5 2.9897321428571427e-05 0.0 2.990625e-05 0.0 2.9906808035714285e-05 1.5 2.9914620535714283e-05 1.5 2.991517857142857e-05 0.0 2.992410714285714e-05 0.0 2.9924665178571428e-05 1.5 2.9932477678571425e-05 1.5 2.9933035714285712e-05 0.0 2.9941964285714283e-05 0.0 2.994252232142857e-05 1.5 2.995033482142857e-05 1.5 2.9950892857142854e-05 0.0 2.9959821428571425e-05 0.0 2.9960379464285712e-05 1.5 2.9968191964285713e-05 1.5 2.9968749999999997e-05 0.0 2.9977678571428568e-05 0.0 2.9978236607142855e-05 1.5 2.9986049107142856e-05 1.5 2.9986607142857142e-05 0.0 2.9995535714285713e-05 0.0 2.9996093749999997e-05 1.5 3.0003906249999998e-05 1.5 3.0004464285714285e-05 0.0 3.0013392857142856e-05 0.0 3.001395089285714e-05 1.5 3.002176339285714e-05 1.5 3.0022321428571427e-05 0.0 3.0031249999999998e-05 0.0 3.0031808035714285e-05 1.5 3.0039620535714283e-05 1.5 3.004017857142857e-05 0.0 3.004910714285714e-05 0.0 3.0049665178571427e-05 1.5 3.0057477678571425e-05 1.5 3.005803571428571e-05 0.0 3.0066964285714283e-05 0.0 3.006752232142857e-05 1.5 3.007533482142857e-05 1.5 3.0075892857142854e-05 0.0 3.0084821428571425e-05 0.0 3.0085379464285712e-05 1.5 3.0093191964285713e-05 1.5 3.0093749999999996e-05 0.0 3.0102120535714284e-05 0.0 3.010267857142857e-05 1.5 3.0111607142857142e-05 1.5 3.0112165178571425e-05 0.0 3.0119977678571426e-05 0.0 3.0120535714285713e-05 1.5 3.0129464285714284e-05 1.5 3.0130022321428568e-05 0.0 3.013783482142857e-05 0.0 3.0138392857142855e-05 1.5 3.0147321428571427e-05 1.5 3.0147879464285713e-05 0.0 3.015569196428571e-05 0.0 3.0156249999999998e-05 1.5 3.016517857142857e-05 1.5 3.0165736607142856e-05 0.0 3.0173549107142853e-05 0.0 3.017410714285714e-05 1.5 3.018303571428571e-05 1.5 3.0183593749999998e-05 0.0 3.019140625e-05 0.0 3.0191964285714282e-05 1.5 3.0200892857142854e-05 1.5 3.020145089285714e-05 0.0 3.020926339285714e-05 0.0 3.0209821428571425e-05 1.5 3.021875e-05 1.5 3.0219308035714283e-05 0.0 3.0227120535714284e-05 0.0 3.022767857142857e-05 1.5 3.023660714285714e-05 1.5 3.0237165178571425e-05 0.0 3.0244977678571426e-05 0.0 3.0245535714285713e-05 1.5 3.0254464285714284e-05 1.5 3.025502232142857e-05 0.0 3.026283482142857e-05 0.0 3.0263392857142855e-05 1.5 3.0272321428571426e-05 1.5 3.0272879464285713e-05 0.0 3.028069196428571e-05 0.0 3.0281249999999997e-05 1.5 3.029017857142857e-05 1.5 3.0290736607142855e-05 0.0 3.0298549107142856e-05 0.0 3.029910714285714e-05 1.5 3.030803571428571e-05 1.5 3.0308593749999998e-05 0.0 3.031640625e-05 0.0 3.0316964285714282e-05 1.5 3.0325892857142857e-05 1.5 3.032645089285714e-05 0.0 3.033426339285714e-05 0.0 3.0334821428571428e-05 1.5 3.034375e-05 1.5 3.0344308035714282e-05 0.0 3.0352120535714283e-05 0.0 3.035267857142857e-05 1.5 3.036160714285714e-05 1.5 3.0362165178571428e-05 0.0 3.0369977678571426e-05 0.0 3.0370535714285712e-05 1.5 3.0379464285714284e-05 1.5 3.038002232142857e-05 0.0 3.0387834821428568e-05 0.0 3.0388392857142855e-05 1.5 3.0397321428571426e-05 1.5 3.0397879464285713e-05 0.0 3.0405691964285714e-05 0.0 3.0406249999999997e-05 1.5 3.0415178571428568e-05 1.5 3.0415736607142855e-05 0.0 3.042299107142857e-05 0.0 3.0423549107142856e-05 1.5 3.0433593749999997e-05 1.5 3.0434151785714284e-05 0.0 3.044084821428571e-05 0.0 3.044140625e-05 1.5 3.045145089285714e-05 1.5 3.0452008928571426e-05 0.0 3.0458705357142854e-05 0.0 3.045926339285714e-05 1.5 3.0469308035714282e-05 1.5 3.046986607142857e-05 0.0 3.0476562499999996e-05 0.0 3.0477120535714283e-05 1.5 3.0487165178571428e-05 1.5 3.048772321428571e-05 0.0 3.0494419642857142e-05 0.0 3.0494977678571425e-05 1.5 3.050502232142857e-05 1.5 3.0505580357142853e-05 0.0 3.0512276785714284e-05 0.0 3.0512834821428568e-05 1.5 3.052287946428571e-05 1.5 3.05234375e-05 0.0 3.0530133928571427e-05 0.0 3.053069196428571e-05 1.5 3.054073660714286e-05 1.5 3.054129464285714e-05 0.0 3.054799107142857e-05 0.0 3.054854910714285e-05 1.5 3.055859375e-05 1.5 3.0559151785714284e-05 0.0 3.056584821428571e-05 0.0 3.0566406249999995e-05 1.5 3.057645089285714e-05 1.5 3.0577008928571426e-05 0.0 3.0583705357142854e-05 0.0 3.0584263392857144e-05 1.5 3.0594308035714285e-05 1.5 3.059486607142857e-05 0.0 3.0601562499999996e-05 0.0 3.0602120535714286e-05 1.5 3.061216517857143e-05 1.5 3.061272321428571e-05 0.0 3.061941964285714e-05 0.0 3.061997767857143e-05 1.5 3.063002232142857e-05 1.5 3.063058035714285e-05 0.0 3.063727678571428e-05 0.0 3.063783482142857e-05 1.5 3.064787946428571e-05 1.5 3.0648437499999995e-05 0.0 3.065513392857143e-05 0.0 3.065569196428571e-05 1.5 3.0665736607142854e-05 1.5 3.066629464285714e-05 0.0 3.067299107142857e-05 0.0 3.0673549107142855e-05 1.5 3.068359375e-05 1.5 3.068415178571429e-05 0.0 3.0690848214285714e-05 0.0 3.069140625e-05 1.5 3.070145089285714e-05 1.5 3.070200892857143e-05 0.0 3.070870535714286e-05 0.0 3.070926339285714e-05 1.5 3.071930803571428e-05 1.5 3.071986607142857e-05 0.0 3.07265625e-05 0.0 3.072712053571428e-05 1.5 3.0737165178571424e-05 1.5 3.0737723214285714e-05 0.0 3.074441964285714e-05 0.0 3.0744977678571425e-05 1.5 3.0755022321428566e-05 1.5 3.0755580357142856e-05 0.0 3.0762276785714284e-05 0.0 3.076283482142857e-05 1.5 3.07734375e-05 1.5 3.077399553571428e-05 0.0 3.077957589285714e-05 0.0 3.0780133928571426e-05 1.5 3.079129464285714e-05 1.5 3.0791852678571424e-05 0.0 3.0797433035714285e-05 0.0 3.079799107142857e-05 1.5 3.080915178571428e-05 1.5 3.0809709821428566e-05 0.0 3.081529017857143e-05 0.0 3.081584821428571e-05 1.5 3.0827008928571425e-05 1.5 3.082756696428571e-05 0.0 3.083314732142857e-05 0.0 3.083370535714285e-05 1.5 3.084486607142857e-05 1.5 3.084542410714286e-05 0.0 3.085100446428571e-05 0.0 3.0851562499999995e-05 1.5 3.086272321428571e-05 1.5 3.086328125e-05 0.0 3.0868861607142854e-05 0.0 3.086941964285714e-05 1.5 3.088058035714285e-05 1.5 3.088113839285714e-05 0.0 3.0886718749999996e-05 0.0 3.088727678571429e-05 1.5 3.0898437499999995e-05 1.5 3.0898995535714285e-05 0.0 3.090457589285714e-05 0.0 3.090513392857143e-05 1.5 3.0916294642857144e-05 1.5 3.091685267857143e-05 0.0 3.092243303571428e-05 0.0 3.092299107142857e-05 1.5 3.0934151785714286e-05 1.5 3.093470982142857e-05 0.0 3.0940290178571423e-05 0.0 3.0940848214285714e-05 1.5 3.095200892857143e-05 1.5 3.095256696428571e-05 0.0 3.095814732142857e-05 0.0 3.0958705357142856e-05 1.5 3.096986607142857e-05 1.5 3.0970424107142854e-05 0.0 3.0976004464285715e-05 0.0 3.09765625e-05 1.5 3.098772321428571e-05 1.5 3.0988281249999996e-05 0.0 3.099386160714286e-05 0.0 3.099441964285714e-05 1.5 3.1005580357142855e-05 1.5 3.100613839285714e-05 0.0 3.101171875e-05 0.0 3.101227678571428e-05 1.5 3.10234375e-05 1.5 3.102399553571428e-05 0.0 3.102957589285714e-05 0.0 3.1030133928571425e-05 1.5 3.104129464285714e-05 1.5 3.104185267857142e-05 0.0 3.1047433035714284e-05 0.0 3.104799107142857e-05 1.5 3.105915178571428e-05 1.5 3.105970982142857e-05 0.0 3.1065290178571426e-05 0.0 3.106584821428571e-05 1.5 3.1077008928571425e-05 1.5 3.1077566964285715e-05 0.0 3.108314732142857e-05 0.0 3.108370535714285e-05 1.5 3.109486607142857e-05 1.5 3.109542410714286e-05 0.0 3.110100446428571e-05 0.0 3.1101562499999995e-05 1.5 3.111272321428571e-05 1.5 3.111328125e-05 0.0 3.1118861607142853e-05 0.0 3.1119419642857144e-05 1.5 3.113058035714285e-05 1.5 3.113113839285714e-05 0.0 3.1136718749999996e-05 0.0 3.1137276785714286e-05 1.5 3.11484375e-05 1.5 3.1148995535714284e-05 0.0 3.115457589285714e-05 0.0 3.115513392857143e-05 1.5 3.116629464285714e-05 1.5 3.1166852678571426e-05 0.0 3.117243303571428e-05 0.0 3.117299107142857e-05 1.5 3.118470982142857e-05 1.5 3.118526785714285e-05 0.0 3.118973214285714e-05 0.0 3.119029017857143e-05 1.5 3.120256696428571e-05 1.5 3.1203124999999994e-05 0.0 3.120758928571428e-05 0.0 3.120814732142857e-05 1.5 3.122042410714285e-05 1.5 3.1220982142857144e-05 0.0 3.1225446428571424e-05 0.0 3.1226004464285714e-05 1.5 3.1238281249999996e-05 1.5 3.1238839285714286e-05 0.0 3.1243303571428566e-05 0.0 3.1243861607142856e-05 1.5 3.125613839285714e-05 1.5 3.125669642857143e-05 0.0 3.126116071428571e-05 0.0 3.126171875e-05 1.5 3.127399553571428e-05 1.5 3.127455357142857e-05 0.0 3.127901785714286e-05 0.0 3.127957589285714e-05 1.5 3.129185267857143e-05 1.5 3.129241071428571e-05 0.0 3.1296875e-05 0.0 3.1297433035714283e-05 1.5 3.130970982142857e-05 1.5 3.1310267857142855e-05 0.0 3.131473214285714e-05 0.0 3.1315290178571426e-05 1.5 3.1327566964285714e-05 1.5 3.1328125e-05 0.0 3.1332589285714285e-05 0.0 3.133314732142857e-05 1.5 3.1345424107142856e-05 1.5 3.134598214285714e-05 0.0 3.135044642857143e-05 0.0 3.135100446428571e-05 1.5 3.136328125e-05 1.5 3.136383928571428e-05 0.0 3.136830357142857e-05 0.0 3.136886160714285e-05 1.5 3.138113839285714e-05 1.5 3.1381696428571424e-05 0.0 3.138616071428571e-05 0.0 3.1386718749999995e-05 1.5 3.1398995535714283e-05 1.5 3.139955357142857e-05 0.0 3.1404017857142854e-05 0.0 3.140457589285714e-05 1.5 3.1416852678571426e-05 1.5 3.141741071428571e-05 0.0 3.1421874999999996e-05 0.0 3.1422433035714287e-05 1.5 3.143470982142857e-05 1.5 3.143526785714286e-05 0.0 3.143973214285714e-05 0.0 3.144029017857143e-05 1.5 3.145256696428571e-05 1.5 3.1453125e-05 0.0 3.145758928571428e-05 0.0 3.145814732142857e-05 1.5 3.147042410714285e-05 1.5 3.147098214285714e-05 0.0 3.147544642857142e-05 0.0 3.1476004464285713e-05 1.5 3.1488281249999995e-05 1.5 3.1488839285714285e-05 0.0 3.149330357142857e-05 0.0 3.1493861607142856e-05 1.5 3.150613839285714e-05 1.5 3.150669642857143e-05 0.0 3.1511160714285715e-05 0.0 3.151171875e-05 1.5 3.1523995535714286e-05 1.5 3.152455357142857e-05 0.0 3.152901785714286e-05 0.0 3.152957589285714e-05 1.5 3.154185267857143e-05 1.5 3.154241071428571e-05 0.0 3.1546875e-05 0.0 3.154743303571428e-05 1.5 3.155970982142857e-05 1.5 3.1560267857142854e-05 0.0 3.156473214285714e-05 0.0 3.1565290178571425e-05 1.5 3.1577566964285713e-05 1.5 3.1578125e-05 0.0 3.1582589285714284e-05 0.0 3.158314732142857e-05 1.5 3.1595424107142856e-05 1.5 3.159598214285714e-05 0.0 3.1600446428571426e-05 0.0 3.160100446428571e-05 1.5 3.161328125e-05 1.5 3.161383928571428e-05 0.0 3.161830357142857e-05 0.0 3.161886160714285e-05 1.5 3.163113839285714e-05 1.5 3.1631696428571424e-05 0.0 3.163616071428571e-05 0.0 3.1636718749999994e-05 1.5 3.164899553571428e-05 1.5 3.1649553571428566e-05 0.0 3.165401785714285e-05 0.0 3.1654575892857143e-05 1.5 3.1666852678571425e-05 1.5 3.1667410714285715e-05 0.0 3.1671874999999996e-05 0.0 3.1672433035714286e-05 1.5 3.168470982142857e-05 1.5 3.168526785714286e-05 0.0 3.168973214285714e-05 0.0 3.169029017857143e-05 1.5 3.170256696428571e-05 1.5 3.1703125e-05 0.0 3.170758928571428e-05 0.0 3.170814732142857e-05 1.5 3.172042410714285e-05 1.5 3.172098214285714e-05 0.0 3.172544642857143e-05 0.0 3.172600446428571e-05 1.5 3.173828125e-05 1.5 3.1738839285714284e-05 0.0 3.174330357142857e-05 0.0 3.1743861607142855e-05 1.5 3.1756138392857143e-05 1.5 3.175669642857143e-05 0.0 3.1761160714285714e-05 0.0 3.176171875e-05 1.5 3.1773995535714286e-05 1.5 3.177455357142857e-05 0.0 3.1779017857142856e-05 0.0 3.177957589285714e-05 1.5 3.179185267857143e-05 1.5 3.179241071428571e-05 0.0 3.1796875e-05 0.0 3.179743303571428e-05 1.5 3.180970982142857e-05 1.5 3.1810267857142854e-05 0.0 3.181473214285714e-05 0.0 3.1815290178571424e-05 1.5 3.182756696428571e-05 1.5 3.1828124999999996e-05 0.0 3.183258928571428e-05 0.0 3.183314732142857e-05 1.5 3.1845424107142855e-05 1.5 3.184598214285714e-05 0.0 3.1850446428571426e-05 0.0 3.185100446428571e-05 1.5 3.186328125e-05 1.5 3.186383928571428e-05 0.0 3.186830357142857e-05 0.0 3.186886160714286e-05 1.5 3.188113839285714e-05 1.5 3.188169642857142e-05 0.0 3.188616071428571e-05 0.0 3.188671875e-05 1.5 3.189899553571428e-05 1.5 3.189955357142857e-05 0.0 3.190401785714285e-05 0.0 3.190457589285714e-05 1.5 3.1916852678571424e-05 1.5 3.1917410714285714e-05 0.0 3.1921874999999995e-05 0.0 3.1922433035714285e-05 1.5 3.193470982142857e-05 1.5 3.193526785714286e-05 0.0 3.193973214285714e-05 0.0 3.194029017857143e-05 1.5 3.195256696428571e-05 1.5 3.1953125e-05 0.0 3.1957589285714286e-05 0.0 3.195814732142857e-05 1.5 3.197042410714286e-05 1.5 3.197098214285714e-05 0.0 3.197544642857143e-05 0.0 3.197600446428571e-05 1.5 3.198828125e-05 1.5 3.1988839285714284e-05 0.0 3.199330357142857e-05 0.0 3.1993861607142854e-05 1.5 3.200613839285714e-05 1.5 3.2006696428571426e-05 0.0 3.201116071428571e-05 0.0 3.201171875e-05 1.5 3.2023995535714285e-05 1.5 3.202455357142857e-05 0.0 3.2029017857142856e-05 0.0 3.202957589285714e-05 1.5 3.204185267857143e-05 1.5 3.204241071428571e-05 0.0 3.2046875e-05 0.0 3.204743303571428e-05 1.5 3.205970982142857e-05 1.5 3.206026785714285e-05 0.0 3.206473214285714e-05 0.0 3.2065290178571424e-05 1.5 3.207756696428571e-05 1.5 3.2078124999999995e-05 0.0 3.208258928571428e-05 0.0 3.2083147321428566e-05 1.5 3.2095424107142854e-05 1.5 3.209598214285714e-05 0.0 3.2100446428571425e-05 0.0 3.2101004464285715e-05 1.5 )"}
C {devices/gnd.sym} 640 -1540 0 0 {name=l46 lab=GND}
C {devices/lab_pin.sym} 1380 -2030 0 0 {name=l26 sig_type=std_logic lab=vin_Q}
C {devices/vsource.sym} 480 -1980 0 1 {name=vcosine spice_ignore=False value="sin(0 \{VDD/2\} \{fsig\} 0 0 90)"
}
C {lab_pin.sym} 740 -2060 0 1 {name=p7 sig_type=std_logic lab=vinp_I_cosine}
C {lab_pin.sym} 740 -1980 0 1 {name=p8 sig_type=std_logic lab=vinn_I_cosine}
C {lab_pin.sym} 1660 -2060 0 1 {name=p9 sig_type=std_logic lab=vinp_Q_sine}
C {lab_pin.sym} 1660 -1980 0 1 {name=p10 sig_type=std_logic lab=vinn_Q_sine}
C {lab_pin.sym} 1280 -1700 0 0 {name=p11 sig_type=std_logic lab=vinp_Q_pwm}
C {lab_pin.sym} 1860 -1820 0 0 {name=p2 sig_type=std_logic lab=vinn_Q_pwm}
C {devices/vcvs.sym} 1680 -1680 0 0 {name=E9 value=-1}
C {devices/vsource.sym} 1320 -1610 0 0 {name=vpwm_sine_100 hide_texts=true value="dc 0 pwl(0.0 1.5 4.464285714285714e-09 1.5 5.022321428571428e-09 0.0 1.2834821428571427e-08 0.0 1.3392857142857143e-08 1.5 2.232142857142857e-08 1.5 2.2879464285714283e-08 0.0 3.069196428571428e-08 0.0 3.125e-08 1.5 4.0178571428571425e-08 1.5 4.073660714285714e-08 0.0 4.854910714285714e-08 0.0 4.910714285714285e-08 1.5 5.8035714285714284e-08 1.5 5.8593749999999995e-08 0.0 6.640625e-08 0.0 6.696428571428571e-08 1.5 7.589285714285714e-08 1.5 7.645089285714285e-08 0.0 8.426339285714285e-08 0.0 8.482142857142856e-08 1.5 9.374999999999999e-08 1.5 9.430803571428571e-08 0.0 1.021205357142857e-07 0.0 1.0267857142857142e-07 1.5 1.1160714285714285e-07 1.5 1.1216517857142857e-07 0.0 1.1997767857142856e-07 0.0 1.2053571428571428e-07 1.5 1.294642857142857e-07 1.5 1.3002232142857143e-07 0.0 1.378348214285714e-07 0.0 1.3839285714285713e-07 1.5 1.4732142857142856e-07 1.5 1.4787946428571428e-07 0.0 1.5569196428571426e-07 0.0 1.5624999999999999e-07 1.5 1.6573660714285714e-07 1.5 1.6629464285714283e-07 0.0 1.7299107142857142e-07 0.0 1.7354910714285714e-07 1.5 1.8359375e-07 1.5 1.8415178571428571e-07 0.0 1.9084821428571427e-07 0.0 1.9140625e-07 1.5 2.0145089285714284e-07 1.5 2.0200892857142857e-07 0.0 2.0870535714285712e-07 0.0 2.0926339285714285e-07 1.5 2.193080357142857e-07 1.5 2.1986607142857142e-07 0.0 2.2656249999999997e-07 0.0 2.271205357142857e-07 1.5 2.3716517857142855e-07 1.5 2.3772321428571427e-07 0.0 2.4441964285714285e-07 0.0 2.4497767857142855e-07 1.5 2.550223214285714e-07 1.5 2.555803571428571e-07 0.0 2.622767857142857e-07 0.0 2.628348214285714e-07 1.5 2.728794642857143e-07 1.5 2.734375e-07 0.0 2.8013392857142856e-07 0.0 2.8069196428571426e-07 1.5 2.9073660714285713e-07 1.5 2.9129464285714283e-07 0.0 2.979910714285714e-07 0.0 2.985491071428571e-07 1.5 3.0859375e-07 1.5 3.091517857142857e-07 0.0 3.1584821428571426e-07 0.0 3.1640624999999996e-07 1.5 3.2700892857142853e-07 1.5 3.275669642857143e-07 0.0 3.331473214285714e-07 0.0 3.337053571428571e-07 1.5 3.448660714285714e-07 1.5 3.4542410714285714e-07 0.0 3.5100446428571427e-07 0.0 3.5156249999999997e-07 1.5 3.6272321428571424e-07 1.5 3.6328125e-07 0.0 3.688616071428571e-07 0.0 3.694196428571428e-07 1.5 3.805803571428571e-07 1.5 3.8113839285714284e-07 0.0 3.8671875e-07 0.0 3.872767857142857e-07 1.5 3.984375e-07 1.5 3.989955357142857e-07 0.0 4.0457589285714283e-07 0.0 4.0513392857142853e-07 1.5 4.1629464285714285e-07 1.5 4.1685267857142855e-07 0.0 4.224330357142857e-07 0.0 4.229910714285714e-07 1.5 4.341517857142857e-07 1.5 4.347098214285714e-07 0.0 4.4029017857142853e-07 0.0 4.4084821428571423e-07 1.5 4.5200892857142855e-07 1.5 4.5256696428571425e-07 0.0 4.581473214285714e-07 0.0 4.587053571428571e-07 1.5 4.698660714285714e-07 1.5 4.704241071428571e-07 0.0 4.7600446428571424e-07 0.0 4.765625e-07 1.5 4.877232142857142e-07 1.5 4.8828125e-07 0.0 4.933035714285714e-07 0.0 4.938616071428571e-07 1.5 5.061383928571429e-07 1.5 5.066964285714286e-07 0.0 5.111607142857142e-07 0.0 5.117187499999999e-07 1.5 5.239955357142857e-07 1.5 5.245535714285714e-07 0.0 5.290178571428571e-07 0.0 5.295758928571428e-07 1.5 5.418526785714286e-07 1.5 5.424107142857143e-07 0.0 5.46875e-07 0.0 5.474330357142856e-07 1.5 5.597098214285714e-07 1.5 5.602678571428571e-07 0.0 5.647321428571428e-07 0.0 5.652901785714285e-07 1.5 5.775669642857143e-07 1.5 5.78125e-07 0.0 5.825892857142857e-07 0.0 5.831473214285714e-07 1.5 5.954241071428571e-07 1.5 5.959821428571428e-07 0.0 6.004464285714285e-07 0.0 6.010044642857142e-07 1.5 6.1328125e-07 1.5 6.138392857142857e-07 0.0 6.183035714285714e-07 0.0 6.188616071428571e-07 1.5 6.311383928571428e-07 1.5 6.316964285714285e-07 0.0 6.361607142857142e-07 0.0 6.367187499999999e-07 1.5 6.489955357142857e-07 1.5 6.495535714285714e-07 0.0 6.540178571428571e-07 0.0 6.545758928571428e-07 1.5 6.668526785714285e-07 1.5 6.674107142857142e-07 0.0 6.713169642857142e-07 0.0 6.718749999999999e-07 1.5 6.852678571428571e-07 1.5 6.858258928571428e-07 0.0 6.891741071428571e-07 0.0 6.897321428571428e-07 1.5 7.031249999999999e-07 1.5 7.036830357142856e-07 0.0 7.070312499999999e-07 0.0 7.075892857142856e-07 1.5 7.209821428571428e-07 1.5 7.215401785714285e-07 0.0 7.248883928571428e-07 0.0 7.254464285714285e-07 1.5 7.388392857142856e-07 1.5 7.393973214285713e-07 0.0 7.427455357142856e-07 0.0 7.433035714285713e-07 1.5 7.566964285714285e-07 1.5 7.572544642857142e-07 0.0 7.606026785714285e-07 0.0 7.611607142857142e-07 1.5 7.745535714285713e-07 1.5 7.75111607142857e-07 0.0 7.784598214285713e-07 0.0 7.79017857142857e-07 1.5 7.924107142857142e-07 1.5 7.929687499999999e-07 0.0 7.963169642857142e-07 0.0 7.96875e-07 1.5 8.102678571428571e-07 1.5 8.108258928571428e-07 0.0 8.14174107142857e-07 0.0 8.147321428571428e-07 1.5 8.281249999999999e-07 1.5 8.286830357142856e-07 0.0 8.320312499999999e-07 0.0 8.325892857142857e-07 1.5 8.459821428571428e-07 1.5 8.465401785714286e-07 0.0 8.498883928571427e-07 0.0 8.504464285714286e-07 1.5 8.643973214285714e-07 1.5 8.649553571428571e-07 0.0 8.671874999999999e-07 0.0 8.677455357142856e-07 1.5 8.822544642857143e-07 1.5 8.828125e-07 0.0 8.850446428571428e-07 0.0 8.856026785714286e-07 1.5 9.001116071428571e-07 1.5 9.006696428571428e-07 0.0 9.029017857142856e-07 0.0 9.034598214285714e-07 1.5 9.1796875e-07 1.5 9.185267857142857e-07 0.0 9.207589285714285e-07 0.0 9.213169642857143e-07 1.5 9.358258928571428e-07 1.5 9.363839285714285e-07 0.0 9.386160714285713e-07 0.0 9.391741071428571e-07 1.5 9.536830357142856e-07 1.5 9.542410714285713e-07 0.0 9.564732142857143e-07 0.0 9.5703125e-07 1.5 9.715401785714285e-07 1.5 9.720982142857142e-07 0.0 9.74330357142857e-07 0.0 9.748883928571427e-07 1.5 9.893973214285713e-07 1.5 9.89955357142857e-07 0.0 9.921875e-07 0.0 9.927455357142857e-07 1.5 1.0072544642857142e-06 1.5 1.0078125e-06 0.0 1.0100446428571427e-06 0.0 1.0106026785714284e-06 1.5 1.025111607142857e-06 1.5 1.0256696428571427e-06 0.0 1.0279017857142857e-06 0.0 1.0284598214285714e-06 1.5 1.04296875e-06 1.5 1.0435267857142856e-06 0.0 1.0457589285714284e-06 0.0 1.0463169642857141e-06 1.5 1.0608258928571427e-06 1.5 1.0613839285714286e-06 0.0 1.0636160714285714e-06 0.0 1.064174107142857e-06 1.5 1.0786830357142856e-06 1.5 1.0792410714285713e-06 0.0 1.0814732142857141e-06 0.0 1.0820312499999998e-06 1.5 1.0970982142857143e-06 1.5 1.09765625e-06 0.0 1.0987723214285714e-06 0.0 1.099330357142857e-06 1.5 1.114955357142857e-06 1.5 1.1155133928571427e-06 0.0 1.1166294642857141e-06 0.0 1.1171874999999998e-06 1.5 1.1328125e-06 1.5 1.1333705357142857e-06 0.0 1.134486607142857e-06 0.0 1.1350446428571428e-06 1.5 1.1506696428571428e-06 1.5 1.1512276785714285e-06 0.0 1.1523437499999998e-06 0.0 1.1529017857142855e-06 1.5 1.1685267857142857e-06 1.5 1.1690848214285714e-06 0.0 1.1702008928571428e-06 0.0 1.1707589285714285e-06 1.5 1.1863839285714285e-06 1.5 1.1869419642857142e-06 0.0 1.1880580357142856e-06 0.0 1.1886160714285712e-06 1.5 1.2042410714285714e-06 1.5 1.2047991071428571e-06 0.0 1.2059151785714285e-06 0.0 1.2064732142857142e-06 1.5 1.2220982142857142e-06 1.5 1.2226562499999999e-06 0.0 1.2237723214285713e-06 0.0 1.224330357142857e-06 1.5 1.2399553571428571e-06 1.5 1.2405133928571428e-06 0.0 1.2416294642857142e-06 0.0 1.2421875e-06 1.5 1.2578124999999999e-06 1.5 1.2583705357142856e-06 0.0 1.259486607142857e-06 0.0 1.2600446428571429e-06 1.5 1.2756696428571428e-06 1.5 1.2762276785714285e-06 0.0 1.27734375e-06 0.0 1.2779017857142856e-06 1.5 1.2935267857142856e-06 1.5 1.2940848214285713e-06 0.0 1.2952008928571427e-06 0.0 1.2957589285714286e-06 1.5 1.3113839285714285e-06 1.5 1.3119419642857142e-06 0.0 1.3130580357142856e-06 0.0 1.3136160714285713e-06 1.5 1.3292410714285713e-06 1.5 1.329799107142857e-06 0.0 1.3309151785714284e-06 0.0 1.3314732142857143e-06 1.5 1.3470982142857142e-06 1.5 1.34765625e-06 0.0 1.3487723214285713e-06 0.0 1.349330357142857e-06 1.5 1.3655133928571427e-06 1.5 1.3660714285714284e-06 0.0 1.3660714285714284e-06 0.0 1.3666294642857143e-06 1.5 1.3833705357142856e-06 1.5 1.3839285714285713e-06 0.0 1.3839285714285713e-06 0.0 1.384486607142857e-06 1.5 1.4012276785714284e-06 1.5 1.401785714285714e-06 0.0 1.401785714285714e-06 0.0 1.40234375e-06 1.5 1.4190848214285713e-06 1.5 1.419642857142857e-06 0.0 1.419642857142857e-06 0.0 1.4202008928571427e-06 1.5 1.436941964285714e-06 1.5 1.4375e-06 0.0 1.4375e-06 0.0 1.4380580357142857e-06 1.5 1.454799107142857e-06 1.5 1.4553571428571427e-06 0.0 1.4553571428571427e-06 0.0 1.4559151785714284e-06 1.5 1.4726562499999998e-06 1.5 1.4732142857142857e-06 0.0 1.4732142857142857e-06 0.0 1.4737723214285714e-06 1.5 1.4905133928571428e-06 1.5 1.4910714285714285e-06 0.0 1.4910714285714285e-06 0.0 1.4916294642857142e-06 1.5 1.5083705357142855e-06 1.5 1.5089285714285714e-06 0.0 1.5089285714285714e-06 0.0 1.5094866071428571e-06 1.5 1.5262276785714285e-06 1.5 1.5267857142857142e-06 0.0 1.5267857142857142e-06 0.0 1.5273437499999999e-06 1.5 1.5440848214285714e-06 1.5 1.5446428571428571e-06 0.0 1.5446428571428571e-06 0.0 1.5452008928571428e-06 1.5 1.5619419642857142e-06 1.5 1.5624999999999999e-06 0.0 1.5624999999999999e-06 0.0 1.5630580357142856e-06 1.5 1.5797991071428571e-06 1.5 1.5803571428571428e-06 0.0 1.5803571428571428e-06 0.0 1.5809151785714285e-06 1.5 1.5976562499999999e-06 1.5 1.5982142857142856e-06 0.0 1.5982142857142856e-06 0.0 1.5987723214285713e-06 1.5 1.6155133928571428e-06 1.5 1.6160714285714285e-06 0.0 1.6160714285714285e-06 0.0 1.6166294642857142e-06 1.5 1.6333705357142856e-06 1.5 1.6339285714285713e-06 0.0 1.6339285714285713e-06 0.0 1.634486607142857e-06 1.5 1.6512276785714285e-06 1.5 1.6517857142857142e-06 0.0 1.6517857142857142e-06 0.0 1.65234375e-06 1.5 1.6690848214285713e-06 1.5 1.669642857142857e-06 0.0 1.669642857142857e-06 0.0 1.6702008928571427e-06 1.5 1.6869419642857142e-06 1.5 1.6875e-06 0.0 1.6875e-06 0.0 1.6880580357142856e-06 1.5 1.704799107142857e-06 1.5 1.7053571428571427e-06 0.0 1.7053571428571427e-06 0.0 1.7059151785714284e-06 1.5 1.72265625e-06 1.5 1.7232142857142856e-06 0.0 1.7232142857142856e-06 0.0 1.7237723214285713e-06 1.5 1.7405133928571427e-06 1.5 1.7410714285714284e-06 0.0 1.7410714285714284e-06 0.0 1.741629464285714e-06 1.5 1.7583705357142856e-06 1.5 1.7589285714285713e-06 0.0 1.7589285714285713e-06 0.0 1.759486607142857e-06 1.5 1.7762276785714284e-06 1.5 1.776785714285714e-06 0.0 1.776785714285714e-06 0.0 1.7773437499999998e-06 1.5 1.7940848214285714e-06 1.5 1.794642857142857e-06 0.0 1.794642857142857e-06 0.0 1.7952008928571427e-06 1.5 1.811941964285714e-06 1.5 1.8124999999999998e-06 0.0 1.8124999999999998e-06 0.0 1.8130580357142855e-06 1.5 1.829799107142857e-06 1.5 1.8303571428571428e-06 0.0 1.8303571428571428e-06 0.0 1.8309151785714285e-06 1.5 1.8476562499999998e-06 1.5 1.8482142857142855e-06 0.0 1.8482142857142855e-06 0.0 1.8487723214285712e-06 1.5 1.8655133928571428e-06 1.5 1.8660714285714285e-06 0.0 1.8660714285714285e-06 0.0 1.8666294642857142e-06 1.5 1.8833705357142855e-06 1.5 1.8839285714285712e-06 0.0 1.8839285714285712e-06 0.0 1.884486607142857e-06 1.5 1.9012276785714285e-06 1.5 1.9017857142857142e-06 0.0 1.9017857142857142e-06 0.0 1.9023437499999999e-06 1.5 1.9190848214285714e-06 1.5 1.919642857142857e-06 0.0 1.919642857142857e-06 0.0 1.920200892857143e-06 1.5 1.936941964285714e-06 1.5 1.9374999999999997e-06 0.0 1.9374999999999997e-06 0.0 1.9380580357142856e-06 1.5 1.954799107142857e-06 1.5 1.955357142857143e-06 0.0 1.955357142857143e-06 0.0 1.9559151785714283e-06 1.5 1.9726562499999997e-06 1.5 1.9732142857142856e-06 0.0 1.9732142857142856e-06 0.0 1.9737723214285715e-06 1.5 1.990513392857143e-06 1.5 1.9910714285714283e-06 0.0 1.9910714285714283e-06 0.0 1.9916294642857142e-06 1.5 2.0083705357142856e-06 1.5 2.0089285714285715e-06 0.0 2.0089285714285715e-06 0.0 2.009486607142857e-06 1.5 2.0262276785714283e-06 1.5 2.0267857142857142e-06 0.0 2.0267857142857142e-06 0.0 2.0273437499999997e-06 1.5 2.044084821428571e-06 1.5 2.044642857142857e-06 0.0 2.044642857142857e-06 0.0 2.045200892857143e-06 1.5 2.0619419642857142e-06 1.5 2.0624999999999997e-06 0.0 2.0624999999999997e-06 0.0 2.0630580357142856e-06 1.5 2.079799107142857e-06 1.5 2.080357142857143e-06 0.0 2.080357142857143e-06 0.0 2.0809151785714284e-06 1.5 2.0976562499999997e-06 1.5 2.0982142857142857e-06 0.0 2.0982142857142857e-06 0.0 2.098772321428571e-06 1.5 2.115513392857143e-06 1.5 2.1160714285714284e-06 0.0 2.1160714285714284e-06 0.0 2.1166294642857143e-06 1.5 2.1333705357142857e-06 1.5 2.133928571428571e-06 0.0 2.133928571428571e-06 0.0 2.134486607142857e-06 1.5 2.1512276785714284e-06 1.5 2.1517857142857143e-06 0.0 2.1517857142857143e-06 0.0 2.15234375e-06 1.5 2.169084821428571e-06 1.5 2.169642857142857e-06 0.0 2.169642857142857e-06 0.0 2.1702008928571425e-06 1.5 2.1869419642857143e-06 1.5 2.1875e-06 0.0 2.1875e-06 0.0 2.1880580357142857e-06 1.5 2.204799107142857e-06 1.5 2.2053571428571426e-06 0.0 2.2053571428571426e-06 0.0 2.2059151785714285e-06 1.5 2.22265625e-06 1.5 2.2232142857142857e-06 0.0 2.2232142857142857e-06 0.0 2.223772321428571e-06 1.5 2.2405133928571426e-06 1.5 2.2410714285714285e-06 0.0 2.2410714285714285e-06 0.0 2.241629464285714e-06 1.5 2.2583705357142857e-06 1.5 2.2589285714285712e-06 0.0 2.2589285714285712e-06 0.0 2.259486607142857e-06 1.5 2.2762276785714285e-06 1.5 2.276785714285714e-06 0.0 2.276785714285714e-06 0.0 2.27734375e-06 1.5 2.2940848214285712e-06 1.5 2.294642857142857e-06 0.0 2.294642857142857e-06 0.0 2.2952008928571426e-06 1.5 2.311941964285714e-06 1.5 2.3125e-06 0.0 2.3125e-06 0.0 2.3130580357142854e-06 1.5 2.329799107142857e-06 1.5 2.3303571428571426e-06 0.0 2.3303571428571426e-06 0.0 2.3309151785714285e-06 1.5 2.34765625e-06 1.5 2.3482142857142854e-06 0.0 2.3482142857142854e-06 0.0 2.3487723214285713e-06 1.5 2.3655133928571426e-06 1.5 2.3660714285714285e-06 0.0 2.3660714285714285e-06 0.0 2.366629464285714e-06 1.5 2.3833705357142854e-06 1.5 2.3839285714285713e-06 0.0 2.3839285714285713e-06 0.0 2.3844866071428568e-06 1.5 2.4012276785714286e-06 1.5 2.401785714285714e-06 0.0 2.401785714285714e-06 0.0 2.40234375e-06 1.5 2.4190848214285713e-06 1.5 2.4196428571428568e-06 0.0 2.4196428571428568e-06 0.0 2.4202008928571427e-06 1.5 2.436941964285714e-06 1.5 2.4375e-06 0.0 2.4375e-06 0.0 2.4380580357142854e-06 1.5 2.454799107142857e-06 1.5 2.4553571428571427e-06 0.0 2.4553571428571427e-06 0.0 2.455915178571428e-06 1.5 2.47265625e-06 1.5 2.4732142857142854e-06 0.0 2.4732142857142854e-06 0.0 2.4737723214285714e-06 1.5 2.4905133928571427e-06 1.5 2.491071428571428e-06 0.0 2.491071428571428e-06 0.0 2.491629464285714e-06 1.5 2.5083705357142855e-06 1.5 2.5089285714285714e-06 0.0 2.5089285714285714e-06 0.0 2.509486607142857e-06 1.5 2.526227678571428e-06 1.5 2.526785714285714e-06 0.0 2.526785714285714e-06 0.0 2.52734375e-06 1.5 2.5440848214285714e-06 1.5 2.544642857142857e-06 0.0 2.544642857142857e-06 0.0 2.5452008928571428e-06 1.5 2.561941964285714e-06 1.5 2.5624999999999996e-06 0.0 2.5624999999999996e-06 0.0 2.5630580357142855e-06 1.5 2.579799107142857e-06 1.5 2.5803571428571428e-06 0.0 2.5803571428571428e-06 0.0 2.5809151785714283e-06 1.5 2.5976562499999996e-06 1.5 2.5982142857142855e-06 0.0 2.5982142857142855e-06 0.0 2.5987723214285714e-06 1.5 2.6155133928571428e-06 1.5 2.6160714285714283e-06 0.0 2.6160714285714283e-06 0.0 2.616629464285714e-06 1.5 2.6333705357142855e-06 1.5 2.6339285714285714e-06 0.0 2.6339285714285714e-06 0.0 2.634486607142857e-06 1.5 2.6512276785714283e-06 1.5 2.651785714285714e-06 0.0 2.6523437499999997e-06 0.0 2.6529017857142856e-06 1.5 2.6685267857142855e-06 1.5 2.6690848214285714e-06 0.0 2.670200892857143e-06 0.0 2.6707589285714283e-06 1.5 2.6863839285714283e-06 1.5 2.686941964285714e-06 0.0 2.6880580357142856e-06 0.0 2.688616071428571e-06 1.5 2.704241071428571e-06 1.5 2.704799107142857e-06 0.0 2.7059151785714283e-06 0.0 2.7064732142857142e-06 1.5 2.722098214285714e-06 1.5 2.7226562499999997e-06 0.0 2.723772321428571e-06 0.0 2.724330357142857e-06 1.5 2.739955357142857e-06 1.5 2.740513392857143e-06 0.0 2.7416294642857143e-06 0.0 2.7421874999999997e-06 1.5 2.7578124999999997e-06 1.5 2.7583705357142856e-06 0.0 2.759486607142857e-06 0.0 2.7600446428571425e-06 1.5 2.775669642857143e-06 1.5 2.7762276785714284e-06 0.0 2.7773437499999997e-06 0.0 2.7779017857142857e-06 1.5 2.7935267857142856e-06 1.5 2.794084821428571e-06 0.0 2.7952008928571425e-06 0.0 2.7957589285714284e-06 1.5 2.8113839285714284e-06 1.5 2.8119419642857143e-06 0.0 2.8130580357142857e-06 0.0 2.813616071428571e-06 1.5 2.829241071428571e-06 1.5 2.829799107142857e-06 0.0 2.8309151785714284e-06 0.0 2.831473214285714e-06 1.5 2.8470982142857143e-06 1.5 2.8476562499999998e-06 0.0 2.848772321428571e-06 0.0 2.849330357142857e-06 1.5 2.864955357142857e-06 1.5 2.8655133928571425e-06 0.0 2.866629464285714e-06 0.0 2.8671875e-06 1.5 2.8828124999999998e-06 1.5 2.8833705357142857e-06 0.0 2.884486607142857e-06 0.0 2.8850446428571426e-06 1.5 2.9006696428571425e-06 1.5 2.9012276785714284e-06 0.0 2.90234375e-06 0.0 2.9029017857142853e-06 1.5 2.9185267857142857e-06 1.5 2.919084821428571e-06 0.0 2.9202008928571426e-06 0.0 2.9207589285714285e-06 1.5 2.9358258928571425e-06 1.5 2.9363839285714284e-06 0.0 2.9386160714285712e-06 0.0 2.939174107142857e-06 1.5 2.9536830357142857e-06 1.5 2.954241071428571e-06 0.0 2.956473214285714e-06 0.0 2.95703125e-06 1.5 2.9715401785714284e-06 1.5 2.972098214285714e-06 0.0 2.974330357142857e-06 0.0 2.9748883928571426e-06 1.5 2.989397321428571e-06 1.5 2.989955357142857e-06 0.0 2.9921875e-06 0.0 2.9927455357142854e-06 1.5 3.007254464285714e-06 1.5 3.0078125e-06 0.0 3.0100446428571426e-06 0.0 3.0106026785714285e-06 1.5 3.025111607142857e-06 1.5 3.0256696428571426e-06 0.0 3.0279017857142854e-06 0.0 3.0284598214285713e-06 1.5 3.04296875e-06 1.5 3.0435267857142853e-06 0.0 3.0457589285714285e-06 0.0 3.046316964285714e-06 1.5 3.0608258928571426e-06 1.5 3.0613839285714285e-06 0.0 3.0636160714285713e-06 0.0 3.0641741071428568e-06 1.5 3.0786830357142853e-06 1.5 3.0792410714285713e-06 0.0 3.081473214285714e-06 0.0 3.08203125e-06 1.5 3.0965401785714285e-06 1.5 3.097098214285714e-06 0.0 3.099330357142857e-06 0.0 3.0998883928571427e-06 1.5 3.1143973214285713e-06 1.5 3.1149553571428567e-06 0.0 3.1171875e-06 0.0 3.1177455357142854e-06 1.5 3.132254464285714e-06 1.5 3.1328125e-06 0.0 3.1350446428571427e-06 0.0 3.135602678571428e-06 1.5 3.1501116071428568e-06 1.5 3.1506696428571427e-06 0.0 3.1534598214285714e-06 0.0 3.154017857142857e-06 1.5 3.167410714285714e-06 1.5 3.16796875e-06 0.0 3.171316964285714e-06 0.0 3.1718749999999996e-06 1.5 3.1852678571428568e-06 1.5 3.1858258928571427e-06 0.0 3.189174107142857e-06 0.0 3.1897321428571428e-06 1.5 3.203125e-06 1.5 3.2036830357142854e-06 0.0 3.2070312499999996e-06 0.0 3.2075892857142855e-06 1.5 3.2209821428571427e-06 1.5 3.221540178571428e-06 0.0 3.2248883928571428e-06 0.0 3.2254464285714283e-06 1.5 3.2388392857142854e-06 1.5 3.2393973214285713e-06 0.0 3.2427455357142855e-06 0.0 3.243303571428571e-06 1.5 3.256696428571428e-06 1.5 3.257254464285714e-06 0.0 3.2606026785714283e-06 0.0 3.261160714285714e-06 1.5 3.2745535714285713e-06 1.5 3.275111607142857e-06 0.0 3.278459821428571e-06 0.0 3.279017857142857e-06 1.5 3.292410714285714e-06 1.5 3.2929687499999996e-06 0.0 3.296316964285714e-06 0.0 3.2968749999999997e-06 1.5 3.310267857142857e-06 1.5 3.3108258928571427e-06 0.0 3.314174107142857e-06 0.0 3.3147321428571424e-06 1.5 3.3281249999999996e-06 1.5 3.3286830357142855e-06 0.0 3.3320312499999997e-06 0.0 3.3325892857142856e-06 1.5 3.345424107142857e-06 1.5 3.3459821428571428e-06 0.0 3.3504464285714283e-06 0.0 3.3510044642857142e-06 1.5 3.3632812499999996e-06 1.5 3.3638392857142855e-06 0.0 3.368303571428571e-06 0.0 3.368861607142857e-06 1.5 3.3811383928571428e-06 1.5 3.3816964285714282e-06 0.0 3.3861607142857142e-06 0.0 3.3867187499999997e-06 1.5 3.3989955357142855e-06 1.5 3.399553571428571e-06 0.0 3.404017857142857e-06 0.0 3.4045758928571425e-06 1.5 3.4168526785714283e-06 1.5 3.417410714285714e-06 0.0 3.4218749999999997e-06 0.0 3.4224330357142857e-06 1.5 3.434709821428571e-06 1.5 3.435267857142857e-06 0.0 3.4397321428571425e-06 0.0 3.4402901785714284e-06 1.5 3.452566964285714e-06 1.5 3.4531249999999997e-06 0.0 3.4575892857142857e-06 0.0 3.458147321428571e-06 1.5 3.470424107142857e-06 1.5 3.4709821428571424e-06 0.0 3.4754464285714284e-06 0.0 3.476004464285714e-06 1.5 3.4882812499999997e-06 1.5 3.4888392857142856e-06 0.0 3.493303571428571e-06 0.0 3.493861607142857e-06 1.5 3.5061383928571424e-06 1.5 3.5066964285714283e-06 0.0 3.511160714285714e-06 0.0 3.51171875e-06 1.5 3.5234374999999997e-06 1.5 3.5239955357142856e-06 0.0 3.5295758928571426e-06 0.0 3.5301339285714285e-06 1.5 3.5412946428571424e-06 1.5 3.5418526785714283e-06 0.0 3.5474330357142853e-06 0.0 3.547991071428571e-06 1.5 3.5591517857142856e-06 1.5 3.559709821428571e-06 0.0 3.5652901785714285e-06 0.0 3.565848214285714e-06 1.5 3.5770089285714283e-06 1.5 3.577566964285714e-06 0.0 3.5831473214285712e-06 0.0 3.5837053571428567e-06 1.5 3.594866071428571e-06 1.5 3.595424107142857e-06 0.0 3.601004464285714e-06 0.0 3.6015625e-06 1.5 3.612723214285714e-06 1.5 3.6132812499999997e-06 0.0 3.6188616071428567e-06 0.0 3.6194196428571426e-06 1.5 3.630580357142857e-06 1.5 3.6311383928571425e-06 0.0 3.63671875e-06 0.0 3.6372767857142854e-06 1.5 3.6484374999999997e-06 1.5 3.6489955357142857e-06 0.0 3.6545758928571426e-06 0.0 3.655133928571428e-06 1.5 3.6662946428571425e-06 1.5 3.6668526785714284e-06 0.0 3.6724330357142854e-06 0.0 3.6729910714285713e-06 1.5 3.6841517857142857e-06 1.5 3.684709821428571e-06 0.0 3.690848214285714e-06 0.0 3.69140625e-06 1.5 3.7014508928571425e-06 1.5 3.7020089285714284e-06 0.0 3.7087053571428568e-06 0.0 3.7092633928571427e-06 1.5 3.7193080357142852e-06 1.5 3.719866071428571e-06 0.0 3.7265624999999995e-06 0.0 3.7271205357142854e-06 1.5 3.7371651785714284e-06 1.5 3.737723214285714e-06 0.0 3.7444196428571427e-06 0.0 3.744977678571428e-06 1.5 3.755022321428571e-06 1.5 3.755580357142857e-06 0.0 3.7622767857142854e-06 0.0 3.7628348214285714e-06 1.5 3.772879464285714e-06 1.5 3.7734375e-06 0.0 3.780133928571428e-06 0.0 3.780691964285714e-06 1.5 3.790736607142857e-06 1.5 3.7912946428571426e-06 0.0 3.7979910714285714e-06 0.0 3.798549107142857e-06 1.5 3.80859375e-06 1.5 3.8091517857142853e-06 0.0 3.815848214285714e-06 0.0 3.81640625e-06 1.5 3.826450892857143e-06 1.5 3.827008928571428e-06 0.0 3.833705357142857e-06 0.0 3.834263392857142e-06 1.5 3.844308035714285e-06 1.5 3.844866071428571e-06 0.0 3.8515625e-06 0.0 3.8521205357142855e-06 1.5 3.861607142857143e-06 1.5 3.8621651785714285e-06 0.0 3.869977678571429e-06 0.0 3.870535714285714e-06 1.5 3.879464285714286e-06 1.5 3.880022321428571e-06 0.0 3.887834821428571e-06 0.0 3.888392857142857e-06 1.5 3.897321428571428e-06 1.5 3.897879464285714e-06 0.0 3.905691964285714e-06 0.0 3.90625e-06 1.5 3.915178571428571e-06 1.5 3.915736607142857e-06 0.0 3.9235491071428565e-06 0.0 3.924107142857142e-06 1.5 3.933035714285714e-06 1.5 3.9335937499999995e-06 0.0 3.94140625e-06 0.0 3.9419642857142856e-06 1.5 3.950892857142857e-06 1.5 3.951450892857143e-06 0.0 3.959263392857143e-06 0.0 3.959821428571428e-06 1.5 3.96875e-06 1.5 3.969308035714286e-06 0.0 3.977120535714285e-06 0.0 3.977678571428571e-06 1.5 3.986607142857142e-06 1.5 3.987165178571428e-06 0.0 3.994977678571428e-06 0.0 3.995535714285714e-06 1.5 4.004464285714285e-06 1.5 4.005022321428571e-06 0.0 4.0133928571428566e-06 0.0 4.0139508928571425e-06 1.5 4.021763392857143e-06 1.5 4.0223214285714286e-06 0.0 4.03125e-06 0.0 4.031808035714286e-06 1.5 4.039620535714286e-06 1.5 4.040178571428571e-06 0.0 4.049107142857143e-06 0.0 4.049665178571428e-06 1.5 4.057477678571428e-06 1.5 4.058035714285714e-06 0.0 4.066964285714285e-06 0.0 4.067522321428571e-06 1.5 4.075334821428571e-06 1.5 4.075892857142857e-06 0.0 4.084821428571428e-06 0.0 4.085379464285714e-06 1.5 4.093191964285714e-06 1.5 4.0937499999999996e-06 0.0 4.102678571428571e-06 0.0 4.103236607142857e-06 1.5 4.111049107142857e-06 1.5 4.111607142857143e-06 0.0 4.120535714285714e-06 0.0 4.12109375e-06 1.5 4.12890625e-06 1.5 4.129464285714285e-06 0.0 4.138392857142857e-06 0.0 4.138950892857143e-06 1.5 4.146763392857142e-06 1.5 4.147321428571428e-06 0.0 4.156249999999999e-06 0.0 4.156808035714285e-06 1.5 4.1646205357142855e-06 1.5 4.165178571428571e-06 0.0 4.1746651785714285e-06 0.0 4.175223214285714e-06 1.5 4.181919642857143e-06 1.5 4.182477678571429e-06 0.0 4.192522321428571e-06 0.0 4.193080357142857e-06 1.5 4.199776785714285e-06 1.5 4.200334821428571e-06 0.0 4.210379464285714e-06 0.0 4.2109375e-06 1.5 4.217633928571428e-06 1.5 4.218191964285714e-06 0.0 4.228236607142857e-06 0.0 4.228794642857142e-06 1.5 4.235491071428571e-06 1.5 4.2360491071428565e-06 0.0 4.2460937499999994e-06 0.0 4.246651785714285e-06 1.5 4.253348214285714e-06 1.5 4.25390625e-06 0.0 4.263950892857143e-06 0.0 4.2645089285714285e-06 1.5 4.271205357142857e-06 1.5 4.271763392857143e-06 0.0 4.281808035714286e-06 0.0 4.282366071428571e-06 1.5 4.2890625e-06 1.5 4.289620535714285e-06 0.0 4.299665178571428e-06 0.0 4.300223214285714e-06 1.5 4.306919642857142e-06 1.5 4.307477678571428e-06 0.0 4.317522321428571e-06 0.0 4.318080357142857e-06 1.5 4.3247767857142856e-06 1.5 4.3253348214285715e-06 0.0 4.3359374999999995e-06 0.0 4.3364955357142854e-06 1.5 4.342075892857143e-06 1.5 4.342633928571428e-06 0.0 4.353794642857143e-06 0.0 4.354352678571429e-06 1.5 4.359933035714285e-06 1.5 4.360491071428571e-06 0.0 4.371651785714285e-06 0.0 4.372209821428571e-06 1.5 4.377790178571428e-06 1.5 4.378348214285714e-06 0.0 4.389508928571428e-06 0.0 4.390066964285714e-06 1.5 4.3956473214285715e-06 1.5 4.3962053571428565e-06 0.0 4.407366071428571e-06 0.0 4.407924107142856e-06 1.5 4.413504464285714e-06 1.5 4.4140625e-06 0.0 4.425223214285714e-06 0.0 4.42578125e-06 1.5 4.431361607142857e-06 1.5 4.431919642857143e-06 0.0 4.443080357142857e-06 0.0 4.443638392857143e-06 1.5 4.449218749999999e-06 1.5 4.449776785714285e-06 0.0 4.4609375e-06 0.0 4.461495535714285e-06 1.5 4.4670758928571425e-06 1.5 4.467633928571428e-06 0.0 4.478794642857142e-06 0.0 4.479352678571428e-06 1.5 4.484933035714286e-06 1.5 4.485491071428571e-06 0.0 4.4966517857142855e-06 0.0 4.497209821428571e-06 1.5 4.502790178571428e-06 1.5 4.503348214285714e-06 0.0 4.515066964285714e-06 0.0 4.515625e-06 1.5 4.520089285714285e-06 1.5 4.520647321428571e-06 0.0 4.532924107142857e-06 0.0 4.533482142857143e-06 1.5 4.537946428571428e-06 1.5 4.538504464285714e-06 0.0 4.55078125e-06 0.0 4.551339285714285e-06 1.5 4.555803571428571e-06 1.5 4.556361607142857e-06 0.0 4.568638392857142e-06 0.0 4.569196428571428e-06 1.5 4.573660714285714e-06 1.5 4.57421875e-06 0.0 4.5864955357142856e-06 0.0 4.5870535714285715e-06 1.5 4.591517857142857e-06 1.5 4.592075892857142e-06 0.0 4.604352678571428e-06 0.0 4.604910714285714e-06 1.5 4.609374999999999e-06 1.5 4.609933035714285e-06 0.0 4.622209821428571e-06 0.0 4.622767857142857e-06 1.5 4.6272321428571426e-06 1.5 4.6277901785714285e-06 0.0 4.640066964285714e-06 0.0 4.640624999999999e-06 1.5 4.645089285714286e-06 1.5 4.645647321428571e-06 0.0 4.6579241071428566e-06 0.0 4.6584821428571425e-06 1.5 4.662946428571428e-06 1.5 4.663504464285714e-06 0.0 4.67578125e-06 0.0 4.676339285714286e-06 1.5 4.680803571428571e-06 1.5 4.681361607142857e-06 0.0 4.694196428571428e-06 0.0 4.694754464285714e-06 1.5 4.6981026785714285e-06 1.5 4.6986607142857135e-06 0.0 4.712053571428571e-06 0.0 4.712611607142857e-06 1.5 4.715959821428571e-06 1.5 4.716517857142857e-06 0.0 4.729910714285714e-06 0.0 4.730468749999999e-06 1.5 4.733816964285714e-06 1.5 4.734375e-06 0.0 4.747767857142857e-06 0.0 4.7483258928571425e-06 1.5 4.751674107142857e-06 1.5 4.752232142857142e-06 0.0 4.765625e-06 0.0 4.766183035714286e-06 1.5 4.7695312499999995e-06 1.5 4.770089285714285e-06 0.0 4.783482142857142e-06 0.0 4.784040178571428e-06 1.5 4.787388392857143e-06 1.5 4.7879464285714285e-06 0.0 4.801339285714285e-06 0.0 4.801897321428571e-06 1.5 4.805245535714285e-06 1.5 4.805803571428571e-06 0.0 4.8191964285714285e-06 0.0 4.8197544642857135e-06 1.5 4.823102678571428e-06 1.5 4.823660714285714e-06 0.0 4.837053571428571e-06 0.0 4.837611607142857e-06 1.5 4.840959821428571e-06 1.5 4.841517857142857e-06 0.0 4.854910714285714e-06 0.0 4.85546875e-06 1.5 4.858816964285714e-06 1.5 4.8593749999999995e-06 0.0 4.872767857142857e-06 0.0 4.873325892857142e-06 1.5 4.876116071428571e-06 1.5 4.876674107142857e-06 0.0 4.891183035714285e-06 0.0 4.891741071428571e-06 1.5 4.893973214285714e-06 1.5 4.89453125e-06 0.0 4.9090401785714285e-06 0.0 4.909598214285714e-06 1.5 4.911830357142856e-06 1.5 4.912388392857142e-06 0.0 4.926897321428571e-06 0.0 4.927455357142857e-06 1.5 4.9296874999999995e-06 1.5 4.9302455357142855e-06 0.0 4.944754464285714e-06 0.0 4.9453125e-06 1.5 4.947544642857143e-06 1.5 4.948102678571429e-06 0.0 4.962611607142857e-06 0.0 4.963169642857142e-06 1.5 4.965401785714285e-06 1.5 4.965959821428571e-06 0.0 4.9804687499999995e-06 0.0 4.981026785714285e-06 1.5 4.983258928571428e-06 1.5 4.983816964285714e-06 0.0 4.998325892857143e-06 0.0 4.998883928571429e-06 1.5 5.001116071428571e-06 1.5 5.0016741071428564e-06 0.0 5.016183035714285e-06 0.0 5.016741071428571e-06 1.5 5.018973214285714e-06 1.5 5.01953125e-06 0.0 5.034040178571428e-06 0.0 5.034598214285714e-06 1.5 5.036830357142857e-06 1.5 5.037388392857143e-06 0.0 5.051897321428571e-06 0.0 5.052455357142856e-06 1.5 5.0546875e-06 1.5 5.055245535714285e-06 0.0 5.069754464285714e-06 0.0 5.0703125e-06 1.5 5.072544642857142e-06 1.5 5.073102678571428e-06 0.0 5.087611607142857e-06 0.0 5.088169642857143e-06 1.5 5.0904017857142855e-06 1.5 5.0909598214285714e-06 0.0 5.106026785714285e-06 0.0 5.106584821428571e-06 1.5 5.107700892857143e-06 1.5 5.108258928571428e-06 0.0 5.123883928571428e-06 0.0 5.124441964285714e-06 1.5 5.125558035714285e-06 1.5 5.126116071428571e-06 0.0 5.141741071428571e-06 0.0 5.1422991071428565e-06 1.5 5.143415178571428e-06 1.5 5.143973214285714e-06 0.0 5.159598214285714e-06 0.0 5.16015625e-06 1.5 5.1612723214285715e-06 1.5 5.1618303571428565e-06 0.0 5.177455357142857e-06 0.0 5.178013392857143e-06 1.5 5.179129464285714e-06 1.5 5.1796875e-06 0.0 5.195312499999999e-06 0.0 5.195870535714285e-06 1.5 5.196986607142857e-06 1.5 5.197544642857143e-06 0.0 5.213169642857142e-06 0.0 5.213727678571428e-06 1.5 5.214843749999999e-06 1.5 5.215401785714285e-06 0.0 5.2310267857142856e-06 0.0 5.231584821428571e-06 1.5 5.2327008928571424e-06 1.5 5.233258928571428e-06 0.0 5.248883928571428e-06 0.0 5.249441964285714e-06 1.5 5.250558035714286e-06 1.5 5.251116071428571e-06 0.0 5.266741071428571e-06 0.0 5.267299107142857e-06 1.5 5.268415178571428e-06 1.5 5.268973214285714e-06 0.0 5.284598214285714e-06 0.0 5.285156249999999e-06 1.5 5.286272321428571e-06 1.5 5.286830357142857e-06 0.0 5.3024553571428566e-06 0.0 5.3030133928571425e-06 1.5 5.304129464285714e-06 1.5 5.304687499999999e-06 0.0 5.3203125e-06 0.0 5.320870535714286e-06 1.5 5.321986607142857e-06 1.5 5.3225446428571425e-06 0.0 5.338169642857143e-06 0.0 5.338727678571428e-06 1.5 5.33984375e-06 1.5 5.340401785714286e-06 0.0 5.356026785714285e-06 0.0 5.356584821428571e-06 1.5 5.357700892857142e-06 1.5 5.358258928571428e-06 0.0 5.374441964285714e-06 0.0 5.374999999999999e-06 1.5 5.374999999999999e-06 1.5 5.375558035714285e-06 0.0 5.392299107142857e-06 0.0 5.3928571428571425e-06 1.5 5.3928571428571425e-06 1.5 5.3934151785714284e-06 0.0 5.41015625e-06 0.0 5.410714285714286e-06 1.5 5.410714285714286e-06 1.5 5.411272321428571e-06 0.0 5.428013392857142e-06 0.0 5.428571428571428e-06 1.5 5.428571428571428e-06 1.5 5.429129464285714e-06 0.0 5.445870535714285e-06 0.0 5.446428571428571e-06 1.5 5.446428571428571e-06 1.5 5.446986607142857e-06 0.0 5.4637276785714285e-06 0.0 5.4642857142857135e-06 1.5 5.4642857142857135e-06 1.5 5.4648437499999994e-06 0.0 5.481584821428571e-06 0.0 5.482142857142857e-06 1.5 5.482142857142857e-06 1.5 5.482700892857143e-06 0.0 5.499441964285714e-06 0.0 5.5e-06 1.5 5.5e-06 1.5 5.500558035714285e-06 0.0 5.517299107142857e-06 0.0 5.517857142857142e-06 1.5 5.517857142857142e-06 1.5 5.518415178571428e-06 0.0 5.5351562499999994e-06 0.0 5.535714285714285e-06 1.5 5.535714285714285e-06 1.5 5.536272321428571e-06 0.0 5.553013392857143e-06 0.0 5.5535714285714285e-06 1.5 5.5535714285714285e-06 1.5 5.554129464285714e-06 0.0 5.570870535714285e-06 0.0 5.571428571428571e-06 1.5 5.571428571428571e-06 1.5 5.571986607142857e-06 0.0 5.588727678571428e-06 0.0 5.589285714285714e-06 1.5 5.589285714285714e-06 1.5 5.58984375e-06 0.0 5.606584821428571e-06 0.0 5.607142857142856e-06 1.5 5.607142857142856e-06 1.5 5.607700892857142e-06 0.0 5.624441964285714e-06 0.0 5.6249999999999995e-06 1.5 5.6249999999999995e-06 1.5 5.625558035714285e-06 0.0 5.642299107142857e-06 0.0 5.642857142857143e-06 1.5 5.642857142857143e-06 1.5 5.643415178571429e-06 0.0 5.66015625e-06 0.0 5.660714285714285e-06 1.5 5.660714285714285e-06 1.5 5.661272321428571e-06 0.0 5.678013392857142e-06 0.0 5.678571428571428e-06 1.5 5.678571428571428e-06 1.5 5.679129464285714e-06 0.0 5.6958705357142854e-06 0.0 5.696428571428571e-06 1.5 5.696428571428571e-06 1.5 5.696986607142856e-06 0.0 5.713727678571428e-06 0.0 5.714285714285714e-06 1.5 5.714285714285714e-06 1.5 5.7148437499999996e-06 0.0 5.731584821428571e-06 0.0 5.732142857142857e-06 1.5 5.732142857142857e-06 1.5 5.732700892857143e-06 0.0 5.749441964285714e-06 0.0 5.75e-06 1.5 5.75e-06 1.5 5.750558035714285e-06 0.0 5.767299107142856e-06 0.0 5.767857142857142e-06 1.5 5.767857142857142e-06 1.5 5.768415178571428e-06 0.0 5.78515625e-06 0.0 5.7857142857142855e-06 1.5 5.7857142857142855e-06 1.5 5.786272321428571e-06 0.0 5.803013392857143e-06 0.0 5.803571428571428e-06 1.5 5.803571428571428e-06 1.5 5.804129464285714e-06 0.0 5.820870535714285e-06 0.0 5.821428571428571e-06 1.5 5.821428571428571e-06 1.5 5.821986607142857e-06 0.0 5.838727678571428e-06 0.0 5.839285714285714e-06 1.5 5.839285714285714e-06 1.5 5.839843749999999e-06 0.0 5.856584821428571e-06 0.0 5.8571428571428565e-06 1.5 5.8571428571428565e-06 1.5 5.857700892857142e-06 0.0 5.874441964285714e-06 0.0 5.875e-06 1.5 5.875e-06 1.5 5.8755580357142856e-06 0.0 5.892299107142857e-06 0.0 5.892857142857143e-06 1.5 5.892857142857143e-06 1.5 5.893415178571428e-06 0.0 5.910156249999999e-06 0.0 5.910714285714285e-06 1.5 5.910714285714285e-06 1.5 5.911272321428571e-06 0.0 5.928013392857142e-06 0.0 5.928571428571428e-06 1.5 5.928571428571428e-06 1.5 5.929129464285714e-06 0.0 5.945870535714286e-06 0.0 5.946428571428571e-06 1.5 5.946428571428571e-06 1.5 5.9469866071428566e-06 0.0 5.963727678571428e-06 0.0 5.964285714285714e-06 1.5 5.964285714285714e-06 1.5 5.96484375e-06 0.0 5.981584821428571e-06 0.0 5.982142857142857e-06 1.5 5.982142857142857e-06 1.5 5.982700892857142e-06 0.0 5.999441964285714e-06 0.0 5.999999999999999e-06 1.5 5.999999999999999e-06 1.5 6.000558035714285e-06 0.0 6.0172991071428566e-06 0.0 6.0178571428571425e-06 1.5 6.0178571428571425e-06 1.5 6.018415178571428e-06 0.0 6.03515625e-06 0.0 6.035714285714286e-06 1.5 6.035714285714286e-06 1.5 6.036272321428571e-06 0.0 6.053013392857142e-06 0.0 6.053571428571428e-06 1.5 6.053571428571428e-06 1.5 6.054129464285714e-06 0.0 6.070870535714285e-06 0.0 6.071428571428571e-06 1.5 6.071428571428571e-06 1.5 6.071986607142857e-06 0.0 6.088727678571428e-06 0.0 6.0892857142857135e-06 1.5 6.0892857142857135e-06 1.5 6.089843749999999e-06 0.0 6.106584821428571e-06 0.0 6.107142857142857e-06 1.5 6.107142857142857e-06 1.5 6.1077008928571425e-06 0.0 6.124441964285714e-06 0.0 6.125e-06 1.5 6.125e-06 1.5 6.125558035714285e-06 0.0 6.142299107142857e-06 0.0 6.142857142857142e-06 1.5 6.142857142857142e-06 1.5 6.143415178571428e-06 0.0 6.160156249999999e-06 0.0 6.160714285714285e-06 1.5 6.160714285714285e-06 1.5 6.161272321428571e-06 0.0 6.1780133928571426e-06 0.0 6.1785714285714285e-06 1.5 6.1785714285714285e-06 1.5 6.1791294642857135e-06 0.0 6.195870535714285e-06 0.0 6.196428571428571e-06 1.5 6.196428571428571e-06 1.5 6.196986607142857e-06 0.0 6.213727678571428e-06 0.0 6.214285714285714e-06 1.5 6.214285714285714e-06 1.5 6.21484375e-06 0.0 6.231584821428571e-06 0.0 6.232142857142856e-06 1.5 6.232142857142856e-06 1.5 6.232700892857142e-06 0.0 6.2494419642857135e-06 0.0 6.2499999999999995e-06 1.5 6.2499999999999995e-06 1.5 6.250558035714285e-06 0.0 6.267299107142857e-06 0.0 6.267857142857143e-06 1.5 6.267857142857143e-06 1.5 6.2684151785714285e-06 0.0 6.28515625e-06 0.0 6.285714285714285e-06 1.5 6.285714285714285e-06 1.5 6.286272321428571e-06 0.0 6.303013392857142e-06 0.0 6.303571428571428e-06 1.5 6.303571428571428e-06 1.5 6.304129464285714e-06 0.0 6.320870535714285e-06 0.0 6.321428571428571e-06 1.5 6.321428571428571e-06 1.5 6.321986607142856e-06 0.0 6.338727678571428e-06 0.0 6.339285714285714e-06 1.5 6.339285714285714e-06 1.5 6.3398437499999995e-06 0.0 6.356584821428571e-06 0.0 6.357142857142857e-06 1.5 6.357142857142857e-06 1.5 6.357700892857143e-06 0.0 6.374441964285714e-06 0.0 6.375e-06 1.5 6.375e-06 1.5 6.375558035714285e-06 0.0 6.392299107142856e-06 0.0 6.392857142857142e-06 1.5 6.392857142857142e-06 1.5 6.393415178571428e-06 0.0 6.4101562499999995e-06 0.0 6.4107142857142854e-06 1.5 6.4107142857142854e-06 1.5 6.411272321428571e-06 0.0 6.428013392857143e-06 0.0 6.428571428571428e-06 1.5 6.428571428571428e-06 1.5 6.429129464285714e-06 0.0 6.445870535714285e-06 0.0 6.446428571428571e-06 1.5 6.446428571428571e-06 1.5 6.446986607142857e-06 0.0 6.463727678571428e-06 0.0 6.464285714285714e-06 1.5 6.464285714285714e-06 1.5 6.464843749999999e-06 0.0 6.481584821428571e-06 0.0 6.4821428571428564e-06 1.5 6.4821428571428564e-06 1.5 6.482700892857142e-06 0.0 6.499441964285714e-06 0.0 6.5e-06 1.5 6.5e-06 1.5 6.5005580357142855e-06 0.0 6.517299107142857e-06 0.0 6.517857142857143e-06 1.5 6.517857142857143e-06 1.5 6.518415178571428e-06 0.0 6.535156249999999e-06 0.0 6.535714285714285e-06 1.5 6.535714285714285e-06 1.5 6.536272321428571e-06 0.0 6.553013392857142e-06 0.0 6.553571428571428e-06 1.5 6.553571428571428e-06 1.5 6.554129464285714e-06 0.0 6.5708705357142855e-06 0.0 6.571428571428571e-06 1.5 6.571428571428571e-06 1.5 6.5719866071428565e-06 0.0 6.588727678571428e-06 0.0 6.589285714285714e-06 1.5 6.589285714285714e-06 1.5 6.58984375e-06 0.0 6.606584821428571e-06 0.0 6.607142857142857e-06 1.5 6.607142857142857e-06 1.5 6.607700892857142e-06 0.0 6.624441964285714e-06 0.0 6.624999999999999e-06 1.5 6.624999999999999e-06 1.5 6.625558035714285e-06 0.0 6.6422991071428565e-06 0.0 6.642857142857142e-06 1.5 6.642857142857142e-06 1.5 6.643415178571428e-06 0.0 6.66015625e-06 0.0 6.660714285714286e-06 1.5 6.660714285714286e-06 1.5 6.661272321428571e-06 0.0 6.677455357142857e-06 0.0 6.678013392857142e-06 1.5 6.679129464285714e-06 1.5 6.6796875e-06 0.0 6.695312499999999e-06 0.0 6.695870535714285e-06 1.5 6.696986607142857e-06 1.5 6.697544642857142e-06 0.0 6.7131696428571424e-06 0.0 6.713727678571428e-06 1.5 6.714843749999999e-06 1.5 6.715401785714285e-06 0.0 6.731026785714286e-06 0.0 6.731584821428571e-06 1.5 6.7327008928571425e-06 1.5 6.733258928571428e-06 0.0 6.748883928571428e-06 0.0 6.749441964285714e-06 1.5 6.750558035714285e-06 1.5 6.751116071428571e-06 0.0 6.766741071428571e-06 0.0 6.767299107142857e-06 1.5 6.768415178571428e-06 1.5 6.768973214285714e-06 0.0 6.784598214285713e-06 0.0 6.785156249999999e-06 1.5 6.786272321428571e-06 1.5 6.786830357142857e-06 0.0 6.802455357142857e-06 0.0 6.8030133928571425e-06 1.5 6.8041294642857135e-06 1.5 6.804687499999999e-06 0.0 6.8203125e-06 0.0 6.820870535714285e-06 1.5 6.821986607142857e-06 1.5 6.8225446428571426e-06 0.0 6.838169642857142e-06 0.0 6.838727678571428e-06 1.5 6.83984375e-06 1.5 6.840401785714285e-06 0.0 6.856026785714285e-06 0.0 6.856584821428571e-06 1.5 6.857700892857142e-06 1.5 6.858258928571428e-06 0.0 6.8738839285714284e-06 0.0 6.8744419642857135e-06 1.5 6.875558035714285e-06 1.5 6.876116071428571e-06 0.0 6.891741071428571e-06 0.0 6.892299107142857e-06 1.5 6.8934151785714285e-06 1.5 6.8939732142857135e-06 0.0 6.909598214285714e-06 0.0 6.91015625e-06 1.5 6.911272321428571e-06 1.5 6.911830357142857e-06 0.0 6.927455357142856e-06 0.0 6.928013392857142e-06 1.5 6.929129464285714e-06 1.5 6.9296875e-06 0.0 6.9447544642857135e-06 0.0 6.945312499999999e-06 1.5 6.947544642857142e-06 1.5 6.948102678571428e-06 0.0 6.962611607142857e-06 0.0 6.963169642857143e-06 1.5 6.965401785714285e-06 1.5 6.965959821428571e-06 0.0 6.98046875e-06 0.0 6.981026785714285e-06 1.5 6.983258928571428e-06 1.5 6.983816964285714e-06 0.0 6.998325892857142e-06 0.0 6.998883928571428e-06 1.5 7.001116071428571e-06 1.5 7.001674107142857e-06 0.0 7.016183035714285e-06 0.0 7.016741071428571e-06 1.5 7.018973214285714e-06 1.5 7.019531249999999e-06 0.0 7.034040178571428e-06 0.0 7.0345982142857136e-06 1.5 7.036830357142856e-06 1.5 7.037388392857142e-06 0.0 7.051897321428571e-06 0.0 7.052455357142857e-06 1.5 7.0546874999999995e-06 1.5 7.0552455357142854e-06 0.0 7.069754464285714e-06 0.0 7.0703125e-06 1.5 7.072544642857143e-06 1.5 7.073102678571428e-06 0.0 7.087611607142856e-06 0.0 7.088169642857142e-06 1.5 7.090401785714285e-06 1.5 7.090959821428571e-06 0.0 7.1054687499999995e-06 0.0 7.106026785714285e-06 1.5 7.108258928571428e-06 1.5 7.108816964285714e-06 0.0 7.123325892857143e-06 0.0 7.123883928571428e-06 1.5 7.1261160714285705e-06 1.5 7.1266741071428564e-06 0.0 7.141183035714285e-06 0.0 7.141741071428571e-06 1.5 7.143973214285714e-06 1.5 7.14453125e-06 0.0 7.159040178571428e-06 0.0 7.159598214285714e-06 1.5 7.161830357142857e-06 1.5 7.162388392857143e-06 0.0 7.176339285714285e-06 0.0 7.176897321428571e-06 1.5 7.180245535714285e-06 1.5 7.180803571428571e-06 0.0 7.194196428571428e-06 0.0 7.194754464285714e-06 1.5 7.198102678571428e-06 1.5 7.198660714285714e-06 0.0 7.212053571428571e-06 0.0 7.212611607142857e-06 1.5 7.215959821428571e-06 1.5 7.2165178571428565e-06 0.0 7.229910714285714e-06 0.0 7.230468749999999e-06 1.5 7.233816964285714e-06 1.5 7.234375e-06 0.0 7.247767857142856e-06 0.0 7.248325892857142e-06 1.5 7.251674107142857e-06 1.5 7.252232142857142e-06 0.0 7.2656249999999996e-06 0.0 7.2661830357142855e-06 1.5 7.269531249999999e-06 1.5 7.270089285714285e-06 0.0 7.283482142857143e-06 0.0 7.284040178571428e-06 1.5 7.287388392857142e-06 1.5 7.287946428571428e-06 0.0 7.301339285714285e-06 0.0 7.301897321428571e-06 1.5 7.305245535714286e-06 1.5 7.305803571428571e-06 0.0 7.319196428571428e-06 0.0 7.319754464285714e-06 1.5 7.323102678571428e-06 1.5 7.323660714285714e-06 0.0 7.3370535714285706e-06 0.0 7.3376116071428565e-06 1.5 7.340959821428571e-06 1.5 7.341517857142857e-06 0.0 7.354910714285714e-06 0.0 7.35546875e-06 1.5 7.359374999999999e-06 1.5 7.359933035714285e-06 0.0 7.372209821428571e-06 0.0 7.372767857142857e-06 1.5 7.3772321428571425e-06 1.5 7.377790178571428e-06 0.0 7.390066964285714e-06 0.0 7.390624999999999e-06 1.5 7.395089285714285e-06 1.5 7.395647321428571e-06 0.0 7.4079241071428565e-06 0.0 7.408482142857142e-06 1.5 7.412946428571428e-06 1.5 7.413504464285714e-06 0.0 7.42578125e-06 0.0 7.4263392857142856e-06 1.5 7.430803571428571e-06 1.5 7.431361607142856e-06 0.0 7.443638392857142e-06 0.0 7.444196428571428e-06 1.5 7.4486607142857135e-06 1.5 7.449218749999999e-06 0.0 7.461495535714285e-06 0.0 7.462053571428571e-06 1.5 7.466517857142857e-06 1.5 7.4670758928571425e-06 0.0 7.479352678571428e-06 0.0 7.479910714285713e-06 1.5 7.484375e-06 1.5 7.484933035714285e-06 0.0 7.497209821428571e-06 0.0 7.4977678571428566e-06 1.5 7.502232142857142e-06 1.5 7.502790178571428e-06 0.0 7.515066964285714e-06 0.0 7.515625e-06 1.5 7.520089285714285e-06 1.5 7.520647321428571e-06 0.0 7.532924107142857e-06 0.0 7.533482142857142e-06 1.5 7.5385044642857135e-06 1.5 7.5390624999999994e-06 0.0 7.550223214285713e-06 0.0 7.550781249999999e-06 1.5 7.556361607142857e-06 1.5 7.556919642857143e-06 0.0 7.5680803571428566e-06 0.0 7.5686383928571425e-06 1.5 7.57421875e-06 1.5 7.574776785714285e-06 0.0 7.5859375e-06 0.0 7.586495535714285e-06 1.5 7.592075892857142e-06 1.5 7.592633928571428e-06 0.0 7.603794642857142e-06 0.0 7.604352678571428e-06 1.5 7.609933035714285e-06 1.5 7.610491071428571e-06 0.0 7.621651785714285e-06 0.0 7.622209821428571e-06 1.5 7.627790178571428e-06 1.5 7.628348214285714e-06 0.0 7.639508928571428e-06 0.0 7.640066964285714e-06 1.5 7.645647321428572e-06 1.5 7.646205357142857e-06 0.0 7.657366071428572e-06 0.0 7.657924107142857e-06 1.5 7.663504464285714e-06 1.5 7.664062499999999e-06 0.0 7.675223214285714e-06 0.0 7.675781249999999e-06 1.5 7.681361607142856e-06 1.5 7.681919642857143e-06 0.0 7.693080357142856e-06 0.0 7.693638392857143e-06 1.5 7.699218749999999e-06 1.5 7.699776785714285e-06 0.0 7.710379464285713e-06 0.0 7.7109375e-06 1.5 7.717633928571428e-06 1.5 7.718191964285715e-06 0.0 7.728236607142856e-06 0.0 7.728794642857143e-06 1.5 7.73549107142857e-06 1.5 7.736049107142857e-06 0.0 7.74609375e-06 0.0 7.746651785714285e-06 1.5 7.753348214285714e-06 1.5 7.75390625e-06 0.0 7.763950892857142e-06 0.0 7.764508928571427e-06 1.5 7.771205357142856e-06 1.5 7.771763392857141e-06 0.0 7.781808035714284e-06 0.0 7.782366071428571e-06 1.5 7.789062499999999e-06 1.5 7.789620535714286e-06 0.0 7.799665178571428e-06 0.0 7.800223214285714e-06 1.5 7.806919642857143e-06 1.5 7.807477678571428e-06 0.0 7.81752232142857e-06 0.0 7.818080357142856e-06 1.5 7.824776785714285e-06 1.5 7.82533482142857e-06 0.0 7.835379464285713e-06 0.0 7.8359375e-06 1.5 7.842633928571427e-06 1.5 7.843191964285714e-06 0.0 7.853236607142857e-06 0.0 7.853794642857142e-06 1.5 7.860491071428571e-06 1.5 7.861049107142856e-06 0.0 7.870535714285714e-06 0.0 7.87109375e-06 1.5 7.878906249999999e-06 1.5 7.879464285714286e-06 0.0 7.888392857142857e-06 0.0 7.888950892857142e-06 1.5 7.896763392857143e-06 1.5 7.897321428571428e-06 0.0 7.906249999999999e-06 0.0 7.906808035714286e-06 1.5 7.914620535714285e-06 1.5 7.91517857142857e-06 0.0 7.924107142857143e-06 0.0 7.924665178571428e-06 1.5 7.932477678571427e-06 1.5 7.933035714285714e-06 0.0 7.941964285714285e-06 0.0 7.94252232142857e-06 1.5 7.950334821428571e-06 1.5 7.950892857142857e-06 0.0 7.959821428571428e-06 0.0 7.960379464285714e-06 1.5 7.968191964285714e-06 1.5 7.968749999999999e-06 0.0 7.97767857142857e-06 0.0 7.978236607142857e-06 1.5 7.986049107142856e-06 1.5 7.986607142857143e-06 0.0 7.995535714285714e-06 0.0 7.996093749999999e-06 1.5 8.00390625e-06 1.5 8.004464285714285e-06 0.0 8.013392857142856e-06 0.0 8.013950892857141e-06 1.5 8.021763392857142e-06 1.5 8.022321428571428e-06 0.0 8.030691964285714e-06 0.0 8.031249999999999e-06 1.5 8.040178571428572e-06 1.5 8.040736607142857e-06 0.0 8.048549107142856e-06 0.0 8.049107142857143e-06 1.5 8.058035714285714e-06 1.5 8.058593749999999e-06 0.0 8.06640625e-06 0.0 8.066964285714285e-06 1.5 8.075892857142856e-06 1.5 8.076450892857143e-06 0.0 8.084263392857142e-06 0.0 8.084821428571427e-06 1.5 8.09375e-06 1.5 8.094308035714285e-06 0.0 8.102120535714285e-06 0.0 8.102678571428571e-06 1.5 8.111607142857143e-06 1.5 8.112165178571428e-06 0.0 8.119977678571429e-06 0.0 8.120535714285714e-06 1.5 8.129464285714285e-06 1.5 8.130022321428572e-06 0.0 8.137834821428571e-06 0.0 8.138392857142856e-06 1.5 8.147321428571427e-06 1.5 8.147879464285714e-06 0.0 8.155691964285713e-06 0.0 8.15625e-06 1.5 8.165178571428571e-06 1.5 8.165736607142856e-06 0.0 8.173549107142857e-06 0.0 8.174107142857142e-06 1.5 8.183035714285714e-06 1.5 8.183593749999999e-06 0.0 8.190848214285713e-06 0.0 8.19140625e-06 1.5 8.201450892857143e-06 1.5 8.202008928571428e-06 0.0 8.208705357142857e-06 0.0 8.209263392857142e-06 1.5 8.219308035714285e-06 1.5 8.21986607142857e-06 0.0 8.2265625e-06 0.0 8.227120535714284e-06 1.5 8.237165178571427e-06 1.5 8.237723214285714e-06 0.0 8.244419642857142e-06 0.0 8.244977678571428e-06 1.5 8.255022321428571e-06 1.5 8.255580357142856e-06 0.0 8.262276785714286e-06 0.0 8.26283482142857e-06 1.5 8.272879464285714e-06 1.5 8.273437499999999e-06 0.0 8.280133928571428e-06 0.0 8.280691964285713e-06 1.5 8.290736607142856e-06 1.5 8.291294642857143e-06 0.0 8.29799107142857e-06 0.0 8.298549107142857e-06 1.5 8.30859375e-06 1.5 8.309151785714285e-06 0.0 8.315848214285714e-06 0.0 8.31640625e-06 1.5 8.326450892857142e-06 1.5 8.327008928571427e-06 0.0 8.333705357142857e-06 0.0 8.334263392857142e-06 1.5 8.344308035714285e-06 1.5 8.344866071428571e-06 0.0 8.351004464285714e-06 0.0 8.351562499999999e-06 1.5 8.362723214285714e-06 1.5 8.363281249999999e-06 0.0 8.368861607142856e-06 0.0 8.369419642857143e-06 1.5 8.380580357142856e-06 1.5 8.381138392857143e-06 0.0 8.38671875e-06 0.0 8.387276785714285e-06 1.5 8.3984375e-06 1.5 8.398995535714285e-06 0.0 8.404575892857142e-06 0.0 8.405133928571428e-06 1.5 8.416294642857142e-06 1.5 8.416852678571427e-06 0.0 8.422433035714285e-06 0.0 8.422991071428572e-06 1.5 8.434151785714285e-06 1.5 8.434709821428571e-06 0.0 8.440290178571429e-06 0.0 8.440848214285714e-06 1.5 8.452008928571429e-06 1.5 8.452566964285714e-06 0.0 8.458147321428571e-06 0.0 8.458705357142856e-06 1.5 8.469866071428571e-06 1.5 8.470424107142856e-06 0.0 8.476004464285713e-06 0.0 8.4765625e-06 1.5 8.487723214285713e-06 1.5 8.48828125e-06 0.0 8.493861607142856e-06 0.0 8.494419642857143e-06 1.5 8.505580357142857e-06 1.5 8.506138392857142e-06 0.0 8.51171875e-06 0.0 8.512276785714285e-06 1.5 8.523995535714285e-06 1.5 8.524553571428571e-06 0.0 8.529017857142857e-06 0.0 8.529575892857142e-06 1.5 8.541852678571429e-06 1.5 8.542410714285714e-06 0.0 8.546875e-06 0.0 8.547433035714284e-06 1.5 8.559709821428571e-06 1.5 8.560267857142856e-06 0.0 8.564732142857142e-06 0.0 8.565290178571428e-06 1.5 8.577566964285713e-06 1.5 8.578125e-06 0.0 8.582589285714286e-06 0.0 8.58314732142857e-06 1.5 8.595424107142856e-06 1.5 8.595982142857142e-06 0.0 8.600446428571428e-06 0.0 8.601004464285713e-06 1.5 8.61328125e-06 1.5 8.613839285714285e-06 0.0 8.61830357142857e-06 0.0 8.618861607142857e-06 1.5 8.631138392857142e-06 1.5 8.631696428571427e-06 0.0 8.636160714285714e-06 0.0 8.63671875e-06 1.5 8.648995535714284e-06 1.5 8.649553571428571e-06 0.0 8.654017857142857e-06 0.0 8.654575892857142e-06 1.5 8.666852678571428e-06 1.5 8.667410714285713e-06 0.0 8.671874999999999e-06 0.0 8.672433035714286e-06 1.5 8.68470982142857e-06 1.5 8.685267857142856e-06 0.0 8.689732142857143e-06 0.0 8.690290178571428e-06 1.5 8.703125e-06 1.5 8.703683035714285e-06 0.0 8.707031249999999e-06 0.0 8.707589285714285e-06 1.5 8.720982142857142e-06 1.5 8.721540178571427e-06 0.0 8.724888392857143e-06 0.0 8.725446428571428e-06 1.5 8.738839285714284e-06 1.5 8.739397321428571e-06 0.0 8.742745535714285e-06 0.0 8.74330357142857e-06 1.5 8.756696428571428e-06 1.5 8.757254464285714e-06 0.0 8.760602678571427e-06 0.0 8.761160714285714e-06 1.5 8.77455357142857e-06 1.5 8.775111607142856e-06 0.0 8.778459821428571e-06 0.0 8.779017857142856e-06 1.5 8.792410714285713e-06 1.5 8.79296875e-06 0.0 8.796316964285714e-06 0.0 8.796874999999999e-06 1.5 8.810267857142857e-06 1.5 8.810825892857142e-06 0.0 8.814174107142856e-06 0.0 8.814732142857143e-06 1.5 8.828125e-06 1.5 8.828683035714285e-06 0.0 8.83203125e-06 0.0 8.832589285714285e-06 1.5 8.845982142857142e-06 1.5 8.846540178571429e-06 0.0 8.849888392857142e-06 0.0 8.850446428571427e-06 1.5 8.863839285714286e-06 1.5 8.86439732142857e-06 0.0 8.867745535714285e-06 0.0 8.868303571428571e-06 1.5 8.881696428571428e-06 1.5 8.882254464285713e-06 0.0 8.885602678571429e-06 0.0 8.886160714285714e-06 1.5 8.900111607142857e-06 1.5 8.900669642857142e-06 0.0 8.902901785714286e-06 0.0 8.903459821428571e-06 1.5 8.91796875e-06 1.5 8.918526785714285e-06 0.0 8.920758928571428e-06 0.0 8.921316964285713e-06 1.5 8.935825892857142e-06 1.5 8.936383928571429e-06 0.0 8.93861607142857e-06 0.0 8.939174107142857e-06 1.5 8.953683035714286e-06 1.5 8.954241071428571e-06 0.0 8.956473214285713e-06 0.0 8.95703125e-06 1.5 8.971540178571428e-06 1.5 8.972098214285713e-06 0.0 8.974330357142857e-06 0.0 8.974888392857142e-06 1.5 8.98939732142857e-06 1.5 8.989955357142857e-06 0.0 8.9921875e-06 0.0 8.992745535714284e-06 1.5 9.007254464285713e-06 1.5 9.0078125e-06 0.0 9.010044642857142e-06 0.0 9.010602678571428e-06 1.5 9.025111607142857e-06 1.5 9.025669642857142e-06 0.0 9.027901785714286e-06 0.0 9.02845982142857e-06 1.5 9.04296875e-06 1.5 9.043526785714286e-06 0.0 9.045758928571428e-06 0.0 9.046316964285713e-06 1.5 9.060825892857141e-06 1.5 9.061383928571428e-06 0.0 9.06361607142857e-06 0.0 9.064174107142857e-06 1.5 9.078683035714285e-06 1.5 9.07924107142857e-06 0.0 9.081473214285714e-06 0.0 9.08203125e-06 1.5 9.096540178571428e-06 1.5 9.097098214285713e-06 0.0 9.099330357142857e-06 0.0 9.099888392857142e-06 1.5 9.114955357142857e-06 1.5 9.115513392857142e-06 0.0 9.116629464285714e-06 0.0 9.117187499999999e-06 1.5 9.1328125e-06 1.5 9.133370535714284e-06 0.0 9.134486607142856e-06 0.0 9.135044642857143e-06 1.5 9.150669642857142e-06 1.5 9.151227678571428e-06 0.0 9.15234375e-06 0.0 9.152901785714285e-06 1.5 9.168526785714286e-06 1.5 9.16908482142857e-06 0.0 9.170200892857142e-06 0.0 9.170758928571428e-06 1.5 9.186383928571428e-06 1.5 9.186941964285713e-06 0.0 9.188058035714285e-06 0.0 9.188616071428572e-06 1.5 9.20424107142857e-06 1.5 9.204799107142857e-06 0.0 9.205915178571427e-06 0.0 9.206473214285714e-06 1.5 9.222098214285714e-06 1.5 9.22265625e-06 0.0 9.223772321428571e-06 0.0 9.224330357142856e-06 1.5 9.239955357142857e-06 1.5 9.240513392857142e-06 0.0 9.241629464285713e-06 0.0 9.242187499999998e-06 1.5 9.257812499999999e-06 1.5 9.258370535714286e-06 0.0 9.259486607142856e-06 0.0 9.260044642857143e-06 1.5 9.275669642857143e-06 1.5 9.276227678571428e-06 0.0 9.27734375e-06 0.0 9.277901785714285e-06 1.5 9.293526785714285e-06 1.5 9.29408482142857e-06 0.0 9.295200892857142e-06 0.0 9.295758928571427e-06 1.5 9.311383928571428e-06 1.5 9.311941964285714e-06 0.0 9.313058035714284e-06 0.0 9.313616071428571e-06 1.5 9.329241071428572e-06 1.5 9.329799107142857e-06 0.0 9.330915178571428e-06 0.0 9.331473214285713e-06 1.5 9.347098214285714e-06 1.5 9.347656249999999e-06 0.0 9.34877232142857e-06 0.0 9.349330357142856e-06 1.5 9.364955357142856e-06 1.5 9.365513392857143e-06 0.0 9.366629464285713e-06 0.0 9.3671875e-06 1.5 9.382812499999999e-06 1.5 9.383370535714285e-06 0.0 9.384486607142857e-06 0.0 9.385044642857142e-06 1.5 9.401227678571428e-06 1.5 9.401785714285714e-06 0.0 9.401785714285714e-06 0.0 9.40234375e-06 1.5 9.41908482142857e-06 1.5 9.419642857142857e-06 0.0 9.419642857142857e-06 0.0 9.420200892857142e-06 1.5 9.436941964285714e-06 1.5 9.437499999999999e-06 0.0 9.437499999999999e-06 0.0 9.438058035714286e-06 1.5 9.454799107142856e-06 1.5 9.455357142857143e-06 0.0 9.455357142857143e-06 0.0 9.455915178571428e-06 1.5 9.472656249999999e-06 1.5 9.473214285714285e-06 0.0 9.473214285714285e-06 0.0 9.47377232142857e-06 1.5 9.490513392857143e-06 1.5 9.491071428571428e-06 0.0 9.491071428571428e-06 0.0 9.491629464285714e-06 1.5 9.508370535714285e-06 1.5 9.50892857142857e-06 0.0 9.50892857142857e-06 0.0 9.509486607142857e-06 1.5 9.526227678571427e-06 1.5 9.526785714285714e-06 0.0 9.526785714285714e-06 0.0 9.527343749999999e-06 1.5 9.544084821428571e-06 1.5 9.544642857142856e-06 0.0 9.544642857142856e-06 0.0 9.545200892857141e-06 1.5 9.561941964285714e-06 1.5 9.562499999999999e-06 0.0 9.562499999999999e-06 0.0 9.563058035714285e-06 1.5 9.579799107142856e-06 1.5 9.580357142857143e-06 0.0 9.580357142857143e-06 0.0 9.580915178571428e-06 1.5 9.59765625e-06 1.5 9.598214285714285e-06 0.0 9.598214285714285e-06 0.0 9.59877232142857e-06 1.5 9.615513392857142e-06 1.5 9.616071428571427e-06 0.0 9.616071428571427e-06 0.0 9.616629464285714e-06 1.5 9.633370535714285e-06 1.5 9.633928571428571e-06 0.0 9.633928571428571e-06 0.0 9.634486607142856e-06 1.5 9.651227678571429e-06 1.5 9.651785714285714e-06 0.0 9.651785714285714e-06 0.0 9.652343749999999e-06 1.5 9.669084821428571e-06 1.5 9.669642857142856e-06 0.0 9.669642857142856e-06 0.0 9.670200892857143e-06 1.5 9.686941964285713e-06 1.5 9.6875e-06 0.0 9.6875e-06 0.0 9.688058035714285e-06 1.5 9.704799107142857e-06 1.5 9.705357142857142e-06 0.0 9.705357142857142e-06 0.0 9.705915178571427e-06 1.5 9.72265625e-06 1.5 9.723214285714285e-06 0.0 9.723214285714285e-06 0.0 9.723772321428571e-06 1.5 9.740513392857142e-06 1.5 9.741071428571429e-06 0.0 9.741071428571429e-06 0.0 9.741629464285714e-06 1.5 9.758370535714284e-06 1.5 9.758928571428571e-06 0.0 9.758928571428571e-06 0.0 9.759486607142856e-06 1.5 9.776227678571428e-06 1.5 9.776785714285713e-06 0.0 9.776785714285713e-06 0.0 9.77734375e-06 1.5 9.79408482142857e-06 1.5 9.794642857142856e-06 0.0 9.794642857142856e-06 0.0 9.795200892857142e-06 1.5 9.811941964285713e-06 1.5 9.8125e-06 0.0 9.8125e-06 0.0 9.813058035714285e-06 1.5 9.829799107142857e-06 1.5 9.830357142857142e-06 0.0 9.830357142857142e-06 0.0 9.830915178571427e-06 1.5 9.84765625e-06 1.5 9.848214285714284e-06 0.0 9.848214285714284e-06 0.0 9.848772321428571e-06 1.5 9.865513392857142e-06 1.5 9.866071428571428e-06 0.0 9.866071428571428e-06 0.0 9.866629464285713e-06 1.5 9.883370535714286e-06 1.5 9.88392857142857e-06 0.0 9.88392857142857e-06 0.0 9.884486607142856e-06 1.5 9.901227678571428e-06 1.5 9.901785714285713e-06 0.0 9.901785714285713e-06 0.0 9.90234375e-06 1.5 9.91908482142857e-06 1.5 9.919642857142857e-06 0.0 9.919642857142857e-06 0.0 9.920200892857142e-06 1.5 9.936941964285714e-06 1.5 9.9375e-06 0.0 9.9375e-06 0.0 9.938058035714284e-06 1.5 9.954799107142857e-06 1.5 9.955357142857142e-06 0.0 9.955357142857142e-06 0.0 9.955915178571428e-06 1.5 9.972656249999999e-06 1.5 9.973214285714286e-06 0.0 9.973214285714286e-06 0.0 9.97377232142857e-06 1.5 9.990513392857143e-06 1.5 9.991071428571428e-06 0.0 9.991071428571428e-06 0.0 9.991629464285713e-06 1.5 1.0008370535714285e-05 1.5 1.000892857142857e-05 0.0 1.000892857142857e-05 0.0 1.0009486607142857e-05 1.5 1.0026227678571428e-05 1.5 1.0026785714285714e-05 0.0 1.0026785714285714e-05 0.0 1.002734375e-05 1.5 1.004408482142857e-05 1.5 1.0044642857142857e-05 0.0 1.0044642857142857e-05 0.0 1.0045200892857142e-05 1.5 1.0061941964285714e-05 1.5 1.0062499999999999e-05 0.0 1.0062499999999999e-05 0.0 1.0063058035714286e-05 1.5 1.0079799107142856e-05 1.5 1.0080357142857143e-05 0.0 1.0080357142857143e-05 0.0 1.0080915178571428e-05 1.5 1.0097656249999999e-05 1.5 1.0098214285714285e-05 0.0 1.0098214285714285e-05 0.0 1.009877232142857e-05 1.5 1.0115513392857143e-05 1.5 1.0116071428571428e-05 0.0 1.0116071428571428e-05 0.0 1.0116629464285714e-05 1.5 1.0133370535714285e-05 1.5 1.013392857142857e-05 0.0 1.013392857142857e-05 0.0 1.0134486607142857e-05 1.5 1.0151227678571427e-05 1.5 1.0151785714285714e-05 0.0 1.0151785714285714e-05 0.0 1.0152343749999999e-05 1.5 1.0169084821428571e-05 1.5 1.0169642857142856e-05 0.0 1.0169642857142856e-05 0.0 1.0170200892857141e-05 1.5 1.0186941964285714e-05 1.5 1.0187499999999999e-05 0.0 1.0187499999999999e-05 0.0 1.0188058035714285e-05 1.5 1.0204799107142856e-05 1.5 1.0205357142857143e-05 0.0 1.0205357142857143e-05 0.0 1.0205915178571428e-05 1.5 1.022265625e-05 1.5 1.0223214285714285e-05 0.0 1.0223214285714285e-05 0.0 1.022377232142857e-05 1.5 1.0240513392857142e-05 1.5 1.0241071428571427e-05 0.0 1.0241071428571427e-05 0.0 1.0241629464285714e-05 1.5 1.0258370535714285e-05 1.5 1.0258928571428571e-05 0.0 1.0258928571428571e-05 0.0 1.0259486607142856e-05 1.5 1.0276227678571429e-05 1.5 1.0276785714285714e-05 0.0 1.0276785714285714e-05 0.0 1.0277343749999999e-05 1.5 1.0294084821428571e-05 1.5 1.0294642857142856e-05 0.0 1.0294642857142856e-05 0.0 1.0295200892857143e-05 1.5 1.0311941964285713e-05 1.5 1.03125e-05 0.0 1.03125e-05 0.0 1.0313058035714285e-05 1.5 1.0329799107142857e-05 1.5 1.0330357142857142e-05 0.0 1.0330357142857142e-05 0.0 1.0330915178571427e-05 1.5 1.034765625e-05 1.5 1.0348214285714285e-05 0.0 1.0348214285714285e-05 0.0 1.0348772321428571e-05 1.5 1.0365513392857142e-05 1.5 1.0366071428571429e-05 0.0 1.0366071428571429e-05 0.0 1.0366629464285714e-05 1.5 1.0383370535714284e-05 1.5 1.0383928571428571e-05 0.0 1.0383928571428571e-05 0.0 1.0384486607142856e-05 1.5 1.0401227678571428e-05 1.5 1.0401785714285713e-05 0.0 1.0401785714285713e-05 0.0 1.040234375e-05 1.5 1.041908482142857e-05 1.5 1.0419642857142856e-05 0.0 1.0419642857142856e-05 0.0 1.0420200892857142e-05 1.5 1.0436941964285713e-05 1.5 1.04375e-05 0.0 1.04375e-05 0.0 1.0438058035714285e-05 1.5 1.0454799107142857e-05 1.5 1.0455357142857142e-05 0.0 1.0455357142857142e-05 0.0 1.0455915178571427e-05 1.5 1.047265625e-05 1.5 1.0473214285714284e-05 0.0 1.0473214285714284e-05 0.0 1.0473772321428571e-05 1.5 1.0490513392857142e-05 1.5 1.0491071428571428e-05 0.0 1.0491071428571428e-05 0.0 1.0491629464285713e-05 1.5 1.0508370535714286e-05 1.5 1.050892857142857e-05 0.0 1.050892857142857e-05 0.0 1.0509486607142856e-05 1.5 1.0526227678571428e-05 1.5 1.0526785714285713e-05 0.0 1.0526785714285713e-05 0.0 1.052734375e-05 1.5 1.054408482142857e-05 1.5 1.0544642857142857e-05 0.0 1.0544642857142857e-05 0.0 1.0545200892857142e-05 1.5 1.0561941964285714e-05 1.5 1.05625e-05 0.0 1.05625e-05 0.0 1.0563058035714284e-05 1.5 1.0579799107142857e-05 1.5 1.0580357142857142e-05 0.0 1.0580357142857142e-05 0.0 1.0580915178571428e-05 1.5 1.0597656249999999e-05 1.5 1.0598214285714286e-05 0.0 1.0598214285714286e-05 0.0 1.059877232142857e-05 1.5 1.0615513392857143e-05 1.5 1.0616071428571428e-05 0.0 1.0616071428571428e-05 0.0 1.0616629464285713e-05 1.5 1.0633370535714285e-05 1.5 1.063392857142857e-05 0.0 1.063392857142857e-05 0.0 1.0634486607142857e-05 1.5 1.0651227678571427e-05 1.5 1.0651785714285714e-05 0.0 1.0651785714285714e-05 0.0 1.065234375e-05 1.5 1.0669084821428572e-05 1.5 1.0669642857142857e-05 0.0 1.0669642857142857e-05 0.0 1.0670200892857142e-05 1.5 1.0686383928571427e-05 1.5 1.0686941964285714e-05 0.0 1.0688058035714286e-05 0.0 1.068861607142857e-05 1.5 1.0704241071428571e-05 1.5 1.0704799107142856e-05 0.0 1.0705915178571428e-05 0.0 1.0706473214285713e-05 1.5 1.0722098214285713e-05 1.5 1.0722656249999998e-05 0.0 1.072377232142857e-05 0.0 1.0724330357142857e-05 1.5 1.0739955357142856e-05 1.5 1.0740513392857142e-05 0.0 1.0741629464285714e-05 0.0 1.07421875e-05 1.5 1.07578125e-05 1.5 1.0758370535714285e-05 0.0 1.0759486607142857e-05 0.0 1.0760044642857142e-05 1.5 1.0775669642857142e-05 1.5 1.0776227678571427e-05 0.0 1.0777343749999999e-05 0.0 1.0777901785714286e-05 1.5 1.0793526785714284e-05 1.5 1.0794084821428571e-05 0.0 1.0795200892857141e-05 0.0 1.0795758928571428e-05 1.5 1.0811383928571428e-05 1.5 1.0811941964285713e-05 0.0 1.0813058035714285e-05 0.0 1.081361607142857e-05 1.5 1.082924107142857e-05 1.5 1.0829799107142856e-05 0.0 1.0830915178571428e-05 0.0 1.0831473214285713e-05 1.5 1.0847098214285713e-05 1.5 1.084765625e-05 0.0 1.084877232142857e-05 0.0 1.0849330357142857e-05 1.5 1.0864955357142857e-05 1.5 1.0865513392857142e-05 0.0 1.0866629464285714e-05 0.0 1.0867187499999999e-05 1.5 1.08828125e-05 1.5 1.0883370535714284e-05 0.0 1.0884486607142856e-05 0.0 1.0885044642857141e-05 1.5 1.0900669642857142e-05 1.5 1.0901227678571428e-05 0.0 1.0902343749999999e-05 0.0 1.0902901785714285e-05 1.5 1.0918526785714286e-05 1.5 1.091908482142857e-05 0.0 1.0920200892857143e-05 0.0 1.0920758928571428e-05 1.5 1.0936383928571428e-05 1.5 1.0936941964285713e-05 0.0 1.0938058035714285e-05 0.0 1.093861607142857e-05 1.5 1.095424107142857e-05 1.5 1.0954799107142857e-05 0.0 1.0956473214285714e-05 0.0 1.0957031249999999e-05 1.5 1.0971540178571428e-05 1.5 1.0972098214285713e-05 0.0 1.0974330357142856e-05 0.0 1.0974888392857141e-05 1.5 1.098939732142857e-05 1.5 1.0989955357142857e-05 0.0 1.0992187499999999e-05 0.0 1.0992745535714285e-05 1.5 1.1007254464285714e-05 1.5 1.1007812499999999e-05 0.0 1.1010044642857143e-05 0.0 1.1010602678571428e-05 1.5 1.1025111607142856e-05 1.5 1.1025669642857141e-05 0.0 1.1027901785714285e-05 0.0 1.102845982142857e-05 1.5 1.1042968749999999e-05 1.5 1.1043526785714285e-05 0.0 1.1045758928571427e-05 0.0 1.1046316964285714e-05 1.5 1.1060825892857143e-05 1.5 1.1061383928571428e-05 0.0 1.1063616071428571e-05 0.0 1.1064174107142856e-05 1.5 1.1078683035714285e-05 1.5 1.107924107142857e-05 0.0 1.1081473214285714e-05 0.0 1.1082031249999999e-05 1.5 1.1096540178571427e-05 1.5 1.1097098214285714e-05 0.0 1.1099330357142856e-05 0.0 1.1099888392857143e-05 1.5 1.1114397321428571e-05 1.5 1.1114955357142856e-05 0.0 1.11171875e-05 0.0 1.1117745535714285e-05 1.5 1.1132254464285714e-05 1.5 1.1132812499999999e-05 0.0 1.1135044642857142e-05 0.0 1.1135602678571427e-05 1.5 1.1150111607142856e-05 1.5 1.1150669642857143e-05 0.0 1.1152901785714285e-05 0.0 1.1153459821428571e-05 1.5 1.116796875e-05 1.5 1.1168526785714285e-05 0.0 1.1170758928571427e-05 0.0 1.1171316964285714e-05 1.5 1.1185267857142856e-05 1.5 1.1185825892857142e-05 0.0 1.1189174107142856e-05 0.0 1.1189732142857143e-05 1.5 1.1203125e-05 1.5 1.1203683035714285e-05 0.0 1.1207031249999998e-05 0.0 1.1207589285714285e-05 1.5 1.1220982142857142e-05 1.5 1.1221540178571427e-05 0.0 1.1224888392857142e-05 0.0 1.1225446428571427e-05 1.5 1.1238839285714284e-05 1.5 1.1239397321428571e-05 0.0 1.1242745535714285e-05 0.0 1.124330357142857e-05 1.5 1.1256696428571428e-05 1.5 1.1257254464285713e-05 0.0 1.1260602678571427e-05 0.0 1.1261160714285714e-05 1.5 1.127455357142857e-05 1.5 1.1275111607142856e-05 0.0 1.1278459821428571e-05 0.0 1.1279017857142856e-05 1.5 1.1292410714285713e-05 1.5 1.129296875e-05 0.0 1.1296316964285713e-05 0.0 1.1296874999999998e-05 1.5 1.1310267857142857e-05 1.5 1.1310825892857142e-05 0.0 1.1314174107142856e-05 0.0 1.1314732142857142e-05 1.5 1.1328125e-05 1.5 1.1328683035714284e-05 0.0 1.133203125e-05 0.0 1.1332589285714285e-05 1.5 1.1345982142857142e-05 1.5 1.1346540178571428e-05 0.0 1.1349888392857142e-05 0.0 1.1350446428571427e-05 1.5 1.1363839285714286e-05 1.5 1.136439732142857e-05 0.0 1.1367745535714284e-05 0.0 1.1368303571428571e-05 1.5 1.1381138392857143e-05 1.5 1.1381696428571428e-05 0.0 1.1386160714285713e-05 0.0 1.1386718749999999e-05 1.5 1.1398995535714285e-05 1.5 1.139955357142857e-05 0.0 1.1404017857142856e-05 0.0 1.1404575892857143e-05 1.5 1.1416852678571427e-05 1.5 1.1417410714285714e-05 0.0 1.1421875e-05 0.0 1.1422433035714285e-05 1.5 1.143470982142857e-05 1.5 1.1435267857142857e-05 0.0 1.1439732142857142e-05 0.0 1.1440290178571427e-05 1.5 1.1452566964285714e-05 1.5 1.1453124999999999e-05 0.0 1.1457589285714284e-05 0.0 1.1458147321428571e-05 1.5 1.1470424107142856e-05 1.5 1.1470982142857141e-05 0.0 1.1475446428571428e-05 0.0 1.1476004464285714e-05 1.5 1.1488281249999998e-05 1.5 1.1488839285714285e-05 0.0 1.149330357142857e-05 0.0 1.1493861607142856e-05 1.5 1.1506138392857142e-05 1.5 1.1506696428571428e-05 0.0 1.1511160714285713e-05 0.0 1.151171875e-05 1.5 1.1523995535714285e-05 1.5 1.152455357142857e-05 0.0 1.1529017857142857e-05 0.0 1.1529575892857142e-05 1.5 1.1541852678571427e-05 1.5 1.1542410714285714e-05 0.0 1.1546875e-05 0.0 1.1547433035714285e-05 1.5 1.1559151785714284e-05 1.5 1.1559709821428571e-05 0.0 1.1565290178571429e-05 0.0 1.1565848214285714e-05 1.5 1.1577008928571428e-05 1.5 1.1577566964285713e-05 0.0 1.1583147321428571e-05 0.0 1.1583705357142856e-05 1.5 1.159486607142857e-05 1.5 1.1595424107142856e-05 0.0 1.1601004464285713e-05 0.0 1.16015625e-05 1.5 1.1612723214285713e-05 1.5 1.161328125e-05 0.0 1.1618861607142856e-05 0.0 1.1619419642857142e-05 1.5 1.1630580357142857e-05 1.5 1.1631138392857142e-05 0.0 1.163671875e-05 0.0 1.1637276785714285e-05 1.5 1.16484375e-05 1.5 1.1648995535714284e-05 0.0 1.1654575892857142e-05 0.0 1.1655133928571427e-05 1.5 1.1666294642857142e-05 1.5 1.1666852678571428e-05 0.0 1.1672433035714284e-05 0.0 1.1672991071428571e-05 1.5 1.1684151785714286e-05 1.5 1.168470982142857e-05 0.0 1.1690290178571428e-05 0.0 1.1690848214285713e-05 1.5 1.1702008928571428e-05 1.5 1.1702566964285713e-05 0.0 1.170814732142857e-05 0.0 1.1708705357142856e-05 1.5 1.1719308035714285e-05 1.5 1.171986607142857e-05 0.0 1.17265625e-05 0.0 1.1727120535714285e-05 1.5 1.1737165178571428e-05 1.5 1.1737723214285713e-05 0.0 1.1744419642857142e-05 0.0 1.1744977678571427e-05 1.5 1.175502232142857e-05 1.5 1.1755580357142857e-05 0.0 1.1762276785714284e-05 0.0 1.1762834821428571e-05 1.5 1.1772879464285714e-05 1.5 1.1773437499999999e-05 0.0 1.1780133928571428e-05 0.0 1.1780691964285713e-05 1.5 1.1790736607142856e-05 1.5 1.1791294642857141e-05 0.0 1.179799107142857e-05 0.0 1.1798549107142856e-05 1.5 1.1808593749999999e-05 1.5 1.1809151785714285e-05 0.0 1.1815848214285713e-05 0.0 1.181640625e-05 1.5 1.1826450892857143e-05 1.5 1.1827008928571428e-05 0.0 1.1833705357142857e-05 0.0 1.1834263392857142e-05 1.5 1.1844308035714285e-05 1.5 1.184486607142857e-05 0.0 1.18515625e-05 0.0 1.1852120535714284e-05 1.5 1.1862165178571427e-05 1.5 1.1862723214285714e-05 0.0 1.1869419642857142e-05 0.0 1.1869977678571428e-05 1.5 1.1879464285714285e-05 1.5 1.1880022321428571e-05 0.0 1.188783482142857e-05 0.0 1.1888392857142856e-05 1.5 1.1897321428571429e-05 1.5 1.1897879464285714e-05 0.0 1.1905691964285713e-05 0.0 1.190625e-05 1.5 1.1915178571428571e-05 1.5 1.1915736607142856e-05 0.0 1.1923549107142857e-05 0.0 1.1924107142857142e-05 1.5 1.1933035714285713e-05 1.5 1.193359375e-05 0.0 1.194140625e-05 0.0 1.1941964285714284e-05 1.5 1.1950892857142856e-05 1.5 1.1951450892857142e-05 0.0 1.1959263392857142e-05 0.0 1.1959821428571428e-05 1.5 1.196875e-05 1.5 1.1969308035714285e-05 0.0 1.1977120535714286e-05 0.0 1.197767857142857e-05 1.5 1.1986607142857142e-05 1.5 1.1987165178571427e-05 0.0 1.1994977678571428e-05 0.0 1.1995535714285713e-05 1.5 1.2004464285714284e-05 1.5 1.2005022321428571e-05 0.0 1.201283482142857e-05 0.0 1.2013392857142857e-05 1.5 1.2022321428571428e-05 1.5 1.2022879464285713e-05 0.0 1.2030691964285713e-05 0.0 1.203125e-05 1.5 1.2039620535714285e-05 1.5 1.204017857142857e-05 0.0 1.2049107142857142e-05 0.0 1.2049665178571428e-05 1.5 1.2057477678571428e-05 1.5 1.2058035714285713e-05 0.0 1.2066964285714284e-05 0.0 1.206752232142857e-05 1.5 1.207533482142857e-05 1.5 1.2075892857142857e-05 0.0 1.2084821428571428e-05 0.0 1.2085379464285713e-05 1.5 1.2093191964285714e-05 1.5 1.209375e-05 0.0 1.210267857142857e-05 0.0 1.2103236607142857e-05 1.5 1.2111049107142856e-05 1.5 1.2111607142857142e-05 0.0 1.2120535714285713e-05 0.0 1.212109375e-05 1.5 1.2128906249999999e-05 1.5 1.2129464285714286e-05 0.0 1.2138392857142857e-05 0.0 1.2138950892857142e-05 1.5 1.2146763392857143e-05 1.5 1.2147321428571428e-05 0.0 1.2156249999999999e-05 0.0 1.2156808035714284e-05 1.5 1.2164620535714285e-05 1.5 1.216517857142857e-05 0.0 1.2174107142857141e-05 0.0 1.2174665178571428e-05 1.5 1.2182477678571427e-05 1.5 1.2183035714285714e-05 0.0 1.2191964285714285e-05 0.0 1.219252232142857e-05 1.5 1.2199776785714285e-05 1.5 1.220033482142857e-05 0.0 1.2210379464285713e-05 0.0 1.22109375e-05 1.5 1.2217633928571427e-05 1.5 1.2218191964285714e-05 0.0 1.2228236607142857e-05 0.0 1.2228794642857142e-05 1.5 1.2235491071428571e-05 1.5 1.2236049107142856e-05 0.0 1.2246093749999999e-05 0.0 1.2246651785714284e-05 1.5 1.2253348214285713e-05 1.5 1.2253906249999998e-05 0.0 1.2263950892857141e-05 0.0 1.2264508928571428e-05 1.5 1.2271205357142856e-05 1.5 1.2271763392857142e-05 0.0 1.2281808035714285e-05 0.0 1.228236607142857e-05 1.5 1.22890625e-05 1.5 1.2289620535714285e-05 0.0 1.2299665178571428e-05 0.0 1.2300223214285713e-05 1.5 1.2306919642857142e-05 1.5 1.2307477678571427e-05 0.0 1.231752232142857e-05 0.0 1.2318080357142857e-05 1.5 1.2324776785714284e-05 1.5 1.2325334821428571e-05 0.0 1.2335379464285714e-05 0.0 1.2335937499999999e-05 1.5 1.2342633928571428e-05 1.5 1.2343191964285713e-05 0.0 1.2353236607142856e-05 0.0 1.2353794642857141e-05 1.5 1.236049107142857e-05 1.5 1.2361049107142856e-05 0.0 1.2371651785714285e-05 0.0 1.237220982142857e-05 1.5 1.2377790178571428e-05 1.5 1.2378348214285713e-05 0.0 1.2389508928571428e-05 0.0 1.2390066964285713e-05 1.5 1.239564732142857e-05 1.5 1.2396205357142857e-05 0.0 1.240736607142857e-05 0.0 1.2407924107142857e-05 1.5 1.2413504464285713e-05 1.5 1.24140625e-05 0.0 1.2425223214285714e-05 0.0 1.242578125e-05 1.5 1.2431361607142857e-05 1.5 1.2431919642857142e-05 0.0 1.2443080357142856e-05 0.0 1.2443638392857142e-05 1.5 1.2449218749999999e-05 1.5 1.2449776785714284e-05 0.0 1.2460937499999999e-05 0.0 1.2461495535714286e-05 1.5 1.2467075892857141e-05 1.5 1.2467633928571428e-05 0.0 1.2478794642857141e-05 0.0 1.2479352678571428e-05 1.5 1.2484933035714285e-05 1.5 1.248549107142857e-05 0.0 1.2496651785714285e-05 0.0 1.249720982142857e-05 1.5 1.2502790178571428e-05 1.5 1.2503348214285713e-05 0.0 1.2514508928571427e-05 0.0 1.2515066964285714e-05 1.5 1.252064732142857e-05 1.5 1.2521205357142857e-05 0.0 1.2532924107142857e-05 0.0 1.2533482142857142e-05 1.5 1.2537946428571427e-05 1.5 1.2538504464285714e-05 0.0 1.2550781249999999e-05 0.0 1.2551339285714286e-05 1.5 1.2555803571428571e-05 1.5 1.2556361607142856e-05 0.0 1.2568638392857141e-05 0.0 1.2569196428571428e-05 1.5 1.2573660714285714e-05 1.5 1.2574218749999999e-05 0.0 1.2586495535714285e-05 0.0 1.258705357142857e-05 1.5 1.2591517857142856e-05 1.5 1.2592075892857143e-05 0.0 1.2604352678571428e-05 0.0 1.2604910714285713e-05 1.5 1.2609375e-05 1.5 1.2609933035714285e-05 0.0 1.262220982142857e-05 0.0 1.2622767857142857e-05 1.5 1.2627232142857142e-05 1.5 1.2627790178571427e-05 0.0 1.2640066964285714e-05 0.0 1.2640624999999999e-05 1.5 1.2645089285714285e-05 1.5 1.2645647321428571e-05 0.0 1.2657924107142856e-05 0.0 1.2658482142857141e-05 1.5 1.2662946428571427e-05 1.5 1.2663504464285714e-05 0.0 1.2675781249999999e-05 0.0 1.2676339285714285e-05 1.5 1.2680803571428571e-05 1.5 1.2681361607142856e-05 0.0 1.2693638392857143e-05 0.0 1.2694196428571428e-05 1.5 1.2698660714285713e-05 1.5 1.269921875e-05 0.0 1.271205357142857e-05 0.0 1.2712611607142857e-05 1.5 1.271595982142857e-05 1.5 1.2716517857142856e-05 0.0 1.2729910714285714e-05 0.0 1.2730468749999999e-05 1.5 1.2733816964285713e-05 1.5 1.2734375e-05 0.0 1.2747767857142856e-05 0.0 1.2748325892857141e-05 1.5 1.2751674107142857e-05 1.5 1.2752232142857142e-05 0.0 1.2765624999999999e-05 0.0 1.2766183035714285e-05 1.5 1.2769531249999999e-05 1.5 1.2770089285714284e-05 0.0 1.2783482142857143e-05 0.0 1.2784040178571428e-05 1.5 1.2787388392857141e-05 1.5 1.2787946428571428e-05 0.0 1.2801339285714285e-05 0.0 1.280189732142857e-05 1.5 1.2805245535714285e-05 1.5 1.280580357142857e-05 0.0 1.2819196428571427e-05 0.0 1.2819754464285714e-05 1.5 1.2823102678571428e-05 1.5 1.2823660714285713e-05 0.0 1.2837053571428571e-05 0.0 1.2837611607142856e-05 1.5 1.284095982142857e-05 1.5 1.2841517857142857e-05 0.0 1.2854910714285714e-05 0.0 1.2855468749999999e-05 1.5 1.2858816964285714e-05 1.5 1.2859375e-05 0.0 1.2872767857142856e-05 0.0 1.2873325892857143e-05 1.5 1.2876674107142856e-05 1.5 1.2877232142857141e-05 0.0 1.2890624999999998e-05 0.0 1.2891183035714285e-05 1.5 1.2894531249999999e-05 1.5 1.2895089285714286e-05 0.0 1.2909040178571427e-05 0.0 1.2909598214285714e-05 1.5 1.2911830357142856e-05 1.5 1.2912388392857143e-05 0.0 1.2926897321428571e-05 0.0 1.2927455357142856e-05 1.5 1.2929687499999998e-05 1.5 1.2930245535714285e-05 0.0 1.2944754464285714e-05 0.0 1.2945312499999999e-05 1.5 1.2947544642857142e-05 1.5 1.2948102678571427e-05 0.0 1.2962611607142856e-05 0.0 1.2963169642857143e-05 1.5 1.2965401785714285e-05 1.5 1.296595982142857e-05 0.0 1.2980468749999998e-05 0.0 1.2981026785714285e-05 1.5 1.2983258928571427e-05 1.5 1.2983816964285714e-05 0.0 1.2998325892857142e-05 0.0 1.2998883928571427e-05 1.5 1.3001116071428571e-05 1.5 1.3001674107142856e-05 0.0 1.3016183035714285e-05 0.0 1.301674107142857e-05 1.5 1.3018973214285713e-05 1.5 1.3019531249999998e-05 0.0 1.3034040178571427e-05 0.0 1.3034598214285714e-05 1.5 1.3036830357142856e-05 1.5 1.3037388392857142e-05 0.0 1.3051897321428571e-05 0.0 1.3052455357142856e-05 1.5 1.30546875e-05 1.5 1.3055245535714285e-05 0.0 1.3069754464285713e-05 0.0 1.3070312499999998e-05 1.5 1.3072544642857142e-05 1.5 1.3073102678571427e-05 0.0 1.3087611607142856e-05 0.0 1.3088169642857142e-05 1.5 1.3090401785714284e-05 1.5 1.3090959821428571e-05 0.0 1.310546875e-05 0.0 1.3106026785714285e-05 1.5 1.3108258928571428e-05 1.5 1.3108816964285713e-05 0.0 1.3123883928571427e-05 0.0 1.3124441964285714e-05 1.5 1.3125558035714286e-05 1.5 1.312611607142857e-05 0.0 1.3141741071428571e-05 0.0 1.3142299107142856e-05 1.5 1.3143415178571428e-05 1.5 1.3143973214285713e-05 0.0 1.3159598214285713e-05 0.0 1.3160156249999998e-05 1.5 1.316127232142857e-05 1.5 1.3161830357142857e-05 0.0 1.3177455357142856e-05 0.0 1.3178013392857142e-05 1.5 1.3179129464285713e-05 1.5 1.31796875e-05 0.0 1.31953125e-05 0.0 1.3195870535714285e-05 1.5 1.3196986607142857e-05 1.5 1.3197544642857142e-05 0.0 1.3213169642857142e-05 0.0 1.3213727678571427e-05 1.5 1.3214843749999999e-05 1.5 1.3215401785714284e-05 0.0 1.3231026785714284e-05 0.0 1.3231584821428571e-05 1.5 1.3232700892857141e-05 1.5 1.3233258928571428e-05 0.0 1.3248883928571428e-05 0.0 1.3249441964285713e-05 1.5 1.3250558035714285e-05 1.5 1.325111607142857e-05 0.0 1.326674107142857e-05 0.0 1.3267299107142856e-05 1.5 1.3268415178571428e-05 1.5 1.3268973214285713e-05 0.0 1.3284598214285713e-05 0.0 1.328515625e-05 1.5 1.328627232142857e-05 1.5 1.3286830357142857e-05 0.0 1.3302455357142855e-05 0.0 1.3303013392857142e-05 1.5 1.3304129464285714e-05 1.5 1.3304687499999999e-05 0.0 1.33203125e-05 0.0 1.3320870535714284e-05 1.5 1.3321986607142856e-05 1.5 1.3322544642857141e-05 0.0 1.3338169642857142e-05 0.0 1.3338727678571428e-05 1.5 1.3339843749999999e-05 1.5 1.3340401785714285e-05 0.0 1.3356026785714284e-05 0.0 1.335658482142857e-05 1.5 1.3357700892857143e-05 1.5 1.3358258928571428e-05 0.0 1.3373883928571428e-05 0.0 1.3374441964285713e-05 1.5 1.3375558035714285e-05 1.5 1.337611607142857e-05 0.0 1.339174107142857e-05 0.0 1.3392299107142855e-05 1.5 1.3393415178571427e-05 1.5 1.3393973214285714e-05 0.0 1.341015625e-05 0.0 1.3410714285714284e-05 1.5 1.3410714285714284e-05 1.5 1.3411272321428571e-05 0.0 1.3428013392857142e-05 0.0 1.3428571428571427e-05 1.5 1.3428571428571427e-05 1.5 1.3429129464285714e-05 0.0 1.3445870535714284e-05 0.0 1.344642857142857e-05 1.5 1.344642857142857e-05 1.5 1.3446986607142856e-05 0.0 1.3463727678571428e-05 0.0 1.3464285714285713e-05 1.5 1.3464285714285713e-05 1.5 1.3464843749999998e-05 0.0 1.348158482142857e-05 0.0 1.3482142857142855e-05 1.5 1.3482142857142855e-05 1.5 1.3482700892857142e-05 0.0 1.3499441964285713e-05 0.0 1.35e-05 1.5 1.35e-05 1.5 1.3500558035714285e-05 0.0 1.3517299107142857e-05 0.0 1.3517857142857142e-05 1.5 1.3517857142857142e-05 1.5 1.3518415178571427e-05 0.0 1.3535156249999999e-05 0.0 1.3535714285714284e-05 1.5 1.3535714285714284e-05 1.5 1.3536272321428571e-05 0.0 1.3553013392857141e-05 0.0 1.3553571428571428e-05 1.5 1.3553571428571428e-05 1.5 1.3554129464285713e-05 0.0 1.3570870535714285e-05 0.0 1.357142857142857e-05 1.5 1.357142857142857e-05 1.5 1.3571986607142856e-05 0.0 1.3588727678571428e-05 0.0 1.3589285714285713e-05 1.5 1.3589285714285713e-05 1.5 1.358984375e-05 0.0 1.360658482142857e-05 0.0 1.3607142857142857e-05 1.5 1.3607142857142857e-05 1.5 1.3607700892857142e-05 0.0 1.3624441964285714e-05 0.0 1.3624999999999999e-05 1.5 1.3624999999999999e-05 1.5 1.3625558035714284e-05 0.0 1.3642299107142856e-05 0.0 1.3642857142857141e-05 1.5 1.3642857142857141e-05 1.5 1.3643415178571428e-05 0.0 1.3660156249999999e-05 0.0 1.3660714285714285e-05 1.5 1.3660714285714285e-05 1.5 1.366127232142857e-05 0.0 1.3678013392857141e-05 0.0 1.3678571428571428e-05 1.5 1.3678571428571428e-05 1.5 1.3679129464285713e-05 0.0 1.3695870535714285e-05 0.0 1.369642857142857e-05 1.5 1.369642857142857e-05 1.5 1.3696986607142857e-05 0.0 1.3713727678571427e-05 0.0 1.3714285714285714e-05 1.5 1.3714285714285714e-05 1.5 1.371484375e-05 0.0 1.373158482142857e-05 0.0 1.3732142857142856e-05 1.5 1.3732142857142856e-05 1.5 1.3732700892857142e-05 0.0 1.3749441964285714e-05 0.0 1.3749999999999999e-05 1.5 1.3749999999999999e-05 1.5 1.3750558035714286e-05 0.0 1.3767299107142856e-05 0.0 1.3767857142857141e-05 1.5 1.3767857142857141e-05 1.5 1.3768415178571428e-05 0.0 1.3785156249999998e-05 0.0 1.3785714285714285e-05 1.5 1.3785714285714285e-05 1.5 1.378627232142857e-05 0.0 1.3803013392857142e-05 0.0 1.3803571428571427e-05 1.5 1.3803571428571427e-05 1.5 1.3804129464285713e-05 0.0 1.3820870535714285e-05 0.0 1.382142857142857e-05 1.5 1.382142857142857e-05 1.5 1.3821986607142857e-05 0.0 1.3838727678571427e-05 0.0 1.3839285714285714e-05 1.5 1.3839285714285714e-05 1.5 1.3839843749999999e-05 0.0 1.3856584821428571e-05 0.0 1.3857142857142856e-05 1.5 1.3857142857142856e-05 1.5 1.3857700892857141e-05 0.0 1.3874441964285713e-05 0.0 1.3874999999999998e-05 1.5 1.3874999999999998e-05 1.5 1.3875558035714285e-05 0.0 1.3892299107142856e-05 0.0 1.3892857142857142e-05 1.5 1.3892857142857142e-05 1.5 1.3893415178571428e-05 0.0 1.391015625e-05 0.0 1.3910714285714285e-05 1.5 1.3910714285714285e-05 1.5 1.391127232142857e-05 0.0 1.3928013392857142e-05 0.0 1.3928571428571427e-05 1.5 1.3928571428571427e-05 1.5 1.3929129464285714e-05 0.0 1.3945870535714284e-05 0.0 1.3946428571428571e-05 1.5 1.3946428571428571e-05 1.5 1.3946986607142856e-05 0.0 1.3963727678571428e-05 0.0 1.3964285714285713e-05 1.5 1.3964285714285713e-05 1.5 1.3964843749999999e-05 0.0 1.398158482142857e-05 0.0 1.3982142857142856e-05 1.5 1.3982142857142856e-05 1.5 1.3982700892857143e-05 0.0 1.3999441964285713e-05 0.0 1.4e-05 1.5 1.4e-05 1.5 1.4000558035714285e-05 0.0 1.4017299107142855e-05 0.0 1.4017857142857142e-05 1.5 1.4017857142857142e-05 1.5 1.4018415178571427e-05 0.0 1.403515625e-05 0.0 1.4035714285714284e-05 1.5 1.4035714285714284e-05 1.5 1.4036272321428571e-05 0.0 1.4053013392857142e-05 0.0 1.4053571428571427e-05 1.5 1.4053571428571427e-05 1.5 1.4054129464285714e-05 0.0 1.4070870535714284e-05 0.0 1.407142857142857e-05 1.5 1.407142857142857e-05 1.5 1.4071986607142856e-05 0.0 1.4088727678571428e-05 0.0 1.4089285714285713e-05 1.5 1.4089285714285713e-05 1.5 1.4089843749999998e-05 0.0 1.410658482142857e-05 0.0 1.4107142857142855e-05 1.5 1.4107142857142855e-05 1.5 1.4107700892857142e-05 0.0 1.4124441964285713e-05 0.0 1.4125e-05 1.5 1.4125e-05 1.5 1.4125558035714285e-05 0.0 1.4142299107142857e-05 0.0 1.4142857142857142e-05 1.5 1.4142857142857142e-05 1.5 1.4143415178571427e-05 0.0 1.4160156249999999e-05 0.0 1.4160714285714284e-05 1.5 1.4160714285714284e-05 1.5 1.416127232142857e-05 0.0 1.4178013392857141e-05 0.0 1.4178571428571428e-05 1.5 1.4178571428571428e-05 1.5 1.4179129464285713e-05 0.0 1.4195870535714285e-05 0.0 1.419642857142857e-05 1.5 1.419642857142857e-05 1.5 1.4196986607142855e-05 0.0 1.4213727678571428e-05 0.0 1.4214285714285713e-05 1.5 1.4214285714285713e-05 1.5 1.421484375e-05 0.0 1.423158482142857e-05 0.0 1.4232142857142857e-05 1.5 1.4232142857142857e-05 1.5 1.4232700892857142e-05 0.0 1.4249441964285714e-05 0.0 1.4249999999999999e-05 1.5 1.4249999999999999e-05 1.5 1.4250558035714284e-05 0.0 1.4267299107142856e-05 0.0 1.4267857142857141e-05 1.5 1.4267857142857141e-05 1.5 1.4268415178571428e-05 0.0 1.4285156249999999e-05 0.0 1.4285714285714285e-05 1.5 1.4285714285714285e-05 1.5 1.428627232142857e-05 0.0 1.4303013392857141e-05 0.0 1.4303571428571428e-05 1.5 1.4303571428571428e-05 1.5 1.4304129464285713e-05 0.0 1.4320870535714285e-05 0.0 1.432142857142857e-05 1.5 1.432142857142857e-05 1.5 1.4321986607142857e-05 0.0 1.4338727678571427e-05 0.0 1.4339285714285714e-05 1.5 1.4339285714285714e-05 1.5 1.433984375e-05 0.0 1.435658482142857e-05 0.0 1.4357142857142856e-05 1.5 1.4357142857142856e-05 1.5 1.4357700892857141e-05 0.0 1.4374441964285714e-05 0.0 1.4374999999999999e-05 1.5 1.4374999999999999e-05 1.5 1.4375558035714285e-05 0.0 1.4392299107142856e-05 0.0 1.4392857142857141e-05 1.5 1.4392857142857141e-05 1.5 1.4393415178571428e-05 0.0 1.4410156249999998e-05 0.0 1.4410714285714285e-05 1.5 1.4410714285714285e-05 1.5 1.441127232142857e-05 0.0 1.4428013392857142e-05 0.0 1.4428571428571427e-05 1.5 1.4428571428571427e-05 1.5 1.4429129464285712e-05 0.0 1.4445870535714285e-05 0.0 1.444642857142857e-05 1.5 1.444642857142857e-05 1.5 1.4446986607142856e-05 0.0 1.4463727678571427e-05 0.0 1.4464285714285714e-05 1.5 1.4464285714285714e-05 1.5 1.4464843749999999e-05 0.0 1.4481584821428571e-05 0.0 1.4482142857142856e-05 1.5 1.4482142857142856e-05 1.5 1.4482700892857141e-05 0.0 1.4499441964285713e-05 0.0 1.4499999999999998e-05 1.5 1.4499999999999998e-05 1.5 1.4500558035714285e-05 0.0 1.4517299107142856e-05 0.0 1.4517857142857142e-05 1.5 1.4517857142857142e-05 1.5 1.4518415178571427e-05 0.0 1.453515625e-05 0.0 1.4535714285714285e-05 1.5 1.4535714285714285e-05 1.5 1.453627232142857e-05 0.0 1.4553013392857142e-05 0.0 1.4553571428571427e-05 1.5 1.4553571428571427e-05 1.5 1.4554129464285714e-05 0.0 1.4570870535714284e-05 0.0 1.4571428571428571e-05 1.5 1.4571428571428571e-05 1.5 1.4571986607142856e-05 0.0 1.4588727678571428e-05 0.0 1.4589285714285713e-05 1.5 1.4589285714285713e-05 1.5 1.4589843749999998e-05 0.0 1.460658482142857e-05 0.0 1.4607142857142856e-05 1.5 1.4607142857142856e-05 1.5 1.4607700892857142e-05 0.0 1.4624441964285713e-05 0.0 1.4625e-05 1.5 1.4625e-05 1.5 1.4625558035714285e-05 0.0 1.4642299107142855e-05 0.0 1.4642857142857142e-05 1.5 1.4642857142857142e-05 1.5 1.4643415178571427e-05 0.0 1.466015625e-05 0.0 1.4660714285714284e-05 1.5 1.4660714285714284e-05 1.5 1.4661272321428571e-05 0.0 1.4678013392857142e-05 0.0 1.4678571428571427e-05 1.5 1.4678571428571427e-05 1.5 1.4679129464285713e-05 0.0 1.4695312499999999e-05 0.0 1.4695870535714284e-05 1.5 1.4696986607142856e-05 1.5 1.4697544642857143e-05 0.0 1.4713169642857141e-05 0.0 1.4713727678571428e-05 1.5 1.4714843749999998e-05 1.5 1.4715401785714285e-05 0.0 1.4731026785714285e-05 0.0 1.473158482142857e-05 1.5 1.4732700892857142e-05 1.5 1.4733258928571427e-05 0.0 1.4748883928571428e-05 0.0 1.4749441964285713e-05 1.5 1.4750558035714284e-05 1.5 1.4751116071428571e-05 0.0 1.476674107142857e-05 0.0 1.4767299107142857e-05 1.5 1.4768415178571427e-05 1.5 1.4768973214285714e-05 0.0 1.4784598214285714e-05 0.0 1.4785156249999999e-05 1.5 1.478627232142857e-05 1.5 1.4786830357142856e-05 0.0 1.4802455357142856e-05 0.0 1.4803013392857141e-05 1.5 1.4804129464285713e-05 1.5 1.4804687499999998e-05 0.0 1.4820312499999999e-05 0.0 1.4820870535714285e-05 1.5 1.4821986607142855e-05 1.5 1.4822544642857142e-05 0.0 1.4838169642857143e-05 0.0 1.4838727678571428e-05 1.5 1.483984375e-05 1.5 1.4840401785714285e-05 0.0 1.4856026785714285e-05 0.0 1.485658482142857e-05 1.5 1.4857700892857142e-05 1.5 1.4858258928571427e-05 0.0 1.4873883928571427e-05 0.0 1.4874441964285714e-05 1.5 1.4875558035714284e-05 1.5 1.4876116071428571e-05 0.0 1.489174107142857e-05 0.0 1.4892299107142856e-05 1.5 1.4893415178571428e-05 1.5 1.4893973214285713e-05 0.0 1.4909598214285714e-05 0.0 1.4910156249999999e-05 1.5 1.491127232142857e-05 1.5 1.4911830357142856e-05 0.0 1.4927455357142856e-05 0.0 1.4928013392857141e-05 1.5 1.4929129464285713e-05 1.5 1.49296875e-05 0.0 1.4945312499999998e-05 0.0 1.4945870535714285e-05 1.5 1.4946986607142857e-05 1.5 1.4947544642857142e-05 0.0 1.4963169642857142e-05 0.0 1.4963727678571427e-05 1.5 1.4964843749999999e-05 1.5 1.4965401785714284e-05 0.0 1.498046875e-05 0.0 1.4981026785714285e-05 1.5 1.4983258928571428e-05 1.5 1.4983816964285713e-05 0.0 1.4998325892857142e-05 0.0 1.4998883928571427e-05 1.5 1.500111607142857e-05 1.5 1.5001674107142856e-05 0.0 1.5016183035714284e-05 0.0 1.5016741071428571e-05 1.5 1.5018973214285713e-05 1.5 1.501953125e-05 0.0 1.5034040178571428e-05 0.0 1.5034598214285713e-05 1.5 1.5036830357142857e-05 1.5 1.5037388392857142e-05 0.0 1.505189732142857e-05 0.0 1.5052455357142856e-05 1.5 1.50546875e-05 1.5 1.5055245535714284e-05 0.0 1.5069754464285713e-05 0.0 1.50703125e-05 1.5 1.5072544642857141e-05 1.5 1.5073102678571428e-05 0.0 1.5087611607142857e-05 0.0 1.5088169642857142e-05 1.5 1.5090401785714284e-05 1.5 1.509095982142857e-05 0.0 1.5105468749999999e-05 0.0 1.5106026785714284e-05 1.5 1.5108258928571428e-05 1.5 1.5108816964285713e-05 0.0 1.5123325892857141e-05 0.0 1.5123883928571428e-05 1.5 1.512611607142857e-05 1.5 1.5126674107142855e-05 0.0 1.5141183035714285e-05 0.0 1.514174107142857e-05 1.5 1.5143973214285712e-05 1.5 1.514453125e-05 0.0 1.5159040178571428e-05 0.0 1.5159598214285713e-05 1.5 1.5161830357142856e-05 1.5 1.5162388392857142e-05 0.0 1.517689732142857e-05 0.0 1.5177455357142857e-05 1.5 1.5179687499999999e-05 1.5 1.5180245535714284e-05 0.0 1.5194196428571427e-05 0.0 1.5194754464285712e-05 1.5 1.5198102678571428e-05 1.5 1.5198660714285713e-05 0.0 1.521205357142857e-05 0.0 1.5212611607142856e-05 1.5 1.521595982142857e-05 1.5 1.5216517857142855e-05 0.0 1.5229910714285714e-05 0.0 1.5230468749999999e-05 1.5 1.5233816964285713e-05 1.5 1.5234375e-05 0.0 1.5247767857142856e-05 0.0 1.5248325892857141e-05 1.5 1.5251674107142857e-05 1.5 1.5252232142857142e-05 0.0 1.5265625e-05 0.0 1.5266183035714283e-05 1.5 1.526953125e-05 1.5 1.5270089285714284e-05 0.0 1.5283482142857142e-05 0.0 1.528404017857143e-05 1.5 1.5287388392857143e-05 1.5 1.5287946428571426e-05 0.0 1.5301339285714285e-05 0.0 1.530189732142857e-05 1.5 1.5305245535714285e-05 1.5 1.5305803571428572e-05 0.0 1.5319196428571427e-05 0.0 1.5319754464285714e-05 1.5 1.5323102678571428e-05 1.5 1.5323660714285714e-05 0.0 1.533705357142857e-05 0.0 1.5337611607142856e-05 1.5 1.534095982142857e-05 1.5 1.5341517857142857e-05 0.0 1.535491071428571e-05 0.0 1.535546875e-05 1.5 1.5358816964285712e-05 1.5 1.5359375e-05 0.0 1.5372767857142857e-05 0.0 1.537332589285714e-05 1.5 1.5376674107142855e-05 1.5 1.537723214285714e-05 0.0 1.5390066964285713e-05 0.0 1.5390625e-05 1.5 1.5395089285714284e-05 1.5 1.539564732142857e-05 0.0 1.5407924107142855e-05 0.0 1.5408482142857142e-05 1.5 1.5412946428571426e-05 1.5 1.5413504464285713e-05 0.0 1.5425781249999998e-05 0.0 1.5426339285714284e-05 1.5 1.543080357142857e-05 1.5 1.5431361607142855e-05 0.0 1.5443638392857143e-05 0.0 1.5444196428571427e-05 1.5 1.5448660714285714e-05 1.5 1.5449218749999997e-05 0.0 1.5461495535714286e-05 0.0 1.546205357142857e-05 1.5 1.5466517857142856e-05 1.5 1.5467075892857143e-05 0.0 1.5479352678571428e-05 0.0 1.5479910714285715e-05 1.5 1.5484375e-05 1.5 1.5484933035714285e-05 0.0 1.549720982142857e-05 0.0 1.5497767857142857e-05 1.5 1.550223214285714e-05 1.5 1.5502790178571428e-05 0.0 1.5515066964285713e-05 0.0 1.5515625e-05 1.5 1.5520089285714283e-05 1.5 1.552064732142857e-05 0.0 1.5532924107142855e-05 0.0 1.553348214285714e-05 1.5 1.553794642857143e-05 1.5 1.5538504464285712e-05 0.0 1.5550781249999997e-05 0.0 1.5551339285714284e-05 1.5 1.555580357142857e-05 1.5 1.5556361607142855e-05 0.0 1.5568080357142856e-05 0.0 1.5568638392857143e-05 1.5 1.557421875e-05 1.5 1.5574776785714284e-05 0.0 1.55859375e-05 0.0 1.5586495535714285e-05 1.5 1.5592075892857143e-05 1.5 1.5592633928571426e-05 0.0 1.560379464285714e-05 0.0 1.5604352678571428e-05 1.5 1.5609933035714285e-05 1.5 1.5610491071428572e-05 0.0 1.5621651785714283e-05 0.0 1.562220982142857e-05 1.5 1.5627790178571427e-05 1.5 1.5628348214285714e-05 0.0 1.563950892857143e-05 0.0 1.5640066964285712e-05 1.5 1.564564732142857e-05 1.5 1.5646205357142856e-05 0.0 1.565736607142857e-05 0.0 1.5657924107142855e-05 1.5 1.5663504464285712e-05 1.5 1.56640625e-05 0.0 1.5675223214285714e-05 0.0 1.567578125e-05 1.5 1.5681361607142858e-05 1.5 1.568191964285714e-05 0.0 1.5693080357142856e-05 0.0 1.5693638392857143e-05 1.5 1.569921875e-05 1.5 1.5699776785714283e-05 0.0 1.5710937499999998e-05 0.0 1.5711495535714285e-05 1.5 1.5717075892857142e-05 1.5 1.571763392857143e-05 0.0 1.5728236607142857e-05 0.0 1.572879464285714e-05 1.5 1.573549107142857e-05 1.5 1.5736049107142855e-05 0.0 1.574609375e-05 0.0 1.5746651785714286e-05 1.5 1.5753348214285714e-05 1.5 1.575390625e-05 0.0 1.5763950892857142e-05 0.0 1.576450892857143e-05 1.5 1.5771205357142856e-05 1.5 1.5771763392857143e-05 0.0 1.5781808035714284e-05 0.0 1.578236607142857e-05 1.5 1.57890625e-05 1.5 1.5789620535714285e-05 0.0 1.5799665178571426e-05 0.0 1.5800223214285713e-05 1.5 1.580691964285714e-05 1.5 1.5807477678571427e-05 0.0 1.581752232142857e-05 0.0 1.5818080357142856e-05 1.5 1.5824776785714283e-05 1.5 1.582533482142857e-05 0.0 1.5835379464285714e-05 0.0 1.5835937499999998e-05 1.5 1.584263392857143e-05 1.5 1.5843191964285712e-05 0.0 1.5853236607142857e-05 0.0 1.585379464285714e-05 1.5 1.586049107142857e-05 1.5 1.5861049107142854e-05 0.0 1.587109375e-05 0.0 1.5871651785714286e-05 1.5 1.5878348214285713e-05 1.5 1.587890625e-05 0.0 1.588895089285714e-05 0.0 1.5889508928571428e-05 1.5 1.5896763392857142e-05 1.5 1.5897321428571426e-05 0.0 1.590625e-05 0.0 1.5906808035714284e-05 1.5 1.5914620535714285e-05 1.5 1.591517857142857e-05 0.0 1.5924107142857143e-05 0.0 1.5924665178571426e-05 1.5 1.5932477678571427e-05 1.5 1.5933035714285714e-05 0.0 1.5941964285714285e-05 0.0 1.5942522321428572e-05 1.5 1.595033482142857e-05 1.5 1.5950892857142856e-05 0.0 1.5959821428571427e-05 0.0 1.5960379464285714e-05 1.5 1.5968191964285712e-05 1.5 1.596875e-05 0.0 1.597767857142857e-05 0.0 1.5978236607142856e-05 1.5 1.5986049107142857e-05 1.5 1.598660714285714e-05 0.0 1.5995535714285712e-05 0.0 1.599609375e-05 1.5 1.600390625e-05 1.5 1.6004464285714283e-05 0.0 1.6013392857142854e-05 0.0 1.601395089285714e-05 1.5 1.6021763392857142e-05 1.5 1.602232142857143e-05 0.0 1.603125e-05 0.0 1.6031808035714283e-05 1.5 1.6039620535714284e-05 1.5 1.604017857142857e-05 0.0 1.6049107142857142e-05 0.0 1.6049665178571426e-05 1.5 1.6058035714285714e-05 1.5 1.605859375e-05 0.0 1.6066406249999998e-05 0.0 1.6066964285714285e-05 1.5 1.6075892857142856e-05 1.5 1.6076450892857143e-05 0.0 1.608426339285714e-05 0.0 1.6084821428571427e-05 1.5 1.6093749999999998e-05 1.5 1.6094308035714285e-05 0.0 1.6102120535714286e-05 0.0 1.610267857142857e-05 1.5 1.611160714285714e-05 1.5 1.6112165178571427e-05 0.0 1.6119977678571428e-05 0.0 1.612053571428571e-05 1.5 1.6129464285714286e-05 1.5 1.613002232142857e-05 0.0 1.613783482142857e-05 0.0 1.6138392857142857e-05 1.5 1.614732142857143e-05 1.5 1.6147879464285712e-05 0.0 1.6155691964285713e-05 0.0 1.615625e-05 1.5 1.616517857142857e-05 1.5 1.6165736607142858e-05 0.0 1.6173549107142855e-05 0.0 1.6174107142857142e-05 1.5 1.6183035714285713e-05 1.5 1.618359375e-05 0.0 1.6191406249999998e-05 0.0 1.6191964285714284e-05 1.5 1.6200892857142855e-05 1.5 1.6201450892857142e-05 0.0 1.6209263392857143e-05 0.0 1.6209821428571427e-05 1.5 1.6219308035714285e-05 1.5 1.621986607142857e-05 0.0 1.62265625e-05 0.0 1.6227120535714286e-05 1.5 1.6237165178571427e-05 1.5 1.6237723214285714e-05 0.0 1.624441964285714e-05 0.0 1.6244977678571428e-05 1.5 1.625502232142857e-05 1.5 1.6255580357142856e-05 0.0 1.6262276785714284e-05 0.0 1.626283482142857e-05 1.5 1.627287946428571e-05 1.5 1.6273437499999998e-05 0.0 1.6280133928571426e-05 0.0 1.6280691964285713e-05 1.5 1.6290736607142857e-05 1.5 1.629129464285714e-05 0.0 1.629799107142857e-05 0.0 1.6298549107142855e-05 1.5 1.630859375e-05 1.5 1.6309151785714283e-05 0.0 1.6315848214285714e-05 0.0 1.6316406249999997e-05 1.5 1.6326450892857142e-05 1.5 1.632700892857143e-05 0.0 1.6333705357142856e-05 0.0 1.6334263392857143e-05 1.5 1.6344308035714284e-05 1.5 1.634486607142857e-05 0.0 1.63515625e-05 0.0 1.6352120535714285e-05 1.5 1.6362165178571427e-05 1.5 1.6362723214285713e-05 0.0 1.636941964285714e-05 0.0 1.6369977678571428e-05 1.5 1.6380580357142856e-05 1.5 1.6381138392857142e-05 0.0 1.638671875e-05 0.0 1.6387276785714283e-05 1.5 1.6398437499999998e-05 1.5 1.6398995535714285e-05 0.0 1.6404575892857142e-05 0.0 1.640513392857143e-05 1.5 1.641629464285714e-05 1.5 1.6416852678571427e-05 0.0 1.6422433035714284e-05 0.0 1.642299107142857e-05 1.5 1.6434151785714286e-05 1.5 1.643470982142857e-05 0.0 1.6440290178571427e-05 0.0 1.6440848214285714e-05 1.5 1.645200892857143e-05 1.5 1.645256696428571e-05 0.0 1.645814732142857e-05 0.0 1.6458705357142856e-05 1.5 1.646986607142857e-05 1.5 1.6470424107142857e-05 0.0 1.6476004464285715e-05 0.0 1.6476562499999998e-05 1.5 1.6487723214285713e-05 1.5 1.648828125e-05 0.0 1.6493861607142857e-05 0.0 1.649441964285714e-05 1.5 1.6505580357142855e-05 1.5 1.6506138392857142e-05 0.0 1.651171875e-05 0.0 1.6512276785714286e-05 1.5 1.6523437499999998e-05 1.5 1.6523995535714284e-05 0.0 1.6529575892857142e-05 0.0 1.653013392857143e-05 1.5 1.6541294642857143e-05 1.5 1.6541852678571427e-05 0.0 1.6546874999999997e-05 0.0 1.6547433035714284e-05 1.5 1.655970982142857e-05 1.5 1.6560267857142856e-05 0.0 1.6564732142857143e-05 0.0 1.6565290178571426e-05 1.5 1.6577566964285715e-05 1.5 1.6578124999999998e-05 0.0 1.6582589285714285e-05 0.0 1.658314732142857e-05 1.5 1.6595424107142857e-05 1.5 1.659598214285714e-05 0.0 1.6600446428571428e-05 0.0 1.6601004464285714e-05 1.5 1.661328125e-05 1.5 1.6613839285714286e-05 0.0 1.661830357142857e-05 0.0 1.6618861607142857e-05 1.5 1.663113839285714e-05 1.5 1.663169642857143e-05 0.0 1.6636160714285712e-05 0.0 1.663671875e-05 1.5 1.6648995535714284e-05 1.5 1.664955357142857e-05 0.0 1.6654017857142855e-05 0.0 1.665457589285714e-05 1.5 1.6666852678571426e-05 1.5 1.6667410714285713e-05 0.0 1.6671875e-05 0.0 1.6672433035714284e-05 1.5 1.668470982142857e-05 1.5 1.6685267857142855e-05 0.0 1.6689732142857143e-05 0.0 1.6690290178571426e-05 1.5 1.6702566964285714e-05 1.5 1.6703124999999998e-05 0.0 1.6707589285714285e-05 0.0 1.6708147321428572e-05 1.5 1.672098214285714e-05 1.5 1.6721540178571427e-05 0.0 1.672488839285714e-05 0.0 1.6725446428571427e-05 1.5 1.6738839285714286e-05 1.5 1.673939732142857e-05 0.0 1.6742745535714283e-05 0.0 1.674330357142857e-05 1.5 1.6756696428571428e-05 1.5 1.675725446428571e-05 0.0 1.676060267857143e-05 0.0 1.6761160714285712e-05 1.5 1.677455357142857e-05 1.5 1.6775111607142857e-05 0.0 1.677845982142857e-05 0.0 1.6779017857142854e-05 1.5 1.6792410714285713e-05 1.5 1.679296875e-05 0.0 1.6796316964285713e-05 0.0 1.6796875e-05 1.5 1.6810267857142855e-05 1.5 1.6810825892857142e-05 0.0 1.6814174107142856e-05 0.0 1.6814732142857142e-05 1.5 1.6828124999999997e-05 1.5 1.6828683035714284e-05 0.0 1.6832031249999998e-05 0.0 1.6832589285714285e-05 1.5 1.6845982142857143e-05 1.5 1.6846540178571426e-05 0.0 1.684988839285714e-05 0.0 1.6850446428571427e-05 1.5 1.6863839285714285e-05 1.5 1.686439732142857e-05 0.0 1.6867745535714286e-05 0.0 1.686830357142857e-05 1.5 1.6881696428571428e-05 1.5 1.6882254464285714e-05 0.0 1.6885602678571428e-05 0.0 1.688616071428571e-05 1.5 1.689955357142857e-05 1.5 1.6900111607142857e-05 0.0 1.690345982142857e-05 0.0 1.6904017857142857e-05 1.5 1.691796875e-05 1.5 1.6918526785714286e-05 0.0 1.6920758928571426e-05 0.0 1.6921316964285713e-05 1.5 1.693582589285714e-05 1.5 1.6936383928571428e-05 0.0 1.6938616071428572e-05 0.0 1.6939174107142855e-05 1.5 1.6953683035714284e-05 1.5 1.695424107142857e-05 0.0 1.6956473214285714e-05 0.0 1.6957031249999998e-05 1.5 1.6971540178571426e-05 1.5 1.6972098214285713e-05 0.0 1.6974330357142857e-05 0.0 1.6974888392857143e-05 1.5 1.6989397321428572e-05 1.5 1.6989955357142855e-05 0.0 1.69921875e-05 0.0 1.6992745535714286e-05 1.5 1.7007254464285714e-05 1.5 1.7007812499999998e-05 0.0 1.701004464285714e-05 0.0 1.7010602678571428e-05 1.5 1.7025111607142856e-05 1.5 1.7025669642857143e-05 0.0 1.7027901785714283e-05 0.0 1.702845982142857e-05 1.5 1.704296875e-05 1.5 1.7043526785714286e-05 0.0 1.7045758928571426e-05 0.0 1.7046316964285713e-05 1.5 1.706082589285714e-05 1.5 1.7061383928571428e-05 0.0 1.706361607142857e-05 0.0 1.7064174107142855e-05 1.5 1.7078683035714283e-05 1.5 1.707924107142857e-05 0.0 1.7081473214285714e-05 0.0 1.7082031249999997e-05 1.5 1.7096540178571426e-05 1.5 1.7097098214285713e-05 0.0 1.7099330357142856e-05 0.0 1.7099888392857143e-05 1.5 1.711439732142857e-05 1.5 1.7114955357142855e-05 0.0 1.71171875e-05 0.0 1.7117745535714285e-05 1.5 1.7132254464285714e-05 1.5 1.7132812499999997e-05 0.0 1.7134486607142857e-05 0.0 1.713504464285714e-05 1.5 1.7150669642857143e-05 1.5 1.7151227678571426e-05 0.0 1.715234375e-05 0.0 1.7152901785714283e-05 1.5 1.7168526785714285e-05 1.5 1.716908482142857e-05 0.0 1.7170200892857142e-05 0.0 1.717075892857143e-05 1.5 1.7186383928571428e-05 1.5 1.7186941964285714e-05 0.0 1.7188058035714284e-05 0.0 1.718861607142857e-05 1.5 1.720424107142857e-05 1.5 1.7204799107142857e-05 0.0 1.7205915178571427e-05 0.0 1.7206473214285713e-05 1.5 1.7222098214285712e-05 1.5 1.722265625e-05 0.0 1.722377232142857e-05 0.0 1.7224330357142856e-05 1.5 1.7239955357142854e-05 1.5 1.724051339285714e-05 0.0 1.724162946428571e-05 0.0 1.7242187499999998e-05 1.5 1.72578125e-05 1.5 1.7258370535714284e-05 0.0 1.7259486607142857e-05 0.0 1.726004464285714e-05 1.5 1.7275669642857143e-05 1.5 1.7276227678571426e-05 0.0 1.727734375e-05 0.0 1.7277901785714286e-05 1.5 1.7293526785714285e-05 1.5 1.729408482142857e-05 0.0 1.7295200892857142e-05 0.0 1.729575892857143e-05 1.5 1.7311383928571427e-05 1.5 1.7311941964285714e-05 0.0 1.7313058035714284e-05 0.0 1.731361607142857e-05 1.5 1.732924107142857e-05 1.5 1.7329799107142856e-05 0.0 1.7330915178571426e-05 0.0 1.7331473214285713e-05 1.5 1.7347098214285712e-05 1.5 1.734765625e-05 0.0 1.734877232142857e-05 0.0 1.7349330357142855e-05 1.5 1.7364955357142858e-05 1.5 1.736551339285714e-05 0.0 1.7366629464285714e-05 0.0 1.7367187499999998e-05 1.5 1.73828125e-05 1.5 1.7383370535714283e-05 0.0 1.7384486607142857e-05 0.0 1.738504464285714e-05 1.5 1.7400669642857142e-05 1.5 1.740122767857143e-05 0.0 1.740234375e-05 0.0 1.7402901785714286e-05 1.5 1.741908482142857e-05 1.5 1.7419642857142855e-05 0.0 1.7419642857142855e-05 0.0 1.742020089285714e-05 1.5 1.7436941964285714e-05 1.5 1.74375e-05 0.0 1.74375e-05 0.0 1.7438058035714284e-05 1.5 1.7454799107142856e-05 1.5 1.7455357142857143e-05 0.0 1.7455357142857143e-05 0.0 1.7455915178571426e-05 1.5 1.7472656249999998e-05 1.5 1.7473214285714285e-05 0.0 1.7473214285714285e-05 0.0 1.7473772321428572e-05 1.5 1.749051339285714e-05 1.5 1.7491071428571427e-05 0.0 1.7491071428571427e-05 0.0 1.7491629464285714e-05 1.5 1.7508370535714283e-05 1.5 1.750892857142857e-05 0.0 1.750892857142857e-05 0.0 1.7509486607142856e-05 1.5 1.752622767857143e-05 1.5 1.7526785714285712e-05 0.0 1.7526785714285712e-05 0.0 1.752734375e-05 1.5 1.754408482142857e-05 1.5 1.7544642857142854e-05 0.0 1.7544642857142854e-05 0.0 1.754520089285714e-05 1.5 1.7561941964285713e-05 1.5 1.75625e-05 0.0 1.75625e-05 0.0 1.7563058035714283e-05 1.5 1.7579799107142856e-05 1.5 1.7580357142857142e-05 0.0 1.7580357142857142e-05 0.0 1.7580915178571426e-05 1.5 1.7597656249999998e-05 1.5 1.7598214285714285e-05 0.0 1.7598214285714285e-05 0.0 1.759877232142857e-05 1.5 1.761551339285714e-05 1.5 1.7616071428571427e-05 0.0 1.7616071428571427e-05 0.0 1.7616629464285714e-05 1.5 1.7633370535714286e-05 1.5 1.763392857142857e-05 0.0 1.763392857142857e-05 0.0 1.7634486607142856e-05 1.5 1.7651227678571428e-05 1.5 1.765178571428571e-05 0.0 1.765178571428571e-05 0.0 1.765234375e-05 1.5 1.766908482142857e-05 1.5 1.7669642857142857e-05 0.0 1.7669642857142857e-05 0.0 1.767020089285714e-05 1.5 1.7686941964285713e-05 1.5 1.76875e-05 0.0 1.76875e-05 0.0 1.7688058035714283e-05 1.5 1.7704799107142855e-05 1.5 1.7705357142857142e-05 0.0 1.7705357142857142e-05 0.0 1.770591517857143e-05 1.5 1.7722656249999998e-05 1.5 1.7723214285714284e-05 0.0 1.7723214285714284e-05 0.0 1.772377232142857e-05 1.5 1.7740513392857143e-05 1.5 1.7741071428571427e-05 0.0 1.7741071428571427e-05 0.0 1.7741629464285713e-05 1.5 1.7758370535714286e-05 1.5 1.775892857142857e-05 0.0 1.775892857142857e-05 0.0 1.7759486607142856e-05 1.5 1.7776227678571428e-05 1.5 1.7776785714285715e-05 0.0 1.7776785714285715e-05 0.0 1.7777343749999998e-05 1.5 1.779408482142857e-05 1.5 1.7794642857142857e-05 0.0 1.7794642857142857e-05 0.0 1.779520089285714e-05 1.5 1.7811941964285713e-05 1.5 1.78125e-05 0.0 1.78125e-05 0.0 1.7813058035714286e-05 1.5 1.7829799107142855e-05 1.5 1.783035714285714e-05 0.0 1.783035714285714e-05 0.0 1.783091517857143e-05 1.5 1.7847656249999997e-05 1.5 1.7848214285714284e-05 0.0 1.7848214285714284e-05 0.0 1.784877232142857e-05 1.5 1.7865513392857143e-05 1.5 1.7866071428571426e-05 0.0 1.7866071428571426e-05 0.0 1.7866629464285713e-05 1.5 1.7883370535714285e-05 1.5 1.788392857142857e-05 0.0 1.788392857142857e-05 0.0 1.7884486607142855e-05 1.5 1.7901227678571428e-05 1.5 1.7901785714285714e-05 0.0 1.7901785714285714e-05 0.0 1.7902343749999998e-05 1.5 1.791908482142857e-05 1.5 1.7919642857142857e-05 0.0 1.7919642857142857e-05 0.0 1.792020089285714e-05 1.5 1.7936941964285712e-05 1.5 1.79375e-05 0.0 1.79375e-05 0.0 1.7938058035714286e-05 1.5 1.7954799107142855e-05 1.5 1.795535714285714e-05 0.0 1.795535714285714e-05 0.0 1.7955915178571428e-05 1.5 1.797265625e-05 1.5 1.7973214285714284e-05 0.0 1.7973214285714284e-05 0.0 1.797377232142857e-05 1.5 1.7990513392857143e-05 1.5 1.7991071428571426e-05 0.0 1.7991071428571426e-05 0.0 1.7991629464285713e-05 1.5 1.8008370535714285e-05 1.5 1.800892857142857e-05 0.0 1.800892857142857e-05 0.0 1.8009486607142855e-05 1.5 1.8026227678571427e-05 1.5 1.8026785714285714e-05 0.0 1.8026785714285714e-05 0.0 1.8027343749999997e-05 1.5 1.804408482142857e-05 1.5 1.8044642857142856e-05 0.0 1.8044642857142856e-05 0.0 1.8045200892857143e-05 1.5 1.8061941964285712e-05 1.5 1.80625e-05 0.0 1.80625e-05 0.0 1.8063058035714285e-05 1.5 1.8079799107142854e-05 1.5 1.808035714285714e-05 0.0 1.808035714285714e-05 0.0 1.8080915178571428e-05 1.5 1.809765625e-05 1.5 1.8098214285714283e-05 0.0 1.8098214285714283e-05 0.0 1.809877232142857e-05 1.5 1.8115513392857142e-05 1.5 1.811607142857143e-05 0.0 1.811607142857143e-05 0.0 1.8116629464285712e-05 1.5 1.8133370535714285e-05 1.5 1.813392857142857e-05 0.0 1.813392857142857e-05 0.0 1.8134486607142855e-05 1.5 1.8151227678571427e-05 1.5 1.8151785714285714e-05 0.0 1.8151785714285714e-05 0.0 1.815234375e-05 1.5 1.816908482142857e-05 1.5 1.8169642857142856e-05 0.0 1.8169642857142856e-05 0.0 1.8170200892857143e-05 1.5 1.818694196428571e-05 1.5 1.8187499999999998e-05 0.0 1.8187499999999998e-05 0.0 1.8188058035714285e-05 1.5 1.8204799107142857e-05 1.5 1.820535714285714e-05 0.0 1.820535714285714e-05 0.0 1.8205915178571427e-05 1.5 1.822265625e-05 1.5 1.8223214285714283e-05 0.0 1.8223214285714283e-05 0.0 1.822377232142857e-05 1.5 1.8240513392857142e-05 1.5 1.824107142857143e-05 0.0 1.824107142857143e-05 0.0 1.8241629464285712e-05 1.5 1.8258370535714284e-05 1.5 1.825892857142857e-05 0.0 1.825892857142857e-05 0.0 1.8259486607142854e-05 1.5 1.8276227678571426e-05 1.5 1.8276785714285713e-05 0.0 1.8276785714285713e-05 0.0 1.827734375e-05 1.5 1.829408482142857e-05 1.5 1.8294642857142856e-05 0.0 1.8294642857142856e-05 0.0 1.8295200892857142e-05 1.5 1.8311941964285715e-05 1.5 1.8312499999999998e-05 0.0 1.8312499999999998e-05 0.0 1.8313058035714285e-05 1.5 1.8329799107142857e-05 1.5 1.833035714285714e-05 0.0 1.833035714285714e-05 0.0 1.8330915178571427e-05 1.5 1.834765625e-05 1.5 1.8348214285714286e-05 0.0 1.8348214285714286e-05 0.0 1.834877232142857e-05 1.5 1.836551339285714e-05 1.5 1.8366071428571428e-05 0.0 1.8366071428571428e-05 0.0 1.836662946428571e-05 1.5 1.8383370535714284e-05 1.5 1.838392857142857e-05 0.0 1.838392857142857e-05 0.0 1.8384486607142857e-05 1.5 1.8401227678571426e-05 1.5 1.8401785714285713e-05 0.0 1.8401785714285713e-05 0.0 1.840234375e-05 1.5 1.841908482142857e-05 1.5 1.8419642857142855e-05 0.0 1.8419642857142855e-05 0.0 1.8420200892857142e-05 1.5 1.8436941964285714e-05 1.5 1.8437499999999998e-05 0.0 1.8437499999999998e-05 0.0 1.8438058035714284e-05 1.5 1.8454799107142856e-05 1.5 1.845535714285714e-05 0.0 1.845535714285714e-05 0.0 1.8455915178571427e-05 1.5 1.847265625e-05 1.5 1.8473214285714286e-05 0.0 1.8473214285714286e-05 0.0 1.847377232142857e-05 1.5 1.849051339285714e-05 1.5 1.8491071428571428e-05 0.0 1.8491071428571428e-05 0.0 1.8491629464285715e-05 1.5 1.8508370535714283e-05 1.5 1.850892857142857e-05 0.0 1.850892857142857e-05 0.0 1.8509486607142857e-05 1.5 1.8526227678571426e-05 1.5 1.8526785714285713e-05 0.0 1.8526785714285713e-05 0.0 1.852734375e-05 1.5 1.854408482142857e-05 1.5 1.8544642857142855e-05 0.0 1.8544642857142855e-05 0.0 1.854520089285714e-05 1.5 1.8561941964285714e-05 1.5 1.8562499999999997e-05 0.0 1.8562499999999997e-05 0.0 1.8563058035714284e-05 1.5 1.8579799107142856e-05 1.5 1.8580357142857143e-05 0.0 1.8580357142857143e-05 0.0 1.8580915178571426e-05 1.5 1.859765625e-05 1.5 1.8598214285714285e-05 0.0 1.8598214285714285e-05 0.0 1.859877232142857e-05 1.5 1.861551339285714e-05 1.5 1.8616071428571428e-05 0.0 1.8616071428571428e-05 0.0 1.8616629464285714e-05 1.5 1.8633370535714283e-05 1.5 1.863392857142857e-05 0.0 1.863392857142857e-05 0.0 1.8634486607142857e-05 1.5 1.865122767857143e-05 1.5 1.8651785714285712e-05 0.0 1.8651785714285712e-05 0.0 1.865234375e-05 1.5 1.866908482142857e-05 1.5 1.8669642857142855e-05 0.0 1.8669642857142855e-05 0.0 1.867020089285714e-05 1.5 1.8686941964285713e-05 1.5 1.86875e-05 0.0 1.86875e-05 0.0 1.8688058035714284e-05 1.5 1.870424107142857e-05 1.5 1.8704799107142856e-05 0.0 1.8705915178571426e-05 0.0 1.8706473214285713e-05 1.5 1.872209821428571e-05 1.5 1.8722656249999998e-05 0.0 1.872377232142857e-05 0.0 1.8724330357142855e-05 1.5 1.8739955357142857e-05 1.5 1.874051339285714e-05 0.0 1.8741629464285714e-05 0.0 1.8742187499999997e-05 1.5 1.87578125e-05 1.5 1.8758370535714283e-05 0.0 1.8759486607142856e-05 0.0 1.8760044642857143e-05 1.5 1.8775669642857142e-05 1.5 1.877622767857143e-05 0.0 1.877734375e-05 0.0 1.8777901785714285e-05 1.5 1.8793526785714284e-05 1.5 1.879408482142857e-05 0.0 1.879520089285714e-05 0.0 1.8795758928571428e-05 1.5 1.8811383928571426e-05 1.5 1.8811941964285713e-05 0.0 1.8813058035714283e-05 0.0 1.881361607142857e-05 1.5 1.882924107142857e-05 1.5 1.8829799107142855e-05 0.0 1.8830915178571426e-05 0.0 1.8831473214285712e-05 1.5 1.8847098214285714e-05 1.5 1.8847656249999998e-05 0.0 1.884877232142857e-05 0.0 1.8849330357142855e-05 1.5 1.8864955357142857e-05 1.5 1.886551339285714e-05 0.0 1.8866629464285714e-05 0.0 1.8867187499999997e-05 1.5 1.88828125e-05 1.5 1.8883370535714286e-05 0.0 1.8884486607142856e-05 0.0 1.8885044642857143e-05 1.5 1.890066964285714e-05 1.5 1.8901227678571428e-05 0.0 1.8902343749999998e-05 0.0 1.8902901785714285e-05 1.5 1.8918526785714284e-05 1.5 1.891908482142857e-05 0.0 1.892020089285714e-05 0.0 1.8920758928571427e-05 1.5 1.8936383928571426e-05 1.5 1.8936941964285713e-05 0.0 1.8938058035714283e-05 0.0 1.893861607142857e-05 1.5 1.8954241071428572e-05 1.5 1.8954799107142855e-05 0.0 1.895591517857143e-05 0.0 1.8956473214285712e-05 1.5 1.8972098214285714e-05 1.5 1.8972656249999997e-05 0.0 1.897377232142857e-05 0.0 1.8974330357142854e-05 1.5 1.898939732142857e-05 1.5 1.8989955357142856e-05 0.0 1.89921875e-05 0.0 1.8992745535714283e-05 1.5 1.9007254464285712e-05 1.5 1.90078125e-05 0.0 1.9010044642857142e-05 0.0 1.9010602678571426e-05 1.5 1.9025111607142854e-05 1.5 1.902566964285714e-05 0.0 1.9027901785714285e-05 0.0 1.902845982142857e-05 1.5 1.904296875e-05 1.5 1.9043526785714283e-05 0.0 1.9045758928571427e-05 0.0 1.9046316964285714e-05 1.5 1.9060825892857142e-05 1.5 1.9061383928571426e-05 0.0 1.906361607142857e-05 0.0 1.9064174107142856e-05 1.5 1.9078683035714285e-05 1.5 1.907924107142857e-05 0.0 1.908147321428571e-05 0.0 1.908203125e-05 1.5 1.9096540178571427e-05 1.5 1.9097098214285714e-05 0.0 1.9099330357142857e-05 0.0 1.909988839285714e-05 1.5 1.911439732142857e-05 1.5 1.9114955357142856e-05 0.0 1.91171875e-05 0.0 1.9117745535714283e-05 1.5 1.913225446428571e-05 1.5 1.91328125e-05 0.0 1.9135044642857142e-05 0.0 1.913560267857143e-05 1.5 1.9150111607142857e-05 1.5 1.915066964285714e-05 0.0 1.9152901785714284e-05 0.0 1.915345982142857e-05 1.5 1.916796875e-05 1.5 1.9168526785714283e-05 0.0 1.9170758928571427e-05 0.0 1.9171316964285713e-05 1.5 1.9185825892857142e-05 1.5 1.918638392857143e-05 0.0 1.918861607142857e-05 0.0 1.9189174107142856e-05 1.5 1.9203124999999998e-05 1.5 1.9203683035714284e-05 0.0 1.9207031249999998e-05 0.0 1.9207589285714285e-05 1.5 1.922098214285714e-05 1.5 1.9221540178571427e-05 0.0 1.922488839285714e-05 0.0 1.9225446428571427e-05 1.5 1.9238839285714286e-05 1.5 1.923939732142857e-05 0.0 1.9242745535714283e-05 0.0 1.924330357142857e-05 1.5 1.9256696428571428e-05 1.5 1.925725446428571e-05 0.0 1.926060267857143e-05 0.0 1.9261160714285712e-05 1.5 1.927455357142857e-05 1.5 1.9275111607142857e-05 0.0 1.927845982142857e-05 0.0 1.9279017857142854e-05 1.5 1.9292410714285713e-05 1.5 1.929296875e-05 0.0 1.9296316964285713e-05 0.0 1.9296875e-05 1.5 1.9310267857142855e-05 1.5 1.931082589285714e-05 0.0 1.9314174107142855e-05 0.0 1.9314732142857142e-05 1.5 1.9328124999999997e-05 1.5 1.9328683035714284e-05 0.0 1.9332031249999998e-05 0.0 1.9332589285714284e-05 1.5 1.9345982142857143e-05 1.5 1.9346540178571426e-05 0.0 1.934988839285714e-05 0.0 1.9350446428571427e-05 1.5 1.9363839285714285e-05 1.5 1.936439732142857e-05 0.0 1.9367745535714286e-05 0.0 1.936830357142857e-05 1.5 1.9381696428571428e-05 1.5 1.9382254464285714e-05 0.0 1.9385602678571428e-05 0.0 1.938616071428571e-05 1.5 1.9398995535714283e-05 1.5 1.939955357142857e-05 0.0 1.9404017857142857e-05 0.0 1.940457589285714e-05 1.5 1.941685267857143e-05 1.5 1.9417410714285712e-05 0.0 1.9421875e-05 0.0 1.9422433035714283e-05 1.5 1.943470982142857e-05 1.5 1.9435267857142854e-05 0.0 1.9439732142857142e-05 0.0 1.944029017857143e-05 1.5 1.9452566964285713e-05 1.5 1.9453125e-05 0.0 1.9457589285714284e-05 0.0 1.945814732142857e-05 1.5 1.9470424107142856e-05 1.5 1.9470982142857143e-05 0.0 1.9475446428571426e-05 0.0 1.9476004464285713e-05 1.5 1.9488281249999998e-05 1.5 1.9488839285714285e-05 0.0 1.949330357142857e-05 0.0 1.9493861607142855e-05 1.5 1.950613839285714e-05 1.5 1.9506696428571427e-05 0.0 1.9511160714285714e-05 0.0 1.9511718749999998e-05 1.5 1.9523995535714283e-05 1.5 1.952455357142857e-05 0.0 1.9529017857142857e-05 0.0 1.952957589285714e-05 1.5 1.954185267857143e-05 1.5 1.9542410714285712e-05 0.0 1.9546875e-05 0.0 1.9547433035714286e-05 1.5 1.955970982142857e-05 1.5 1.9560267857142854e-05 0.0 1.956473214285714e-05 0.0 1.9565290178571428e-05 1.5 1.9577008928571426e-05 1.5 1.9577566964285713e-05 0.0 1.958314732142857e-05 0.0 1.9583705357142857e-05 1.5 1.959486607142857e-05 1.5 1.9595424107142855e-05 0.0 1.9601004464285713e-05 0.0 1.96015625e-05 1.5 1.9612723214285714e-05 1.5 1.9613281249999998e-05 0.0 1.9618861607142855e-05 0.0 1.9619419642857142e-05 1.5 1.9630580357142857e-05 1.5 1.963113839285714e-05 0.0 1.9636718749999997e-05 0.0 1.9637276785714284e-05 1.5 1.96484375e-05 1.5 1.9648995535714286e-05 0.0 1.965457589285714e-05 0.0 1.9655133928571427e-05 1.5 1.966629464285714e-05 1.5 1.9666852678571428e-05 0.0 1.9672433035714285e-05 0.0 1.967299107142857e-05 1.5 1.9684151785714284e-05 1.5 1.968470982142857e-05 0.0 1.9690290178571428e-05 0.0 1.969084821428571e-05 1.5 1.9702008928571426e-05 1.5 1.9702566964285713e-05 0.0 1.970814732142857e-05 0.0 1.9708705357142857e-05 1.5 1.9719866071428572e-05 1.5 1.9720424107142855e-05 0.0 1.9726004464285712e-05 0.0 1.97265625e-05 1.5 1.9737723214285714e-05 1.5 1.9738281249999997e-05 0.0 1.974441964285714e-05 0.0 1.9744977678571428e-05 1.5 1.975502232142857e-05 1.5 1.9755580357142856e-05 0.0 1.9762276785714284e-05 0.0 1.976283482142857e-05 1.5 1.9772879464285712e-05 1.5 1.97734375e-05 0.0 1.9780133928571426e-05 0.0 1.9780691964285713e-05 1.5 1.9790736607142854e-05 1.5 1.979129464285714e-05 0.0 1.979799107142857e-05 0.0 1.9798549107142855e-05 1.5 1.980859375e-05 1.5 1.9809151785714283e-05 0.0 1.9815848214285714e-05 0.0 1.9816406249999998e-05 1.5 1.9826450892857142e-05 1.5 1.9827008928571426e-05 0.0 1.9833705357142857e-05 0.0 1.983426339285714e-05 1.5 1.9844308035714285e-05 1.5 1.984486607142857e-05 0.0 1.98515625e-05 0.0 1.9852120535714286e-05 1.5 1.9862165178571427e-05 1.5 1.9862723214285714e-05 0.0 1.986941964285714e-05 0.0 1.9869977678571428e-05 1.5 1.988002232142857e-05 1.5 1.9880580357142856e-05 0.0 1.9887276785714284e-05 0.0 1.988783482142857e-05 1.5 1.989787946428571e-05 1.5 1.98984375e-05 0.0 1.9905691964285713e-05 0.0 1.990625e-05 1.5 1.991517857142857e-05 1.5 1.9915736607142857e-05 0.0 1.9923549107142855e-05 0.0 1.992410714285714e-05 1.5 1.9933035714285713e-05 1.5 1.993359375e-05 0.0 1.9941406249999997e-05 0.0 1.9941964285714284e-05 1.5 1.9950892857142855e-05 1.5 1.9951450892857142e-05 0.0 1.9959263392857143e-05 0.0 1.9959821428571426e-05 1.5 1.9968749999999997e-05 1.5 1.9969308035714284e-05 0.0 1.9977120535714285e-05 0.0 1.997767857142857e-05 1.5 1.998660714285714e-05 1.5 1.9987165178571427e-05 0.0 1.9994977678571428e-05 0.0 1.9995535714285714e-05 1.5 2.0004464285714286e-05 1.5 2.000502232142857e-05 0.0 2.001283482142857e-05 0.0 2.0013392857142857e-05 1.5 2.0022321428571428e-05 1.5 2.002287946428571e-05 0.0 2.0030691964285712e-05 0.0 2.003125e-05 1.5 2.004017857142857e-05 1.5 2.0040736607142857e-05 0.0 2.0048549107142855e-05 0.0 2.004910714285714e-05 1.5 2.0058035714285712e-05 1.5 2.005859375e-05 0.0 2.0066964285714284e-05 0.0 2.006752232142857e-05 1.5 2.007533482142857e-05 1.5 2.0075892857142855e-05 0.0 2.0084821428571426e-05 0.0 2.0085379464285713e-05 1.5 2.0093191964285714e-05 1.5 2.0093749999999997e-05 0.0 2.0102678571428568e-05 0.0 2.0103236607142855e-05 1.5 2.0111049107142856e-05 1.5 2.0111607142857143e-05 0.0 2.0120535714285714e-05 0.0 2.0121093749999997e-05 1.5 2.012890625e-05 1.5 2.0129464285714285e-05 0.0 2.0138392857142856e-05 0.0 2.0138950892857143e-05 1.5 2.014676339285714e-05 1.5 2.0147321428571427e-05 0.0 2.015625e-05 0.0 2.0156808035714285e-05 1.5 2.0164620535714283e-05 1.5 2.016517857142857e-05 0.0 2.017410714285714e-05 0.0 2.0174665178571428e-05 1.5 2.018247767857143e-05 1.5 2.0183035714285712e-05 0.0 2.0191964285714283e-05 0.0 2.019252232142857e-05 1.5 2.020033482142857e-05 1.5 2.0200892857142854e-05 0.0 2.0209821428571426e-05 0.0 2.0210379464285712e-05 1.5 2.0218191964285713e-05 1.5 2.021875e-05 0.0 2.0228236607142855e-05 0.0 2.022879464285714e-05 1.5 2.023549107142857e-05 1.5 2.0236049107142856e-05 0.0 2.0246093749999997e-05 0.0 2.0246651785714284e-05 1.5 2.025334821428571e-05 1.5 2.0253906249999998e-05 0.0 2.0263950892857143e-05 0.0 2.0264508928571426e-05 1.5 2.0271205357142857e-05 1.5 2.027176339285714e-05 0.0 2.0281808035714285e-05 0.0 2.028236607142857e-05 1.5 2.02890625e-05 1.5 2.0289620535714283e-05 0.0 2.0299665178571427e-05 0.0 2.0300223214285714e-05 1.5 2.030691964285714e-05 1.5 2.030747767857143e-05 0.0 2.031752232142857e-05 0.0 2.0318080357142856e-05 1.5 2.0324776785714284e-05 1.5 2.032533482142857e-05 0.0 2.0335379464285712e-05 0.0 2.03359375e-05 1.5 2.0342633928571426e-05 1.5 2.0343191964285713e-05 0.0 2.0353236607142854e-05 0.0 2.035379464285714e-05 1.5 2.036049107142857e-05 1.5 2.0361049107142855e-05 0.0 2.037109375e-05 0.0 2.0371651785714283e-05 1.5 2.0378348214285714e-05 1.5 2.0378906249999998e-05 0.0 2.0389508928571426e-05 0.0 2.0390066964285713e-05 1.5 2.039564732142857e-05 1.5 2.0396205357142857e-05 0.0 2.040736607142857e-05 0.0 2.0407924107142855e-05 1.5 2.0413504464285712e-05 1.5 2.04140625e-05 0.0 2.0425223214285714e-05 0.0 2.0425781249999997e-05 1.5 2.0431361607142855e-05 1.5 2.043191964285714e-05 0.0 2.0443080357142856e-05 0.0 2.0443638392857143e-05 1.5 2.0449218749999997e-05 1.5 2.0449776785714284e-05 0.0 2.04609375e-05 0.0 2.0461495535714285e-05 1.5 2.0467075892857143e-05 1.5 2.0467633928571426e-05 0.0 2.047879464285714e-05 0.0 2.0479352678571428e-05 1.5 2.0484933035714285e-05 1.5 2.0485491071428568e-05 0.0 2.0496651785714283e-05 0.0 2.049720982142857e-05 1.5 2.0502790178571427e-05 1.5 2.0503348214285714e-05 0.0 2.0514508928571425e-05 0.0 2.0515066964285712e-05 1.5 2.052064732142857e-05 1.5 2.0521205357142856e-05 0.0 2.053236607142857e-05 0.0 2.0532924107142854e-05 1.5 2.0538504464285712e-05 1.5 2.05390625e-05 0.0 2.0550223214285713e-05 0.0 2.055078125e-05 1.5 2.055580357142857e-05 1.5 2.0556361607142854e-05 0.0 2.0568638392857143e-05 0.0 2.0569196428571426e-05 1.5 2.0573660714285713e-05 1.5 2.057421875e-05 0.0 2.0586495535714285e-05 0.0 2.058705357142857e-05 1.5 2.0591517857142855e-05 1.5 2.0592075892857142e-05 0.0 2.0604352678571427e-05 0.0 2.0604910714285714e-05 1.5 2.0609374999999998e-05 1.5 2.0609933035714285e-05 0.0 2.062220982142857e-05 0.0 2.0622767857142856e-05 1.5 2.062723214285714e-05 1.5 2.0627790178571427e-05 0.0 2.0640066964285712e-05 0.0 2.0640625e-05 1.5 2.0645089285714286e-05 1.5 2.064564732142857e-05 0.0 2.0657924107142854e-05 0.0 2.065848214285714e-05 1.5 2.0662946428571428e-05 1.5 2.066350446428571e-05 0.0 2.067578125e-05 0.0 2.0676339285714283e-05 1.5 2.068080357142857e-05 1.5 2.0681361607142857e-05 0.0 2.0693638392857142e-05 0.0 2.0694196428571426e-05 1.5 2.0698660714285713e-05 1.5 2.069921875e-05 0.0 2.0711495535714284e-05 0.0 2.071205357142857e-05 1.5 2.0716517857142855e-05 1.5 2.0717075892857142e-05 0.0 2.0729352678571427e-05 0.0 2.0729910714285714e-05 1.5 2.0733816964285714e-05 1.5 2.0734374999999997e-05 0.0 2.0747767857142856e-05 0.0 2.0748325892857143e-05 1.5 2.0751674107142856e-05 1.5 2.075223214285714e-05 0.0 2.0765624999999998e-05 0.0 2.0766183035714285e-05 1.5 2.076953125e-05 1.5 2.0770089285714285e-05 0.0 2.078348214285714e-05 0.0 2.0784040178571427e-05 1.5 2.078738839285714e-05 1.5 2.0787946428571428e-05 0.0 2.0801339285714283e-05 0.0 2.080189732142857e-05 1.5 2.0805245535714283e-05 1.5 2.080580357142857e-05 0.0 2.081919642857143e-05 0.0 2.0819754464285712e-05 1.5 2.0823102678571426e-05 1.5 2.0823660714285712e-05 0.0 2.083705357142857e-05 0.0 2.0837611607142854e-05 1.5 2.084095982142857e-05 1.5 2.0841517857142855e-05 0.0 2.0854910714285713e-05 0.0 2.085546875e-05 1.5 2.0858816964285714e-05 1.5 2.0859374999999997e-05 0.0 2.0872767857142856e-05 0.0 2.0873325892857142e-05 1.5 2.0876674107142856e-05 1.5 2.0877232142857143e-05 0.0 2.0890624999999998e-05 0.0 2.0891183035714285e-05 1.5 2.089453125e-05 1.5 2.0895089285714285e-05 0.0 2.090848214285714e-05 0.0 2.0909040178571427e-05 1.5 2.091238839285714e-05 1.5 2.0912946428571427e-05 0.0 2.092689732142857e-05 0.0 2.0927455357142856e-05 1.5 2.09296875e-05 1.5 2.0930245535714283e-05 0.0 2.094475446428571e-05 0.0 2.09453125e-05 1.5 2.0947544642857142e-05 1.5 2.094810267857143e-05 0.0 2.0962611607142857e-05 0.0 2.096316964285714e-05 1.5 2.0965401785714284e-05 1.5 2.096595982142857e-05 0.0 2.098046875e-05 0.0 2.0981026785714283e-05 1.5 2.0983258928571427e-05 1.5 2.0983816964285713e-05 0.0 2.0998325892857142e-05 0.0 2.099888392857143e-05 1.5 2.100111607142857e-05 1.5 2.1001674107142856e-05 0.0 2.1016183035714284e-05 0.0 2.101674107142857e-05 1.5 2.101897321428571e-05 1.5 2.1019531249999998e-05 0.0 2.1034040178571427e-05 0.0 2.1034598214285713e-05 1.5 2.1036830357142857e-05 1.5 2.103738839285714e-05 0.0 2.105189732142857e-05 0.0 2.1052455357142856e-05 1.5 2.10546875e-05 1.5 2.1055245535714283e-05 0.0 2.106975446428571e-05 0.0 2.1070312499999998e-05 1.5 2.107254464285714e-05 1.5 2.107310267857143e-05 0.0 2.1087611607142857e-05 0.0 2.108816964285714e-05 1.5 2.1090401785714284e-05 1.5 2.109095982142857e-05 0.0 2.110546875e-05 0.0 2.1106026785714283e-05 1.5 2.1108258928571426e-05 1.5 2.1108816964285713e-05 0.0 2.112332589285714e-05 0.0 2.112388392857143e-05 1.5 2.112611607142857e-05 1.5 2.1126674107142855e-05 0.0 2.1141183035714284e-05 0.0 2.114174107142857e-05 1.5 2.1143973214285714e-05 1.5 2.1144531249999998e-05 0.0 2.1159598214285713e-05 0.0 2.116015625e-05 1.5 2.116127232142857e-05 1.5 2.1161830357142857e-05 0.0 2.1177455357142855e-05 0.0 2.1178013392857142e-05 1.5 2.1179129464285712e-05 1.5 2.11796875e-05 0.0 2.1195312499999998e-05 0.0 2.1195870535714284e-05 1.5 2.1196986607142855e-05 1.5 2.119754464285714e-05 0.0 2.121316964285714e-05 0.0 2.1213727678571427e-05 1.5 2.1214843749999997e-05 1.5 2.1215401785714284e-05 0.0 2.1231026785714286e-05 0.0 2.123158482142857e-05 1.5 2.1232700892857143e-05 1.5 2.1233258928571426e-05 0.0 2.1248883928571428e-05 0.0 2.124944196428571e-05 1.5 2.1250558035714285e-05 1.5 2.1251116071428568e-05 0.0 2.126674107142857e-05 0.0 2.1267299107142857e-05 1.5 2.1268415178571427e-05 1.5 2.1268973214285714e-05 0.0 2.1284598214285713e-05 0.0 2.128515625e-05 1.5 2.128627232142857e-05 1.5 2.1286830357142856e-05 0.0 2.1302455357142855e-05 0.0 2.1303013392857142e-05 1.5 2.1304129464285712e-05 1.5 2.13046875e-05 0.0 2.1320312499999997e-05 0.0 2.1320870535714284e-05 1.5 2.1321986607142854e-05 1.5 2.132254464285714e-05 0.0 2.1338169642857143e-05 0.0 2.1338727678571426e-05 1.5 2.133984375e-05 1.5 2.1340401785714283e-05 0.0 2.1356026785714285e-05 0.0 2.135658482142857e-05 1.5 2.1357700892857142e-05 1.5 2.1358258928571426e-05 0.0 2.1373883928571428e-05 0.0 2.1374441964285714e-05 1.5 2.1375558035714285e-05 1.5 2.137611607142857e-05 0.0 2.139174107142857e-05 0.0 2.1392299107142857e-05 1.5 2.1393415178571427e-05 1.5 2.1393973214285714e-05 0.0 2.1409598214285712e-05 0.0 2.141015625e-05 1.5 2.141127232142857e-05 1.5 2.1411830357142856e-05 0.0 2.142801339285714e-05 0.0 2.1428571428571428e-05 1.5 2.1428571428571428e-05 1.5 2.142912946428571e-05 0.0 2.1445870535714284e-05 0.0 2.144642857142857e-05 1.5 2.144642857142857e-05 1.5 2.1446986607142857e-05 0.0 2.1463727678571426e-05 0.0 2.1464285714285713e-05 1.5 2.1464285714285713e-05 1.5 2.146484375e-05 0.0 2.148158482142857e-05 0.0 2.1482142857142855e-05 1.5 2.1482142857142855e-05 1.5 2.1482700892857142e-05 0.0 2.1499441964285714e-05 0.0 2.1499999999999997e-05 1.5 2.1499999999999997e-05 1.5 2.1500558035714284e-05 0.0 2.1517299107142856e-05 0.0 2.151785714285714e-05 1.5 2.151785714285714e-05 1.5 2.1518415178571427e-05 0.0 2.153515625e-05 0.0 2.1535714285714285e-05 1.5 2.1535714285714285e-05 1.5 2.153627232142857e-05 0.0 2.155301339285714e-05 0.0 2.1553571428571428e-05 1.5 2.1553571428571428e-05 1.5 2.155412946428571e-05 0.0 2.1570870535714283e-05 0.0 2.157142857142857e-05 1.5 2.157142857142857e-05 1.5 2.1571986607142857e-05 0.0 2.1588727678571426e-05 0.0 2.1589285714285712e-05 1.5 2.1589285714285712e-05 1.5 2.158984375e-05 0.0 2.160658482142857e-05 0.0 2.1607142857142855e-05 1.5 2.1607142857142855e-05 1.5 2.160770089285714e-05 0.0 2.1624441964285714e-05 0.0 2.1624999999999997e-05 1.5 2.1624999999999997e-05 1.5 2.1625558035714284e-05 0.0 2.1642299107142856e-05 0.0 2.1642857142857143e-05 1.5 2.1642857142857143e-05 1.5 2.1643415178571426e-05 0.0 2.166015625e-05 0.0 2.1660714285714285e-05 1.5 2.1660714285714285e-05 1.5 2.166127232142857e-05 0.0 2.167801339285714e-05 0.0 2.1678571428571427e-05 1.5 2.1678571428571427e-05 1.5 2.1679129464285714e-05 0.0 2.1695870535714283e-05 0.0 2.169642857142857e-05 1.5 2.169642857142857e-05 1.5 2.1696986607142857e-05 0.0 2.1713727678571425e-05 0.0 2.1714285714285712e-05 1.5 2.1714285714285712e-05 1.5 2.171484375e-05 0.0 2.173158482142857e-05 0.0 2.1732142857142854e-05 1.5 2.1732142857142854e-05 1.5 2.173270089285714e-05 0.0 2.1749441964285713e-05 0.0 2.175e-05 1.5 2.175e-05 1.5 2.1750558035714283e-05 0.0 2.1767299107142856e-05 0.0 2.1767857142857142e-05 1.5 2.1767857142857142e-05 1.5 2.1768415178571426e-05 0.0 2.1785156249999998e-05 0.0 2.1785714285714285e-05 1.5 2.1785714285714285e-05 1.5 2.178627232142857e-05 0.0 2.180301339285714e-05 0.0 2.1803571428571427e-05 1.5 2.1803571428571427e-05 1.5 2.1804129464285714e-05 0.0 2.1820870535714283e-05 0.0 2.182142857142857e-05 1.5 2.182142857142857e-05 1.5 2.1821986607142856e-05 0.0 2.183872767857143e-05 0.0 2.1839285714285712e-05 1.5 2.1839285714285712e-05 1.5 2.183984375e-05 0.0 2.185658482142857e-05 0.0 2.1857142857142854e-05 1.5 2.1857142857142854e-05 1.5 2.185770089285714e-05 0.0 2.1874441964285713e-05 0.0 2.1875e-05 1.5 2.1875e-05 1.5 2.1875558035714283e-05 0.0 2.1892299107142855e-05 0.0 2.1892857142857142e-05 1.5 2.1892857142857142e-05 1.5 2.1893415178571425e-05 0.0 2.1910156249999998e-05 0.0 2.1910714285714284e-05 1.5 2.1910714285714284e-05 1.5 2.191127232142857e-05 0.0 2.192801339285714e-05 0.0 2.1928571428571427e-05 1.5 2.1928571428571427e-05 1.5 2.1929129464285714e-05 0.0 2.1945870535714286e-05 0.0 2.194642857142857e-05 1.5 2.194642857142857e-05 1.5 2.1946986607142856e-05 0.0 2.1963727678571428e-05 0.0 2.196428571428571e-05 1.5 2.196428571428571e-05 1.5 2.1964843749999998e-05 0.0 2.198158482142857e-05 0.0 2.1982142857142857e-05 1.5 2.1982142857142857e-05 1.5 2.198270089285714e-05 0.0 2.1999441964285713e-05 0.0 2.2e-05 1.5 2.2e-05 1.5 2.2000558035714283e-05 0.0 2.2017299107142855e-05 0.0 2.2017857142857142e-05 1.5 2.2017857142857142e-05 1.5 2.201841517857143e-05 0.0 2.2035156249999997e-05 0.0 2.2035714285714284e-05 1.5 2.2035714285714284e-05 1.5 2.203627232142857e-05 0.0 2.205301339285714e-05 0.0 2.2053571428571426e-05 1.5 2.2053571428571426e-05 1.5 2.2054129464285713e-05 0.0 2.2070870535714285e-05 0.0 2.207142857142857e-05 1.5 2.207142857142857e-05 1.5 2.2071986607142855e-05 0.0 2.2088727678571428e-05 0.0 2.208928571428571e-05 1.5 2.208928571428571e-05 1.5 2.2089843749999998e-05 0.0 2.210658482142857e-05 0.0 2.2107142857142857e-05 1.5 2.2107142857142857e-05 1.5 2.210770089285714e-05 0.0 2.2124441964285712e-05 0.0 2.2125e-05 1.5 2.2125e-05 1.5 2.2125558035714282e-05 0.0 2.2142299107142855e-05 0.0 2.214285714285714e-05 1.5 2.214285714285714e-05 1.5 2.2143415178571428e-05 0.0 2.2160156249999997e-05 0.0 2.2160714285714284e-05 1.5 2.2160714285714284e-05 1.5 2.216127232142857e-05 0.0 2.2178013392857143e-05 0.0 2.2178571428571426e-05 1.5 2.2178571428571426e-05 1.5 2.2179129464285713e-05 0.0 2.2195870535714285e-05 0.0 2.219642857142857e-05 1.5 2.219642857142857e-05 1.5 2.2196986607142855e-05 0.0 2.2213727678571427e-05 0.0 2.2214285714285714e-05 1.5 2.2214285714285714e-05 1.5 2.2214843749999997e-05 0.0 2.223158482142857e-05 0.0 2.2232142857142856e-05 1.5 2.2232142857142856e-05 1.5 2.223270089285714e-05 0.0 2.2249441964285712e-05 0.0 2.225e-05 1.5 2.225e-05 1.5 2.2250558035714285e-05 0.0 2.2267299107142854e-05 0.0 2.226785714285714e-05 1.5 2.226785714285714e-05 1.5 2.2268415178571428e-05 0.0 2.228515625e-05 0.0 2.2285714285714283e-05 1.5 2.2285714285714283e-05 1.5 2.228627232142857e-05 0.0 2.2303013392857142e-05 0.0 2.2303571428571426e-05 1.5 2.2303571428571426e-05 1.5 2.2304129464285712e-05 0.0 2.2320870535714285e-05 0.0 2.232142857142857e-05 1.5 2.232142857142857e-05 1.5 2.2321986607142855e-05 0.0 2.2338727678571427e-05 0.0 2.2339285714285714e-05 1.5 2.2339285714285714e-05 1.5 2.2339843749999997e-05 0.0 2.235658482142857e-05 0.0 2.2357142857142856e-05 1.5 2.2357142857142856e-05 1.5 2.2357700892857143e-05 0.0 2.237444196428571e-05 0.0 2.2375e-05 1.5 2.2375e-05 1.5 2.2375558035714285e-05 0.0 2.2392299107142854e-05 0.0 2.239285714285714e-05 1.5 2.239285714285714e-05 1.5 2.2393415178571427e-05 0.0 2.241015625e-05 0.0 2.2410714285714283e-05 1.5 2.2410714285714283e-05 1.5 2.241127232142857e-05 0.0 2.2428013392857142e-05 0.0 2.2428571428571425e-05 1.5 2.2428571428571425e-05 1.5 2.2429129464285712e-05 0.0 2.2445870535714284e-05 0.0 2.244642857142857e-05 1.5 2.244642857142857e-05 1.5 2.2446986607142854e-05 0.0 2.2463727678571427e-05 0.0 2.2464285714285713e-05 1.5 2.2464285714285713e-05 1.5 2.2464843749999997e-05 0.0 2.248158482142857e-05 0.0 2.2482142857142856e-05 1.5 2.2482142857142856e-05 1.5 2.2482700892857142e-05 0.0 2.249944196428571e-05 0.0 2.2499999999999998e-05 1.5 2.2499999999999998e-05 1.5 2.2500558035714285e-05 0.0 2.2517299107142857e-05 0.0 2.251785714285714e-05 1.5 2.251785714285714e-05 1.5 2.2518415178571427e-05 0.0 2.253515625e-05 0.0 2.2535714285714283e-05 1.5 2.2535714285714283e-05 1.5 2.253627232142857e-05 0.0 2.255301339285714e-05 0.0 2.255357142857143e-05 1.5 2.255357142857143e-05 1.5 2.2554129464285712e-05 0.0 2.2570870535714284e-05 0.0 2.257142857142857e-05 1.5 2.257142857142857e-05 1.5 2.2571986607142854e-05 0.0 2.2588727678571426e-05 0.0 2.2589285714285713e-05 1.5 2.2589285714285713e-05 1.5 2.258984375e-05 0.0 2.260658482142857e-05 0.0 2.2607142857142855e-05 1.5 2.2607142857142855e-05 1.5 2.2607700892857142e-05 0.0 2.2624441964285714e-05 0.0 2.2624999999999998e-05 1.5 2.2624999999999998e-05 1.5 2.2625558035714284e-05 0.0 2.2642299107142857e-05 0.0 2.264285714285714e-05 1.5 2.264285714285714e-05 1.5 2.2643415178571427e-05 0.0 2.266015625e-05 0.0 2.2660714285714286e-05 1.5 2.2660714285714286e-05 1.5 2.266127232142857e-05 0.0 2.267801339285714e-05 0.0 2.2678571428571428e-05 1.5 2.2678571428571428e-05 1.5 2.267912946428571e-05 0.0 2.2695870535714284e-05 0.0 2.269642857142857e-05 1.5 2.269642857142857e-05 1.5 2.2696986607142857e-05 0.0 2.2713727678571426e-05 0.0 2.2714285714285713e-05 1.5 2.2714285714285713e-05 1.5 2.271484375e-05 0.0 2.2731026785714285e-05 0.0 2.2731584821428568e-05 1.5 2.2732700892857142e-05 1.5 2.273325892857143e-05 0.0 2.2748883928571427e-05 0.0 2.2749441964285714e-05 1.5 2.2750558035714284e-05 1.5 2.275111607142857e-05 0.0 2.276674107142857e-05 0.0 2.2767299107142856e-05 1.5 2.2768415178571426e-05 1.5 2.2768973214285713e-05 0.0 2.2784598214285712e-05 0.0 2.278515625e-05 1.5 2.278627232142857e-05 1.5 2.2786830357142855e-05 0.0 2.2802455357142854e-05 0.0 2.280301339285714e-05 1.5 2.280412946428571e-05 1.5 2.2804687499999998e-05 0.0 2.28203125e-05 0.0 2.2820870535714283e-05 1.5 2.2821986607142857e-05 1.5 2.282254464285714e-05 0.0 2.2838169642857142e-05 0.0 2.2838727678571426e-05 1.5 2.283984375e-05 1.5 2.2840401785714282e-05 0.0 2.2856026785714285e-05 0.0 2.285658482142857e-05 1.5 2.285770089285714e-05 1.5 2.2858258928571428e-05 0.0 2.2873883928571427e-05 0.0 2.2874441964285714e-05 1.5 2.2875558035714284e-05 1.5 2.287611607142857e-05 0.0 2.289174107142857e-05 0.0 2.2892299107142856e-05 1.5 2.2893415178571426e-05 1.5 2.2893973214285713e-05 0.0 2.290959821428571e-05 0.0 2.2910156249999998e-05 1.5 2.291127232142857e-05 1.5 2.2911830357142855e-05 0.0 2.2927455357142854e-05 0.0 2.292801339285714e-05 1.5 2.2929129464285714e-05 1.5 2.2929687499999997e-05 0.0 2.29453125e-05 0.0 2.2945870535714283e-05 1.5 2.2946986607142856e-05 1.5 2.294754464285714e-05 0.0 2.2963169642857142e-05 0.0 2.296372767857143e-05 1.5 2.296484375e-05 1.5 2.2965401785714285e-05 0.0 2.2981026785714284e-05 0.0 2.298158482142857e-05 1.5 2.298270089285714e-05 1.5 2.2983258928571428e-05 0.0 2.299832589285714e-05 0.0 2.2998883928571427e-05 1.5 2.300111607142857e-05 1.5 2.3001674107142857e-05 0.0 2.3016183035714285e-05 0.0 2.301674107142857e-05 1.5 2.3018973214285712e-05 1.5 2.301953125e-05 0.0 2.3034040178571428e-05 0.0 2.303459821428571e-05 1.5 2.3036830357142855e-05 1.5 2.303738839285714e-05 0.0 2.305189732142857e-05 0.0 2.3052455357142857e-05 1.5 2.3054687499999997e-05 1.5 2.3055245535714284e-05 0.0 2.3069754464285712e-05 0.0 2.30703125e-05 1.5 2.3072544642857143e-05 1.5 2.3073102678571426e-05 0.0 2.3087611607142855e-05 0.0 2.308816964285714e-05 1.5 2.3090401785714285e-05 1.5 2.309095982142857e-05 0.0 2.3105468749999997e-05 0.0 2.3106026785714284e-05 1.5 2.3108258928571427e-05 1.5 2.3108816964285714e-05 0.0 2.3123325892857143e-05 0.0 2.3123883928571426e-05 1.5 2.312611607142857e-05 1.5 2.3126674107142857e-05 0.0 2.3141183035714285e-05 0.0 2.314174107142857e-05 1.5 2.3143973214285712e-05 1.5 2.314453125e-05 0.0 2.3159040178571427e-05 0.0 2.3159598214285714e-05 1.5 2.3161830357142854e-05 1.5 2.316238839285714e-05 0.0 2.317689732142857e-05 0.0 2.3177455357142857e-05 1.5 2.3179687499999997e-05 1.5 2.3180245535714284e-05 0.0 2.3194754464285712e-05 0.0 2.31953125e-05 1.5 2.3197544642857142e-05 1.5 2.3198102678571426e-05 0.0 2.3212611607142854e-05 0.0 2.321316964285714e-05 1.5 2.3215959821428568e-05 1.5 2.3216517857142855e-05 0.0 2.3229910714285713e-05 0.0 2.3230468749999997e-05 1.5 2.3233816964285714e-05 1.5 2.3234374999999997e-05 0.0 2.3247767857142856e-05 0.0 2.3248325892857142e-05 1.5 2.3251674107142856e-05 1.5 2.325223214285714e-05 0.0 2.3265624999999998e-05 0.0 2.3266183035714285e-05 1.5 2.326953125e-05 1.5 2.3270089285714285e-05 0.0 2.328348214285714e-05 0.0 2.3284040178571427e-05 1.5 2.328738839285714e-05 1.5 2.3287946428571428e-05 0.0 2.3301339285714283e-05 0.0 2.330189732142857e-05 1.5 2.3305245535714283e-05 1.5 2.330580357142857e-05 0.0 2.331919642857143e-05 0.0 2.3319754464285712e-05 1.5 2.3323102678571425e-05 1.5 2.3323660714285712e-05 0.0 2.333705357142857e-05 0.0 2.3337611607142854e-05 1.5 2.334095982142857e-05 1.5 2.3341517857142855e-05 0.0 2.3354910714285713e-05 0.0 2.335546875e-05 1.5 2.3358816964285714e-05 1.5 2.3359374999999997e-05 0.0 2.3372767857142855e-05 0.0 2.3373325892857142e-05 1.5 2.3376674107142856e-05 1.5 2.3377232142857143e-05 0.0 2.3390624999999998e-05 0.0 2.3391183035714284e-05 1.5 2.3394531249999998e-05 1.5 2.3395089285714285e-05 0.0 2.3407924107142857e-05 0.0 2.340848214285714e-05 1.5 2.3412946428571427e-05 1.5 2.3413504464285714e-05 0.0 2.342578125e-05 0.0 2.3426339285714286e-05 1.5 2.343080357142857e-05 1.5 2.3431361607142856e-05 0.0 2.344363839285714e-05 0.0 2.3444196428571428e-05 1.5 2.3448660714285712e-05 1.5 2.344921875e-05 0.0 2.3461495535714284e-05 0.0 2.346205357142857e-05 1.5 2.3466517857142854e-05 1.5 2.346707589285714e-05 0.0 2.3479352678571426e-05 0.0 2.3479910714285713e-05 1.5 2.3484375e-05 1.5 2.3484933035714283e-05 0.0 2.3497209821428568e-05 0.0 2.3497767857142855e-05 1.5 2.3502232142857142e-05 1.5 2.3502790178571426e-05 0.0 2.3515066964285714e-05 0.0 2.3515624999999997e-05 1.5 2.3520089285714285e-05 1.5 2.352064732142857e-05 0.0 2.3532924107142856e-05 0.0 2.353348214285714e-05 1.5 2.3537946428571427e-05 1.5 2.3538504464285714e-05 0.0 2.355078125e-05 0.0 2.3551339285714285e-05 1.5 2.355580357142857e-05 1.5 2.3556361607142856e-05 0.0 2.356863839285714e-05 0.0 2.3569196428571428e-05 1.5 2.357366071428571e-05 1.5 2.3574218749999998e-05 0.0 2.35859375e-05 0.0 2.3586495535714283e-05 1.5 2.359207589285714e-05 1.5 2.3592633928571427e-05 0.0 2.3603794642857142e-05 0.0 2.3604352678571426e-05 1.5 2.3609933035714283e-05 1.5 2.361049107142857e-05 0.0 2.3621651785714285e-05 0.0 2.362220982142857e-05 1.5 2.3627790178571425e-05 1.5 2.3628348214285712e-05 0.0 2.3639508928571427e-05 0.0 2.3640066964285714e-05 1.5 2.364564732142857e-05 1.5 2.3646205357142854e-05 0.0 2.365736607142857e-05 0.0 2.3657924107142856e-05 1.5 2.3663504464285713e-05 1.5 2.3664062499999997e-05 0.0 2.367522321428571e-05 0.0 2.3675781249999998e-05 1.5 2.3681361607142856e-05 1.5 2.3681919642857142e-05 0.0 2.3693080357142854e-05 0.0 2.369363839285714e-05 1.5 2.3699218749999998e-05 1.5 2.3699776785714285e-05 0.0 2.37109375e-05 0.0 2.3711495535714283e-05 1.5 2.371707589285714e-05 1.5 2.3717633928571427e-05 0.0 2.3728794642857142e-05 0.0 2.3729352678571425e-05 1.5 2.3734933035714283e-05 1.5 2.373549107142857e-05 0.0 2.3746651785714284e-05 0.0 2.374720982142857e-05 1.5 2.375279017857143e-05 1.5 2.375334821428571e-05 0.0 2.376395089285714e-05 0.0 2.3764508928571426e-05 1.5 2.3771205357142854e-05 1.5 2.377176339285714e-05 0.0 2.3781808035714285e-05 0.0 2.378236607142857e-05 1.5 2.37890625e-05 1.5 2.3789620535714283e-05 0.0 2.3799665178571428e-05 0.0 2.380022321428571e-05 1.5 2.3806919642857142e-05 1.5 2.3807477678571425e-05 0.0 2.381752232142857e-05 0.0 2.3818080357142857e-05 1.5 2.3824776785714284e-05 1.5 2.382533482142857e-05 0.0 2.3835379464285712e-05 0.0 2.38359375e-05 1.5 2.3842633928571427e-05 1.5 2.3843191964285713e-05 0.0 2.3853236607142855e-05 0.0 2.385379464285714e-05 1.5 2.386049107142857e-05 1.5 2.3861049107142856e-05 0.0 2.3871093749999997e-05 0.0 2.3871651785714284e-05 1.5 2.387834821428571e-05 1.5 2.3878906249999998e-05 0.0 2.3888950892857143e-05 0.0 2.3889508928571426e-05 1.5 2.3896205357142857e-05 1.5 2.389676339285714e-05 0.0 2.3906808035714285e-05 0.0 2.390736607142857e-05 1.5 2.39140625e-05 1.5 2.3914620535714283e-05 0.0 2.392410714285714e-05 0.0 2.3924665178571427e-05 1.5 2.393247767857143e-05 1.5 2.3933035714285712e-05 0.0 2.3941964285714283e-05 0.0 2.394252232142857e-05 1.5 2.395033482142857e-05 1.5 2.3950892857142854e-05 0.0 2.3959821428571425e-05 0.0 2.3960379464285712e-05 1.5 2.3968191964285713e-05 1.5 2.396875e-05 0.0 2.397767857142857e-05 0.0 2.3978236607142854e-05 1.5 2.3986049107142855e-05 1.5 2.3986607142857142e-05 0.0 2.3995535714285713e-05 0.0 2.3996093749999997e-05 1.5 2.4003906249999998e-05 1.5 2.4004464285714284e-05 0.0 2.4013392857142856e-05 0.0 2.4013950892857142e-05 1.5 2.402176339285714e-05 1.5 2.4022321428571427e-05 0.0 2.4031249999999998e-05 0.0 2.4031808035714285e-05 1.5 2.4039620535714282e-05 1.5 2.404017857142857e-05 0.0 2.404910714285714e-05 0.0 2.4049665178571427e-05 1.5 2.4057477678571428e-05 1.5 2.405803571428571e-05 0.0 2.4066964285714283e-05 0.0 2.406752232142857e-05 1.5 2.407533482142857e-05 1.5 2.4075892857142854e-05 0.0 2.408426339285714e-05 0.0 2.408482142857143e-05 1.5 2.409375e-05 1.5 2.4094308035714283e-05 0.0 2.4102120535714284e-05 0.0 2.410267857142857e-05 1.5 2.4111607142857142e-05 1.5 2.4112165178571425e-05 0.0 2.4119977678571426e-05 0.0 2.4120535714285713e-05 1.5 2.4129464285714284e-05 1.5 2.413002232142857e-05 0.0 2.413783482142857e-05 0.0 2.4138392857142855e-05 1.5 2.4147321428571426e-05 1.5 2.4147879464285713e-05 0.0 2.415569196428571e-05 0.0 2.4156249999999998e-05 1.5 2.416517857142857e-05 1.5 2.4165736607142856e-05 0.0 2.4173549107142857e-05 0.0 2.417410714285714e-05 1.5 2.418303571428571e-05 1.5 2.4183593749999998e-05 0.0 2.419140625e-05 0.0 2.4191964285714286e-05 1.5 2.4200892857142857e-05 1.5 2.420145089285714e-05 0.0 2.420926339285714e-05 0.0 2.4209821428571428e-05 1.5 2.421875e-05 1.5 2.4219308035714283e-05 0.0 2.4227120535714284e-05 0.0 2.422767857142857e-05 1.5 2.4237165178571428e-05 1.5 2.423772321428571e-05 0.0 2.4244419642857143e-05 0.0 2.4244977678571426e-05 1.5 2.425502232142857e-05 1.5 2.4255580357142854e-05 0.0 2.4262276785714285e-05 0.0 2.4262834821428568e-05 1.5 2.4272879464285713e-05 1.5 2.42734375e-05 0.0 2.4280133928571427e-05 0.0 2.4280691964285714e-05 1.5 2.4290736607142855e-05 1.5 2.4291294642857142e-05 0.0 2.429799107142857e-05 0.0 2.4298549107142856e-05 1.5 2.4308593749999998e-05 1.5 2.4309151785714284e-05 0.0 2.4315848214285712e-05 0.0 2.431640625e-05 1.5 2.432645089285714e-05 1.5 2.4327008928571427e-05 0.0 2.4333705357142854e-05 0.0 2.433426339285714e-05 1.5 2.4344308035714286e-05 1.5 2.434486607142857e-05 0.0 2.43515625e-05 0.0 2.4352120535714283e-05 1.5 2.4362165178571428e-05 1.5 2.436272321428571e-05 0.0 2.4369419642857142e-05 0.0 2.4369977678571426e-05 1.5 2.438002232142857e-05 1.5 2.4380580357142857e-05 0.0 2.4387276785714284e-05 0.0 2.438783482142857e-05 1.5 2.4397879464285713e-05 1.5 2.43984375e-05 0.0 2.440457589285714e-05 0.0 2.4405133928571427e-05 1.5 2.441629464285714e-05 1.5 2.441685267857143e-05 0.0 2.4422433035714282e-05 0.0 2.442299107142857e-05 1.5 2.4434151785714284e-05 1.5 2.443470982142857e-05 0.0 2.4440290178571428e-05 0.0 2.444084821428571e-05 1.5 2.4452008928571426e-05 1.5 2.4452566964285713e-05 0.0 2.445814732142857e-05 0.0 2.4458705357142854e-05 1.5 2.446986607142857e-05 1.5 2.4470424107142855e-05 0.0 2.4476004464285713e-05 0.0 2.44765625e-05 1.5 2.448772321428571e-05 1.5 2.4488281249999998e-05 0.0 2.4493861607142855e-05 0.0 2.4494419642857142e-05 1.5 2.4505580357142857e-05 1.5 2.450613839285714e-05 0.0 2.4511718749999997e-05 0.0 2.4512276785714284e-05 1.5 2.45234375e-05 1.5 2.4523995535714282e-05 0.0 2.452957589285714e-05 0.0 2.4530133928571426e-05 1.5 2.454129464285714e-05 1.5 2.4541852678571428e-05 0.0 2.4547433035714285e-05 0.0 2.454799107142857e-05 1.5 2.4559151785714284e-05 1.5 2.455970982142857e-05 0.0 2.4565290178571428e-05 0.0 2.456584821428571e-05 1.5 2.4577566964285713e-05 1.5 2.4578125e-05 0.0 2.4582589285714283e-05 0.0 2.458314732142857e-05 1.5 2.4595424107142855e-05 1.5 2.4595982142857142e-05 0.0 2.4600446428571426e-05 0.0 2.4601004464285712e-05 1.5 2.4613281249999997e-05 1.5 2.4613839285714284e-05 0.0 2.461830357142857e-05 0.0 2.4618861607142855e-05 1.5 2.463113839285714e-05 1.5 2.4631696428571426e-05 0.0 2.4636160714285714e-05 0.0 2.4636718749999997e-05 1.5 2.4648995535714285e-05 1.5 2.464955357142857e-05 0.0 2.4654017857142856e-05 0.0 2.4654575892857143e-05 1.5 2.4666852678571428e-05 1.5 2.466741071428571e-05 0.0 2.4671874999999998e-05 0.0 2.4672433035714285e-05 1.5 2.468470982142857e-05 1.5 2.4685267857142857e-05 0.0 2.468973214285714e-05 0.0 2.4690290178571427e-05 1.5 2.4702566964285712e-05 1.5 2.4703125e-05 0.0 2.4707589285714283e-05 0.0 2.470814732142857e-05 1.5 2.4720424107142855e-05 1.5 2.472098214285714e-05 0.0 2.4725446428571425e-05 0.0 2.4726004464285712e-05 1.5 2.4738281249999997e-05 1.5 2.4738839285714284e-05 0.0 2.474330357142857e-05 0.0 2.4743861607142854e-05 1.5 2.4756696428571426e-05 1.5 2.4757254464285713e-05 0.0 2.4760602678571427e-05 0.0 2.4761160714285713e-05 1.5 2.477455357142857e-05 1.5 2.4775111607142855e-05 0.0 2.477845982142857e-05 0.0 2.4779017857142856e-05 1.5 2.4792410714285714e-05 1.5 2.4792968749999997e-05 0.0 2.479631696428571e-05 0.0 2.4796874999999998e-05 1.5 2.4810267857142856e-05 1.5 2.481082589285714e-05 0.0 2.4814174107142857e-05 0.0 2.481473214285714e-05 1.5 2.4828125e-05 1.5 2.4828683035714285e-05 0.0 2.483203125e-05 0.0 2.4832589285714283e-05 1.5 2.484598214285714e-05 1.5 2.4846540178571428e-05 0.0 2.484988839285714e-05 0.0 2.485044642857143e-05 1.5 2.4863839285714283e-05 1.5 2.486439732142857e-05 0.0 2.4867745535714284e-05 0.0 2.486830357142857e-05 1.5 2.4881696428571426e-05 1.5 2.4882254464285712e-05 0.0 2.4885602678571426e-05 0.0 2.4886160714285713e-05 1.5 2.4899553571428568e-05 1.5 2.4900111607142855e-05 0.0 2.490345982142857e-05 0.0 2.4904017857142855e-05 1.5 2.4917410714285714e-05 1.5 2.4917968749999997e-05 0.0 2.492131696428571e-05 0.0 2.4921874999999998e-05 1.5 2.4935267857142856e-05 1.5 2.493582589285714e-05 0.0 2.4939174107142857e-05 0.0 2.493973214285714e-05 1.5 2.4953683035714285e-05 1.5 2.495424107142857e-05 0.0 2.4956473214285712e-05 0.0 2.495703125e-05 1.5 2.4971540178571427e-05 1.5 2.497209821428571e-05 0.0 2.4974330357142854e-05 0.0 2.497488839285714e-05 1.5 2.498939732142857e-05 1.5 2.4989955357142857e-05 0.0 2.4992187499999997e-05 0.0 2.4992745535714284e-05 1.5 2.5007254464285712e-05 1.5 2.50078125e-05 0.0 2.5010044642857142e-05 0.0 2.5010602678571426e-05 1.5 2.5025111607142854e-05 1.5 2.502566964285714e-05 0.0 2.5027901785714285e-05 0.0 2.5028459821428568e-05 1.5 2.5042968749999997e-05 1.5 2.5043526785714283e-05 0.0 2.5045758928571427e-05 0.0 2.5046316964285714e-05 1.5 2.5060825892857142e-05 1.5 2.5061383928571426e-05 0.0 2.506361607142857e-05 0.0 2.5064174107142856e-05 1.5 2.5078683035714285e-05 1.5 2.5079241071428568e-05 0.0 2.5081473214285712e-05 0.0 2.508203125e-05 1.5 2.5096540178571427e-05 1.5 2.5097098214285714e-05 0.0 2.5099330357142854e-05 0.0 2.509988839285714e-05 1.5 2.511439732142857e-05 1.5 2.5114955357142856e-05 0.0 2.51171875e-05 0.0 2.5117745535714283e-05 1.5 2.5132254464285712e-05 1.5 2.51328125e-05 0.0 2.5135044642857142e-05 0.0 2.5135602678571426e-05 1.5 2.5150111607142854e-05 1.5 2.515066964285714e-05 0.0 2.5152901785714284e-05 0.0 2.515345982142857e-05 1.5 2.5168526785714283e-05 1.5 2.516908482142857e-05 0.0 2.517020089285714e-05 0.0 2.5170758928571427e-05 1.5 2.5186383928571425e-05 1.5 2.5186941964285712e-05 0.0 2.5188058035714282e-05 0.0 2.518861607142857e-05 1.5 2.520424107142857e-05 1.5 2.5204799107142855e-05 0.0 2.5205915178571428e-05 0.0 2.520647321428571e-05 1.5 2.5222098214285714e-05 1.5 2.5222656249999997e-05 0.0 2.522377232142857e-05 0.0 2.5224330357142854e-05 1.5 2.5239955357142856e-05 1.5 2.5240513392857143e-05 0.0 2.5241629464285713e-05 0.0 2.52421875e-05 1.5 2.5257812499999998e-05 1.5 2.5258370535714285e-05 0.0 2.5259486607142855e-05 0.0 2.5260044642857142e-05 1.5 2.527566964285714e-05 1.5 2.5276227678571427e-05 0.0 2.5277343749999997e-05 0.0 2.5277901785714284e-05 1.5 2.5293526785714283e-05 1.5 2.529408482142857e-05 0.0 2.529520089285714e-05 0.0 2.5295758928571426e-05 1.5 2.5311383928571425e-05 1.5 2.5311941964285712e-05 0.0 2.5313058035714285e-05 0.0 2.531361607142857e-05 1.5 2.532924107142857e-05 1.5 2.5329799107142854e-05 0.0 2.5330915178571428e-05 0.0 2.533147321428571e-05 1.5 2.5347098214285713e-05 1.5 2.5347656249999997e-05 0.0 2.534877232142857e-05 0.0 2.5349330357142857e-05 1.5 2.5364955357142855e-05 1.5 2.5365513392857142e-05 0.0 2.5366629464285712e-05 0.0 2.53671875e-05 1.5 2.5382812499999998e-05 1.5 2.5383370535714285e-05 0.0 2.5384486607142855e-05 0.0 2.538504464285714e-05 1.5 2.540066964285714e-05 1.5 2.5401227678571427e-05 0.0 2.5402343749999997e-05 0.0 2.5402901785714284e-05 1.5 2.5418526785714282e-05 1.5 2.541908482142857e-05 0.0 2.5420200892857143e-05 0.0 2.5420758928571426e-05 1.5 2.5436383928571428e-05 1.5 2.543694196428571e-05 0.0 2.5437499999999998e-05 0.0 2.5438058035714285e-05 1.5 2.5454799107142854e-05 1.5 2.545535714285714e-05 0.0 2.545535714285714e-05 0.0 2.5455915178571427e-05 1.5 2.547265625e-05 1.5 2.5473214285714283e-05 0.0 2.5473214285714283e-05 0.0 2.547377232142857e-05 1.5 2.5490513392857142e-05 1.5 2.5491071428571425e-05 0.0 2.5491071428571425e-05 0.0 2.5491629464285712e-05 1.5 2.5508370535714284e-05 1.5 2.550892857142857e-05 0.0 2.550892857142857e-05 0.0 2.5509486607142854e-05 1.5 2.5526227678571427e-05 1.5 2.5526785714285713e-05 0.0 2.5526785714285713e-05 0.0 2.5527343749999997e-05 1.5 2.554408482142857e-05 1.5 2.5544642857142856e-05 0.0 2.5544642857142856e-05 0.0 2.5545200892857142e-05 1.5 2.556194196428571e-05 1.5 2.5562499999999998e-05 0.0 2.5562499999999998e-05 0.0 2.5563058035714285e-05 1.5 2.5579799107142857e-05 1.5 2.558035714285714e-05 0.0 2.558035714285714e-05 0.0 2.5580915178571427e-05 1.5 2.559765625e-05 1.5 2.5598214285714283e-05 0.0 2.5598214285714283e-05 0.0 2.559877232142857e-05 1.5 2.561551339285714e-05 1.5 2.5616071428571428e-05 0.0 2.5616071428571428e-05 0.0 2.561662946428571e-05 1.5 2.5633370535714284e-05 1.5 2.563392857142857e-05 0.0 2.563392857142857e-05 0.0 2.5634486607142854e-05 1.5 2.5651227678571426e-05 1.5 2.5651785714285713e-05 0.0 2.5651785714285713e-05 0.0 2.565234375e-05 1.5 2.566908482142857e-05 1.5 2.5669642857142855e-05 0.0 2.5669642857142855e-05 0.0 2.5670200892857142e-05 1.5 2.568694196428571e-05 1.5 2.5687499999999998e-05 0.0 2.5687499999999998e-05 0.0 2.5688058035714284e-05 1.5 2.5704799107142857e-05 1.5 2.570535714285714e-05 0.0 2.570535714285714e-05 0.0 2.5705915178571427e-05 1.5 2.572265625e-05 1.5 2.5723214285714282e-05 0.0 2.5723214285714282e-05 0.0 2.572377232142857e-05 1.5 2.574051339285714e-05 1.5 2.5741071428571428e-05 0.0 2.5741071428571428e-05 0.0 2.574162946428571e-05 1.5 2.5758370535714284e-05 1.5 2.575892857142857e-05 0.0 2.575892857142857e-05 0.0 2.5759486607142854e-05 1.5 2.5776227678571426e-05 1.5 2.5776785714285713e-05 0.0 2.5776785714285713e-05 0.0 2.577734375e-05 1.5 2.5794084821428568e-05 1.5 2.5794642857142855e-05 0.0 2.5794642857142855e-05 0.0 2.579520089285714e-05 1.5 2.5811941964285714e-05 1.5 2.5812499999999997e-05 0.0 2.5812499999999997e-05 0.0 2.5813058035714284e-05 1.5 2.5829799107142856e-05 1.5 2.583035714285714e-05 0.0 2.583035714285714e-05 0.0 2.5830915178571426e-05 1.5 2.584765625e-05 1.5 2.5848214285714285e-05 0.0 2.5848214285714285e-05 0.0 2.584877232142857e-05 1.5 2.586551339285714e-05 1.5 2.5866071428571428e-05 0.0 2.5866071428571428e-05 0.0 2.586662946428571e-05 1.5 2.5883370535714283e-05 1.5 2.588392857142857e-05 0.0 2.588392857142857e-05 0.0 2.5884486607142857e-05 1.5 2.5901227678571425e-05 1.5 2.5901785714285712e-05 0.0 2.5901785714285712e-05 0.0 2.590234375e-05 1.5 2.591908482142857e-05 1.5 2.5919642857142855e-05 0.0 2.5919642857142855e-05 0.0 2.592020089285714e-05 1.5 2.5936941964285714e-05 1.5 2.5937499999999997e-05 0.0 2.5937499999999997e-05 0.0 2.5938058035714284e-05 1.5 2.5954799107142856e-05 1.5 2.5955357142857143e-05 0.0 2.5955357142857143e-05 0.0 2.5955915178571426e-05 1.5 2.5972656249999998e-05 1.5 2.5973214285714285e-05 0.0 2.5973214285714285e-05 0.0 2.5973772321428568e-05 1.5 2.599051339285714e-05 1.5 2.5991071428571427e-05 0.0 2.5991071428571427e-05 0.0 2.5991629464285714e-05 1.5 2.6008370535714283e-05 1.5 2.600892857142857e-05 0.0 2.600892857142857e-05 0.0 2.6009486607142856e-05 1.5 2.6026227678571425e-05 1.5 2.6026785714285712e-05 0.0 2.6026785714285712e-05 0.0 2.602734375e-05 1.5 2.604408482142857e-05 1.5 2.6044642857142854e-05 0.0 2.6044642857142854e-05 0.0 2.604520089285714e-05 1.5 2.6061941964285713e-05 1.5 2.6062499999999997e-05 0.0 2.6062499999999997e-05 0.0 2.6063058035714283e-05 1.5 2.6079799107142855e-05 1.5 2.6080357142857142e-05 0.0 2.6080357142857142e-05 0.0 2.6080915178571426e-05 1.5 2.6097656249999998e-05 1.5 2.6098214285714285e-05 0.0 2.6098214285714285e-05 0.0 2.6098772321428568e-05 1.5 2.611551339285714e-05 1.5 2.6116071428571427e-05 0.0 2.6116071428571427e-05 0.0 2.6116629464285714e-05 1.5 2.6133370535714282e-05 1.5 2.613392857142857e-05 0.0 2.613392857142857e-05 0.0 2.6134486607142856e-05 1.5 2.6151227678571428e-05 1.5 2.615178571428571e-05 0.0 2.615178571428571e-05 0.0 2.6152343749999998e-05 1.5 2.616908482142857e-05 1.5 2.6169642857142854e-05 0.0 2.6169642857142854e-05 0.0 2.617020089285714e-05 1.5 2.6186941964285713e-05 1.5 2.61875e-05 0.0 2.61875e-05 0.0 2.6188058035714283e-05 1.5 2.6204799107142855e-05 1.5 2.6205357142857142e-05 0.0 2.6205357142857142e-05 0.0 2.6205915178571425e-05 1.5 2.6222656249999997e-05 1.5 2.6223214285714284e-05 0.0 2.6223214285714284e-05 0.0 2.622377232142857e-05 1.5 2.624051339285714e-05 1.5 2.6241071428571427e-05 0.0 2.6241071428571427e-05 0.0 2.6241629464285713e-05 1.5 2.6258370535714285e-05 1.5 2.625892857142857e-05 0.0 2.625892857142857e-05 0.0 2.6259486607142856e-05 1.5 2.6276227678571428e-05 1.5 2.627678571428571e-05 0.0 2.627678571428571e-05 0.0 2.6277343749999998e-05 1.5 2.629408482142857e-05 1.5 2.6294642857142857e-05 0.0 2.6294642857142857e-05 0.0 2.629520089285714e-05 1.5 2.6311941964285712e-05 1.5 2.63125e-05 0.0 2.63125e-05 0.0 2.6313058035714283e-05 1.5 2.6329799107142855e-05 1.5 2.633035714285714e-05 0.0 2.633035714285714e-05 0.0 2.6330915178571428e-05 1.5 2.6347656249999997e-05 1.5 2.6348214285714284e-05 0.0 2.6348214285714284e-05 0.0 2.634877232142857e-05 1.5 2.636551339285714e-05 1.5 2.6366071428571426e-05 0.0 2.6366071428571426e-05 0.0 2.6366629464285713e-05 1.5 2.6383370535714285e-05 1.5 2.638392857142857e-05 0.0 2.638392857142857e-05 0.0 2.6384486607142855e-05 1.5 2.6401227678571427e-05 1.5 2.640178571428571e-05 0.0 2.640178571428571e-05 0.0 2.6402343749999998e-05 1.5 2.641908482142857e-05 1.5 2.6419642857142857e-05 0.0 2.6419642857142857e-05 0.0 2.642020089285714e-05 1.5 2.6436941964285712e-05 1.5 2.64375e-05 0.0 2.64375e-05 0.0 2.6438058035714282e-05 1.5 2.6454799107142854e-05 1.5 2.645535714285714e-05 0.0 2.645535714285714e-05 0.0 2.6455915178571428e-05 1.5 2.6472656249999997e-05 1.5 2.6473214285714284e-05 0.0 2.6473214285714284e-05 0.0 2.647377232142857e-05 1.5 2.6490513392857142e-05 1.5 2.6491071428571426e-05 0.0 2.6491071428571426e-05 0.0 2.6491629464285713e-05 1.5 2.6508370535714285e-05 1.5 2.6508928571428568e-05 0.0 2.6508928571428568e-05 0.0 2.6509486607142855e-05 1.5 2.6526227678571427e-05 1.5 2.6526785714285714e-05 0.0 2.6526785714285714e-05 0.0 2.6527343749999997e-05 1.5 2.654408482142857e-05 1.5 2.6544642857142856e-05 0.0 2.6544642857142856e-05 0.0 2.654520089285714e-05 1.5 2.6561941964285712e-05 1.5 2.65625e-05 0.0 2.65625e-05 0.0 2.6563058035714285e-05 1.5 2.6579799107142854e-05 1.5 2.658035714285714e-05 0.0 2.658035714285714e-05 0.0 2.6580915178571428e-05 1.5 2.6597656249999996e-05 1.5 2.6598214285714283e-05 0.0 2.6598214285714283e-05 0.0 2.659877232142857e-05 1.5 2.6615513392857142e-05 1.5 2.6616071428571425e-05 0.0 2.6616071428571425e-05 0.0 2.6616629464285712e-05 1.5 2.6633370535714284e-05 1.5 2.663392857142857e-05 0.0 2.663392857142857e-05 0.0 2.6634486607142855e-05 1.5 2.6651227678571427e-05 1.5 2.6651785714285714e-05 0.0 2.6651785714285714e-05 0.0 2.6652343749999997e-05 1.5 2.666908482142857e-05 1.5 2.6669642857142856e-05 0.0 2.6669642857142856e-05 0.0 2.6670200892857143e-05 1.5 2.668694196428571e-05 1.5 2.6687499999999998e-05 0.0 2.6687499999999998e-05 0.0 2.6688058035714285e-05 1.5 2.6704799107142854e-05 1.5 2.670535714285714e-05 0.0 2.670535714285714e-05 0.0 2.6705915178571427e-05 1.5 2.672265625e-05 1.5 2.6723214285714283e-05 0.0 2.6723214285714283e-05 0.0 2.672377232142857e-05 1.5 2.6739955357142855e-05 1.5 2.6740513392857142e-05 0.0 2.6741629464285712e-05 0.0 2.67421875e-05 1.5 2.6757812499999997e-05 1.5 2.6758370535714284e-05 0.0 2.6759486607142854e-05 0.0 2.676004464285714e-05 1.5 2.677566964285714e-05 1.5 2.6776227678571426e-05 0.0 2.6777343749999997e-05 0.0 2.6777901785714283e-05 1.5 2.6793526785714285e-05 1.5 2.679408482142857e-05 0.0 2.6795200892857142e-05 0.0 2.6795758928571426e-05 1.5 2.6811383928571428e-05 1.5 2.681194196428571e-05 0.0 2.6813058035714285e-05 0.0 2.6813616071428568e-05 1.5 2.682924107142857e-05 1.5 2.6829799107142857e-05 0.0 2.6830915178571427e-05 0.0 2.6831473214285714e-05 1.5 2.6847098214285712e-05 1.5 2.684765625e-05 0.0 2.684877232142857e-05 0.0 2.6849330357142856e-05 1.5 2.6864955357142855e-05 1.5 2.686551339285714e-05 0.0 2.686662946428571e-05 0.0 2.6867187499999998e-05 1.5 2.6882812499999997e-05 1.5 2.6883370535714284e-05 0.0 2.6884486607142854e-05 0.0 2.688504464285714e-05 1.5 2.690066964285714e-05 1.5 2.6901227678571426e-05 0.0 2.690234375e-05 0.0 2.6902901785714283e-05 1.5 2.6918526785714285e-05 1.5 2.691908482142857e-05 0.0 2.6920200892857142e-05 0.0 2.6920758928571425e-05 1.5 2.6936383928571427e-05 1.5 2.693694196428571e-05 0.0 2.6938058035714284e-05 0.0 2.693861607142857e-05 1.5 2.695424107142857e-05 1.5 2.6954799107142856e-05 0.0 2.6955915178571427e-05 0.0 2.6956473214285713e-05 1.5 2.6972098214285712e-05 1.5 2.697265625e-05 0.0 2.697377232142857e-05 0.0 2.6974330357142856e-05 1.5 2.6989955357142854e-05 1.5 2.699051339285714e-05 0.0 2.699162946428571e-05 0.0 2.6992187499999998e-05 1.5 2.7007254464285713e-05 1.5 2.7007812499999997e-05 0.0 2.701004464285714e-05 0.0 2.7010602678571427e-05 1.5 2.7025111607142856e-05 1.5 2.7025669642857142e-05 0.0 2.7027901785714283e-05 0.0 2.702845982142857e-05 1.5 2.7042968749999998e-05 1.5 2.7043526785714285e-05 0.0 2.704575892857143e-05 0.0 2.704631696428571e-05 1.5 2.706082589285714e-05 1.5 2.7061383928571427e-05 0.0 2.706361607142857e-05 0.0 2.7064174107142854e-05 1.5 2.7078683035714283e-05 1.5 2.707924107142857e-05 0.0 2.7081473214285713e-05 0.0 2.708203125e-05 1.5 2.7096540178571428e-05 1.5 2.709709821428571e-05 0.0 2.7099330357142855e-05 0.0 2.7099888392857142e-05 1.5 2.711439732142857e-05 1.5 2.7114955357142854e-05 0.0 2.7117187499999998e-05 0.0 2.7117745535714284e-05 1.5 2.7132254464285713e-05 1.5 2.71328125e-05 0.0 2.713504464285714e-05 0.0 2.7135602678571427e-05 1.5 2.7150111607142855e-05 1.5 2.7150669642857142e-05 0.0 2.7152901785714282e-05 0.0 2.715345982142857e-05 1.5 2.7167968749999998e-05 1.5 2.7168526785714284e-05 0.0 2.7170758928571428e-05 0.0 2.717131696428571e-05 1.5 2.718582589285714e-05 1.5 2.7186383928571427e-05 0.0 2.718861607142857e-05 0.0 2.7189174107142854e-05 1.5 2.7203683035714282e-05 1.5 2.720424107142857e-05 0.0 2.7206473214285713e-05 0.0 2.720703125e-05 1.5 2.7221540178571428e-05 1.5 2.722209821428571e-05 0.0 2.7224330357142855e-05 0.0 2.722488839285714e-05 1.5 2.7238839285714283e-05 1.5 2.723939732142857e-05 0.0 2.7242745535714284e-05 0.0 2.724330357142857e-05 1.5 2.7256696428571426e-05 1.5 2.7257254464285713e-05 0.0 2.7260602678571426e-05 0.0 2.7261160714285713e-05 1.5 2.7274553571428568e-05 1.5 2.7275111607142855e-05 0.0 2.727845982142857e-05 0.0 2.7279017857142855e-05 1.5 2.7292410714285714e-05 1.5 2.7292968749999997e-05 0.0 2.729631696428571e-05 0.0 2.7296874999999998e-05 1.5 2.7310267857142856e-05 1.5 2.731082589285714e-05 0.0 2.7314174107142857e-05 0.0 2.731473214285714e-05 1.5 2.7328125e-05 1.5 2.7328683035714285e-05 0.0 2.733203125e-05 0.0 2.7332589285714282e-05 1.5 2.734598214285714e-05 1.5 2.7346540178571428e-05 0.0 2.734988839285714e-05 0.0 2.7350446428571428e-05 1.5 2.7363839285714283e-05 1.5 2.736439732142857e-05 0.0 2.7367745535714284e-05 0.0 2.736830357142857e-05 1.5 2.7381696428571425e-05 1.5 2.7382254464285712e-05 0.0 2.7385602678571426e-05 0.0 2.7386160714285713e-05 1.5 2.7399553571428568e-05 1.5 2.7400111607142855e-05 0.0 2.740345982142857e-05 0.0 2.7404017857142855e-05 1.5 2.7417410714285713e-05 1.5 2.7417968749999997e-05 0.0 2.7421874999999997e-05 0.0 2.7422433035714284e-05 1.5 2.743470982142857e-05 1.5 2.7435267857142856e-05 0.0 2.743973214285714e-05 0.0 2.7440290178571426e-05 1.5 2.745256696428571e-05 1.5 2.7453124999999998e-05 0.0 2.7457589285714285e-05 0.0 2.745814732142857e-05 1.5 2.7470424107142854e-05 1.5 2.747098214285714e-05 0.0 2.7475446428571428e-05 0.0 2.747600446428571e-05 1.5 2.748828125e-05 1.5 2.7488839285714283e-05 0.0 2.749330357142857e-05 0.0 2.7493861607142857e-05 1.5 2.7506138392857142e-05 1.5 2.7506696428571425e-05 0.0 2.7511160714285712e-05 0.0 2.751171875e-05 1.5 2.7523995535714284e-05 1.5 2.752455357142857e-05 0.0 2.7529017857142855e-05 0.0 2.752957589285714e-05 1.5 2.7541852678571426e-05 1.5 2.7542410714285713e-05 0.0 2.7546874999999997e-05 0.0 2.7547433035714284e-05 1.5 2.755970982142857e-05 1.5 2.7560267857142855e-05 0.0 2.756473214285714e-05 0.0 2.7565290178571426e-05 1.5 2.757756696428571e-05 1.5 2.7578124999999998e-05 0.0 2.7582589285714285e-05 0.0 2.758314732142857e-05 1.5 2.7595424107142857e-05 1.5 2.759598214285714e-05 0.0 2.760100446428571e-05 0.0 2.7601562499999998e-05 1.5 2.7612723214285712e-05 1.5 2.761328125e-05 0.0 2.7618861607142856e-05 0.0 2.761941964285714e-05 1.5 2.7630580357142855e-05 1.5 2.763113839285714e-05 0.0 2.763671875e-05 0.0 2.7637276785714282e-05 1.5 2.7648437499999997e-05 1.5 2.7648995535714284e-05 0.0 2.765457589285714e-05 0.0 2.7655133928571428e-05 1.5 2.766629464285714e-05 1.5 2.7666852678571426e-05 0.0 2.7672433035714283e-05 0.0 2.767299107142857e-05 1.5 2.7684151785714285e-05 1.5 2.768470982142857e-05 0.0 2.7690290178571426e-05 0.0 2.7690848214285713e-05 1.5 2.7702008928571427e-05 1.5 2.770256696428571e-05 0.0 2.7708147321428568e-05 0.0 2.7708705357142855e-05 1.5 2.771986607142857e-05 1.5 2.7720424107142856e-05 0.0 2.7726004464285714e-05 0.0 2.7726562499999997e-05 1.5 2.7737723214285712e-05 1.5 2.773828125e-05 0.0 2.7743861607142856e-05 0.0 2.774441964285714e-05 1.5 2.7755580357142854e-05 1.5 2.775613839285714e-05 0.0 2.776171875e-05 0.0 2.7762276785714285e-05 1.5 2.7772879464285713e-05 1.5 2.7773437499999997e-05 0.0 2.7780133928571428e-05 0.0 2.778069196428571e-05 1.5 2.7790736607142856e-05 1.5 2.7791294642857142e-05 0.0 2.779799107142857e-05 0.0 2.7798549107142857e-05 1.5 2.7808593749999998e-05 1.5 2.7809151785714285e-05 0.0 2.7815848214285712e-05 0.0 2.781640625e-05 1.5 2.782645089285714e-05 1.5 2.7827008928571427e-05 0.0 2.7833705357142854e-05 0.0 2.783426339285714e-05 1.5 2.7844308035714283e-05 1.5 2.784486607142857e-05 0.0 2.7851562499999997e-05 0.0 2.7852120535714284e-05 1.5 2.7862165178571428e-05 1.5 2.786272321428571e-05 0.0 2.7869419642857143e-05 0.0 2.7869977678571426e-05 1.5 2.788002232142857e-05 1.5 2.7880580357142854e-05 0.0 2.7887276785714285e-05 0.0 2.7887834821428568e-05 1.5 2.7897879464285713e-05 1.5 2.78984375e-05 0.0 2.7905133928571427e-05 0.0 2.7905691964285714e-05 1.5 2.7915736607142855e-05 1.5 2.7916294642857142e-05 0.0 2.792299107142857e-05 0.0 2.7923549107142856e-05 1.5 2.793303571428571e-05 1.5 2.7933593749999998e-05 0.0 2.794140625e-05 0.0 2.7941964285714285e-05 1.5 2.7950892857142856e-05 1.5 2.795145089285714e-05 0.0 2.795926339285714e-05 0.0 2.7959821428571428e-05 1.5 2.796875e-05 1.5 2.7969308035714282e-05 0.0 2.7977120535714283e-05 0.0 2.797767857142857e-05 1.5 2.798660714285714e-05 1.5 2.7987165178571428e-05 0.0 2.7994977678571426e-05 0.0 2.7995535714285712e-05 1.5 2.8004464285714283e-05 1.5 2.800502232142857e-05 0.0 2.8012834821428568e-05 0.0 2.8013392857142855e-05 1.5 2.8022321428571426e-05 1.5 2.8022879464285713e-05 0.0 2.8030691964285714e-05 0.0 2.8031249999999997e-05 1.5 2.8040178571428568e-05 1.5 2.8040736607142855e-05 0.0 2.8048549107142856e-05 0.0 2.804910714285714e-05 1.5 2.8058035714285714e-05 1.5 2.8058593749999997e-05 0.0 2.8066406249999998e-05 0.0 2.8066964285714285e-05 1.5 2.8075892857142856e-05 1.5 2.807645089285714e-05 0.0 2.808426339285714e-05 0.0 2.8084821428571427e-05 1.5 2.8093191964285712e-05 1.5 2.809375e-05 0.0 2.810267857142857e-05 0.0 2.8103236607142856e-05 1.5 2.8111049107142854e-05 1.5 2.811160714285714e-05 0.0 2.8120535714285712e-05 0.0 2.812109375e-05 1.5 2.8128906249999996e-05 1.5 2.8129464285714283e-05 0.0 2.8138392857142854e-05 0.0 2.813895089285714e-05 1.5 2.8146763392857142e-05 1.5 2.8147321428571425e-05 0.0 2.8156249999999997e-05 0.0 2.8156808035714283e-05 1.5 2.8164620535714284e-05 1.5 2.8165178571428568e-05 0.0 2.8174107142857142e-05 0.0 2.8174665178571426e-05 1.5 2.8182477678571427e-05 1.5 2.8183035714285713e-05 0.0 2.8191964285714285e-05 0.0 2.8192522321428568e-05 1.5 2.820033482142857e-05 1.5 2.8200892857142856e-05 0.0 2.8209821428571427e-05 0.0 2.8210379464285714e-05 1.5 2.821819196428571e-05 1.5 2.8218749999999998e-05 0.0 2.822767857142857e-05 0.0 2.8228236607142856e-05 1.5 2.8236049107142854e-05 1.5 2.823660714285714e-05 0.0 2.824553571428571e-05 0.0 2.824609375e-05 1.5 2.8253348214285713e-05 1.5 2.825390625e-05 0.0 2.826395089285714e-05 0.0 2.8264508928571427e-05 1.5 2.8271205357142855e-05 1.5 2.8271763392857142e-05 0.0 2.8281808035714283e-05 0.0 2.828236607142857e-05 1.5 2.8289062499999997e-05 1.5 2.8289620535714284e-05 0.0 2.8299665178571425e-05 0.0 2.8300223214285712e-05 1.5 2.830691964285714e-05 1.5 2.8307477678571426e-05 0.0 2.831752232142857e-05 0.0 2.8318080357142854e-05 1.5 2.8324776785714285e-05 1.5 2.832533482142857e-05 0.0 2.8335379464285713e-05 0.0 2.8335937499999997e-05 1.5 2.8342633928571428e-05 1.5 2.834319196428571e-05 0.0 2.8353236607142856e-05 0.0 2.8353794642857142e-05 1.5 2.836049107142857e-05 1.5 2.8361049107142857e-05 0.0 2.8371093749999998e-05 0.0 2.8371651785714285e-05 1.5 2.8378348214285712e-05 1.5 2.837890625e-05 0.0 2.838895089285714e-05 0.0 2.8389508928571427e-05 1.5 2.8396205357142855e-05 1.5 2.839676339285714e-05 0.0 2.8406808035714283e-05 0.0 2.840736607142857e-05 1.5 2.8413504464285714e-05 1.5 2.8414062499999997e-05 0.0 2.8425223214285712e-05 0.0 2.842578125e-05 1.5 2.8431361607142856e-05 1.5 2.843191964285714e-05 0.0 2.8443080357142854e-05 0.0 2.844363839285714e-05 1.5 2.8449218749999998e-05 1.5 2.8449776785714285e-05 0.0 2.8460937499999996e-05 0.0 2.8461495535714283e-05 1.5 2.846707589285714e-05 1.5 2.8467633928571427e-05 0.0 2.8478794642857142e-05 0.0 2.8479352678571425e-05 1.5 2.8484933035714283e-05 1.5 2.848549107142857e-05 0.0 2.8496651785714284e-05 0.0 2.8497209821428568e-05 1.5 2.8502790178571425e-05 1.5 2.8503348214285712e-05 0.0 2.8514508928571427e-05 0.0 2.8515066964285713e-05 1.5 2.852064732142857e-05 1.5 2.8521205357142854e-05 0.0 2.853236607142857e-05 0.0 2.8532924107142856e-05 1.5 2.8538504464285713e-05 1.5 2.8539062499999997e-05 0.0 2.855022321428571e-05 0.0 2.8550781249999998e-05 1.5 2.8556361607142856e-05 1.5 2.8556919642857142e-05 0.0 2.8568080357142854e-05 0.0 2.856863839285714e-05 1.5 2.8574218749999998e-05 1.5 2.8574776785714285e-05 0.0 2.8586495535714283e-05 0.0 2.858705357142857e-05 1.5 2.8591517857142853e-05 1.5 2.859207589285714e-05 0.0 2.8604352678571425e-05 0.0 2.8604910714285712e-05 1.5 2.8609375e-05 1.5 2.8609933035714283e-05 0.0 2.862220982142857e-05 0.0 2.8622767857142854e-05 1.5 2.862723214285714e-05 1.5 2.8627790178571425e-05 0.0 2.8640066964285713e-05 0.0 2.8640624999999997e-05 1.5 2.8645089285714284e-05 1.5 2.864564732142857e-05 0.0 2.8657924107142855e-05 0.0 2.8658482142857142e-05 1.5 2.8662946428571426e-05 1.5 2.8663504464285713e-05 0.0 2.8675781249999998e-05 0.0 2.8676339285714285e-05 1.5 2.868080357142857e-05 1.5 2.8681361607142855e-05 0.0 2.869363839285714e-05 0.0 2.8694196428571427e-05 1.5 2.869866071428571e-05 1.5 2.8699218749999998e-05 0.0 2.8711495535714282e-05 0.0 2.871205357142857e-05 1.5 2.8716517857142856e-05 1.5 2.871707589285714e-05 0.0 2.8729352678571428e-05 0.0 2.872991071428571e-05 1.5 2.8734375e-05 1.5 2.8734933035714282e-05 0.0 2.874720982142857e-05 0.0 2.8747767857142854e-05 1.5 2.875223214285714e-05 1.5 2.8752790178571428e-05 0.0 2.8765625e-05 0.0 2.8766183035714283e-05 1.5 2.8769531249999997e-05 1.5 2.8770089285714283e-05 0.0 2.8783482142857142e-05 0.0 2.8784040178571425e-05 1.5 2.8787388392857142e-05 1.5 2.8787946428571426e-05 0.0 2.8801339285714284e-05 0.0 2.880189732142857e-05 1.5 2.8805245535714285e-05 1.5 2.8805803571428568e-05 0.0 2.8819196428571427e-05 0.0 2.8819754464285713e-05 1.5 2.8823102678571427e-05 1.5 2.8823660714285714e-05 0.0 2.883705357142857e-05 0.0 2.8837611607142856e-05 1.5 2.884095982142857e-05 1.5 2.8841517857142856e-05 0.0 2.885491071428571e-05 0.0 2.8855468749999998e-05 1.5 2.885881696428571e-05 1.5 2.8859375e-05 0.0 2.8872767857142853e-05 0.0 2.887332589285714e-05 1.5 2.8876674107142854e-05 1.5 2.887723214285714e-05 0.0 2.8890625e-05 0.0 2.8891183035714283e-05 1.5 2.8894531249999996e-05 1.5 2.8895089285714283e-05 0.0 2.890848214285714e-05 0.0 2.8909040178571425e-05 1.5 2.8912388392857142e-05 1.5 2.8912946428571425e-05 0.0 2.8926339285714284e-05 0.0 2.892689732142857e-05 1.5 2.8930245535714284e-05 1.5 2.8930803571428568e-05 0.0 2.8944196428571426e-05 0.0 2.8944754464285713e-05 1.5 2.8948102678571427e-05 1.5 2.8948660714285713e-05 0.0 2.8962611607142855e-05 0.0 2.8963169642857142e-05 1.5 2.8965401785714282e-05 1.5 2.896595982142857e-05 0.0 2.8980468749999998e-05 0.0 2.8981026785714284e-05 1.5 2.8983258928571428e-05 1.5 2.898381696428571e-05 0.0 2.899832589285714e-05 0.0 2.8998883928571427e-05 1.5 2.900111607142857e-05 1.5 2.9001674107142854e-05 0.0 2.9016183035714282e-05 0.0 2.901674107142857e-05 1.5 2.9018973214285713e-05 1.5 2.901953125e-05 0.0 2.9034040178571428e-05 0.0 2.903459821428571e-05 1.5 2.9036830357142855e-05 1.5 2.9037388392857142e-05 0.0 2.905189732142857e-05 0.0 2.9052455357142854e-05 1.5 2.9054687499999997e-05 1.5 2.9055245535714284e-05 0.0 2.9069754464285713e-05 0.0 2.90703125e-05 1.5 2.907254464285714e-05 1.5 2.9073102678571426e-05 0.0 2.9087611607142855e-05 0.0 2.908816964285714e-05 1.5 2.9090401785714285e-05 1.5 2.909095982142857e-05 0.0 2.9105468749999997e-05 0.0 2.9106026785714284e-05 1.5 2.9108258928571428e-05 1.5 2.910881696428571e-05 0.0 2.912332589285714e-05 0.0 2.9123883928571426e-05 1.5 2.912611607142857e-05 1.5 2.9126674107142857e-05 0.0 2.9141183035714285e-05 0.0 2.914174107142857e-05 1.5 2.9143973214285712e-05 1.5 2.914453125e-05 0.0 2.9159040178571428e-05 0.0 2.915959821428571e-05 1.5 2.9161830357142855e-05 1.5 2.916238839285714e-05 0.0 2.9177455357142857e-05 0.0 2.917801339285714e-05 1.5 2.9179129464285714e-05 1.5 2.9179687499999997e-05 0.0 2.91953125e-05 0.0 2.9195870535714282e-05 1.5 2.9196986607142856e-05 1.5 2.919754464285714e-05 0.0 2.921316964285714e-05 0.0 2.9213727678571428e-05 1.5 2.9214843749999998e-05 1.5 2.9215401785714285e-05 0.0 2.9231026785714284e-05 0.0 2.923158482142857e-05 1.5 2.923270089285714e-05 1.5 2.9233258928571427e-05 0.0 2.9248883928571426e-05 0.0 2.9249441964285713e-05 1.5 2.9250558035714283e-05 1.5 2.925111607142857e-05 0.0 2.9266741071428568e-05 0.0 2.9267299107142855e-05 1.5 2.9268415178571425e-05 1.5 2.9268973214285712e-05 0.0 2.928459821428571e-05 0.0 2.9285156249999997e-05 1.5 2.928627232142857e-05 1.5 2.9286830357142854e-05 0.0 2.9302455357142856e-05 0.0 2.930301339285714e-05 1.5 2.9304129464285713e-05 1.5 2.9304687499999997e-05 0.0 2.93203125e-05 0.0 2.9320870535714282e-05 1.5 2.9321986607142856e-05 1.5 2.9322544642857142e-05 0.0 2.933816964285714e-05 0.0 2.9338727678571428e-05 1.5 2.9339843749999998e-05 1.5 2.9340401785714285e-05 0.0 2.9356026785714283e-05 0.0 2.935658482142857e-05 1.5 2.935770089285714e-05 1.5 2.9358258928571427e-05 0.0 2.9373883928571426e-05 0.0 2.9374441964285712e-05 1.5 2.9375558035714282e-05 1.5 2.937611607142857e-05 0.0 2.9391741071428568e-05 0.0 2.9392299107142855e-05 1.5 2.9393415178571425e-05 1.5 2.939397321428571e-05 0.0 2.9409598214285714e-05 0.0 2.9410156249999997e-05 1.5 2.941127232142857e-05 1.5 2.9411830357142854e-05 0.0 2.9427455357142856e-05 0.0 2.942801339285714e-05 1.5 2.9429129464285713e-05 1.5 2.9429687499999996e-05 0.0 2.9445312499999998e-05 0.0 2.9445870535714285e-05 1.5 2.9446986607142855e-05 1.5 2.9447544642857142e-05 0.0 2.9463727678571427e-05 0.0 2.946428571428571e-05 1.5 2.946428571428571e-05 1.5 2.9464843749999997e-05 0.0 2.948158482142857e-05 0.0 2.9482142857142856e-05 1.5 2.9482142857142856e-05 1.5 2.948270089285714e-05 0.0 2.9499441964285712e-05 0.0 2.95e-05 1.5 2.95e-05 1.5 2.9500558035714282e-05 0.0 2.9517299107142854e-05 0.0 2.951785714285714e-05 1.5 2.951785714285714e-05 1.5 2.9518415178571428e-05 0.0 2.9535156249999997e-05 0.0 2.9535714285714283e-05 1.5 2.9535714285714283e-05 1.5 2.953627232142857e-05 0.0 2.9553013392857142e-05 0.0 2.9553571428571426e-05 1.5 2.9553571428571426e-05 1.5 2.9554129464285712e-05 0.0 2.9570870535714285e-05 0.0 2.9571428571428568e-05 1.5 2.9571428571428568e-05 1.5 2.9571986607142855e-05 0.0 2.9588727678571427e-05 0.0 2.9589285714285714e-05 1.5 2.9589285714285714e-05 1.5 2.9589843749999997e-05 0.0 2.960658482142857e-05 0.0 2.9607142857142856e-05 1.5 2.9607142857142856e-05 1.5 2.960770089285714e-05 0.0 2.962444196428571e-05 0.0 2.9625e-05 1.5 2.9625e-05 1.5 2.9625558035714285e-05 0.0 2.9642299107142854e-05 0.0 2.964285714285714e-05 1.5 2.964285714285714e-05 1.5 2.9643415178571428e-05 0.0 2.9660156249999996e-05 0.0 2.9660714285714283e-05 1.5 2.9660714285714283e-05 1.5 2.966127232142857e-05 0.0 2.9678013392857142e-05 0.0 2.9678571428571425e-05 1.5 2.9678571428571425e-05 1.5 2.9679129464285712e-05 0.0 2.9695870535714284e-05 0.0 2.9696428571428568e-05 1.5 2.9696428571428568e-05 1.5 2.9696986607142854e-05 0.0 2.9713727678571427e-05 0.0 2.9714285714285713e-05 1.5 2.9714285714285713e-05 1.5 2.9714843749999997e-05 0.0 2.973158482142857e-05 0.0 2.9732142857142856e-05 1.5 2.9732142857142856e-05 1.5 2.973270089285714e-05 0.0 2.974944196428571e-05 0.0 2.9749999999999998e-05 1.5 2.9749999999999998e-05 1.5 2.9750558035714285e-05 0.0 2.9767299107142854e-05 0.0 2.976785714285714e-05 1.5 2.976785714285714e-05 1.5 2.9768415178571427e-05 0.0 2.978515625e-05 0.0 2.9785714285714283e-05 1.5 2.9785714285714283e-05 1.5 2.978627232142857e-05 0.0 2.980301339285714e-05 0.0 2.9803571428571425e-05 1.5 2.9803571428571425e-05 1.5 2.9804129464285712e-05 0.0 2.9820870535714284e-05 0.0 2.982142857142857e-05 1.5 2.982142857142857e-05 1.5 2.9821986607142854e-05 0.0 2.9838727678571426e-05 0.0 2.9839285714285713e-05 1.5 2.9839285714285713e-05 1.5 2.9839843749999996e-05 0.0 2.985658482142857e-05 0.0 2.9857142857142855e-05 1.5 2.9857142857142855e-05 1.5 2.9857700892857142e-05 0.0 2.987444196428571e-05 0.0 2.9874999999999998e-05 1.5 2.9874999999999998e-05 1.5 2.9875558035714284e-05 0.0 2.9892299107142857e-05 0.0 2.989285714285714e-05 1.5 2.989285714285714e-05 1.5 2.9893415178571427e-05 0.0 2.991015625e-05 0.0 2.9910714285714282e-05 1.5 2.9910714285714282e-05 1.5 2.991127232142857e-05 0.0 2.992801339285714e-05 0.0 2.9928571428571428e-05 1.5 2.9928571428571428e-05 1.5 2.992912946428571e-05 0.0 2.9945870535714284e-05 0.0 2.994642857142857e-05 1.5 2.994642857142857e-05 1.5 2.9946986607142854e-05 0.0 2.9963727678571426e-05 0.0 2.9964285714285713e-05 1.5 2.9964285714285713e-05 1.5 2.996484375e-05 0.0 2.9981584821428568e-05 0.0 2.9982142857142855e-05 1.5 2.9982142857142855e-05 1.5 2.9982700892857142e-05 0.0 2.999944196428571e-05 0.0 2.9999999999999997e-05 1.5 2.9999999999999997e-05 1.5 3.0000558035714284e-05 0.0 3.0017299107142856e-05 0.0 3.001785714285714e-05 1.5 3.001785714285714e-05 1.5 3.0018415178571426e-05 0.0 3.003515625e-05 0.0 3.0035714285714282e-05 1.5 3.0035714285714282e-05 1.5 3.003627232142857e-05 0.0 3.005301339285714e-05 0.0 3.0053571428571428e-05 1.5 3.0053571428571428e-05 1.5 3.005412946428571e-05 0.0 3.0070870535714283e-05 0.0 3.007142857142857e-05 1.5 3.007142857142857e-05 1.5 3.0071986607142853e-05 0.0 3.0088727678571426e-05 0.0 3.0089285714285712e-05 1.5 3.0089285714285712e-05 1.5 3.008984375e-05 0.0 3.0106584821428568e-05 0.0 3.0107142857142855e-05 1.5 3.0107142857142855e-05 1.5 3.010770089285714e-05 0.0 3.0124441964285714e-05 0.0 3.0124999999999997e-05 1.5 3.0124999999999997e-05 1.5 3.0125558035714284e-05 0.0 3.0142299107142856e-05 0.0 3.014285714285714e-05 1.5 3.014285714285714e-05 1.5 3.0143415178571426e-05 0.0 3.0160156249999998e-05 0.0 3.0160714285714285e-05 1.5 3.0160714285714285e-05 1.5 3.016127232142857e-05 0.0 3.017801339285714e-05 0.0 3.0178571428571427e-05 1.5 3.0178571428571427e-05 1.5 3.017912946428571e-05 0.0 3.0195870535714283e-05 0.0 3.019642857142857e-05 1.5 3.019642857142857e-05 1.5 3.0196986607142856e-05 0.0 3.0213727678571425e-05 0.0 3.0214285714285712e-05 1.5 3.0214285714285712e-05 1.5 3.021484375e-05 0.0 3.0231584821428568e-05 0.0 3.0232142857142854e-05 1.5 3.0232142857142854e-05 1.5 3.023270089285714e-05 0.0 3.0249441964285713e-05 0.0 3.0249999999999997e-05 1.5 3.0249999999999997e-05 1.5 3.0250558035714283e-05 0.0 3.0267299107142856e-05 0.0 3.026785714285714e-05 1.5 3.026785714285714e-05 1.5 3.0268415178571426e-05 0.0 3.0285156249999998e-05 0.0 3.0285714285714285e-05 1.5 3.0285714285714285e-05 1.5 3.0286272321428568e-05 0.0 3.030301339285714e-05 0.0 3.0303571428571427e-05 1.5 3.0303571428571427e-05 1.5 3.0304129464285714e-05 0.0 3.0320870535714283e-05 0.0 3.032142857142857e-05 1.5 3.032142857142857e-05 1.5 3.0321986607142856e-05 0.0 3.0338727678571425e-05 0.0 3.033928571428571e-05 1.5 3.033928571428571e-05 1.5 3.033984375e-05 0.0 3.035658482142857e-05 0.0 3.0357142857142854e-05 1.5 3.0357142857142854e-05 1.5 3.035770089285714e-05 0.0 3.0374441964285713e-05 0.0 3.0374999999999996e-05 1.5 3.0374999999999996e-05 1.5 3.0375558035714283e-05 0.0 3.0392299107142855e-05 0.0 3.0392857142857142e-05 1.5 3.0392857142857142e-05 1.5 3.0393415178571425e-05 0.0 3.0410156249999998e-05 0.0 3.0410714285714284e-05 1.5 3.0410714285714284e-05 1.5 3.0411272321428568e-05 0.0 3.042801339285714e-05 0.0 3.0428571428571427e-05 1.5 3.0428571428571427e-05 1.5 3.0429129464285713e-05 0.0 3.0445870535714282e-05 0.0 3.044642857142857e-05 1.5 3.044642857142857e-05 1.5 3.0446986607142856e-05 0.0 3.0463727678571428e-05 0.0 3.046428571428571e-05 1.5 3.046428571428571e-05 1.5 3.0464843749999998e-05 0.0 3.048158482142857e-05 0.0 3.0482142857142854e-05 1.5 3.0482142857142854e-05 1.5 3.048270089285714e-05 0.0 3.0499441964285713e-05 0.0 3.05e-05 1.5 3.05e-05 1.5 3.0500558035714283e-05 0.0 3.0517299107142855e-05 0.0 3.051785714285714e-05 1.5 3.051785714285714e-05 1.5 3.051841517857143e-05 0.0 3.053515625e-05 0.0 3.053571428571428e-05 1.5 3.053571428571428e-05 1.5 3.053627232142857e-05 0.0 3.055301339285714e-05 0.0 3.055357142857143e-05 1.5 3.055357142857143e-05 1.5 3.055412946428571e-05 0.0 3.057087053571428e-05 0.0 3.057142857142857e-05 1.5 3.057142857142857e-05 1.5 3.0571986607142855e-05 0.0 3.0588727678571424e-05 0.0 3.0589285714285714e-05 1.5 3.0589285714285714e-05 1.5 3.058984375e-05 0.0 3.0606584821428567e-05 0.0 3.060714285714286e-05 1.5 3.060714285714286e-05 1.5 3.060770089285714e-05 0.0 3.062444196428571e-05 0.0 3.0625e-05 1.5 3.0625e-05 1.5 3.062555803571428e-05 0.0 3.064229910714286e-05 0.0 3.064285714285714e-05 1.5 3.064285714285714e-05 1.5 3.0643415178571425e-05 0.0 3.066015625e-05 0.0 3.0660714285714284e-05 1.5 3.0660714285714284e-05 1.5 3.066127232142857e-05 0.0 3.067801339285714e-05 0.0 3.0678571428571426e-05 1.5 3.0678571428571426e-05 1.5 3.067912946428571e-05 0.0 3.0695870535714285e-05 0.0 3.069642857142857e-05 1.5 3.069642857142857e-05 1.5 3.069698660714285e-05 0.0 3.071372767857143e-05 0.0 3.071428571428571e-05 1.5 3.071428571428571e-05 1.5 3.071484375e-05 0.0 3.073158482142857e-05 0.0 3.073214285714285e-05 1.5 3.073214285714285e-05 1.5 3.073270089285714e-05 0.0 3.074888392857143e-05 0.0 3.074944196428571e-05 1.5 3.0750558035714285e-05 1.5 3.075111607142857e-05 0.0 3.076674107142857e-05 0.0 3.0767299107142854e-05 1.5 3.076841517857143e-05 1.5 3.076897321428571e-05 0.0 3.078459821428571e-05 0.0 3.0785156249999997e-05 1.5 3.078627232142857e-05 1.5 3.0786830357142853e-05 0.0 3.0802455357142856e-05 0.0 3.080301339285714e-05 1.5 3.080412946428571e-05 1.5 3.0804687499999996e-05 0.0 3.08203125e-05 0.0 3.082087053571428e-05 1.5 3.0821986607142855e-05 1.5 3.082254464285714e-05 0.0 3.083816964285714e-05 0.0 3.0838727678571424e-05 1.5 3.083984375e-05 1.5 3.084040178571428e-05 0.0 3.085602678571428e-05 0.0 3.0856584821428566e-05 1.5 3.085770089285714e-05 1.5 3.085825892857143e-05 0.0 3.0873883928571425e-05 0.0 3.0874441964285715e-05 1.5 3.087555803571428e-05 1.5 3.087611607142857e-05 0.0 3.089174107142857e-05 0.0 3.089229910714286e-05 1.5 3.0893415178571424e-05 1.5 3.0893973214285714e-05 0.0 3.090959821428571e-05 0.0 3.091015625e-05 1.5 3.0911272321428566e-05 1.5 3.0911830357142856e-05 0.0 3.092745535714285e-05 0.0 3.092801339285714e-05 1.5 3.0929129464285715e-05 1.5 3.09296875e-05 0.0 3.09453125e-05 0.0 3.0945870535714284e-05 1.5 3.094698660714286e-05 1.5 3.094754464285714e-05 0.0 3.096316964285714e-05 0.0 3.0963727678571427e-05 1.5 3.096484375e-05 1.5 3.0965401785714283e-05 0.0 3.0981026785714286e-05 0.0 3.098158482142857e-05 1.5 3.098270089285714e-05 1.5 3.0983258928571426e-05 0.0 3.099888392857143e-05 0.0 3.099944196428571e-05 1.5 3.1000558035714285e-05 1.5 3.100111607142857e-05 0.0 3.101674107142857e-05 0.0 3.1017299107142854e-05 1.5 3.101841517857143e-05 1.5 3.101897321428571e-05 0.0 3.103404017857143e-05 0.0 3.103459821428571e-05 1.5 3.103683035714285e-05 1.5 3.103738839285714e-05 0.0 3.105189732142857e-05 0.0 3.1052455357142855e-05 1.5 3.1054687499999995e-05 1.5 3.1055245535714285e-05 0.0 3.1069754464285714e-05 0.0 3.10703125e-05 1.5 3.107254464285714e-05 1.5 3.107310267857143e-05 0.0 3.1087611607142856e-05 0.0 3.108816964285714e-05 1.5 3.1090401785714286e-05 1.5 3.109095982142857e-05 0.0 3.110546875e-05 0.0 3.110602678571428e-05 1.5 3.110825892857143e-05 1.5 3.110881696428571e-05 0.0 3.112332589285714e-05 0.0 3.1123883928571424e-05 1.5 3.112611607142857e-05 1.5 3.1126674107142854e-05 0.0 3.114118303571428e-05 0.0 3.1141741071428566e-05 1.5 3.1143973214285713e-05 1.5 3.114453125e-05 0.0 3.1159040178571425e-05 0.0 3.115959821428571e-05 1.5 3.1161830357142856e-05 1.5 3.116238839285714e-05 0.0 3.117689732142857e-05 0.0 3.117745535714286e-05 1.5 3.11796875e-05 1.5 3.118024553571428e-05 0.0 3.119475446428571e-05 0.0 3.11953125e-05 1.5 3.119754464285714e-05 1.5 3.1198102678571424e-05 0.0 3.121261160714285e-05 0.0 3.121316964285714e-05 1.5 3.121540178571428e-05 1.5 3.1215959821428566e-05 0.0 3.1230468749999995e-05 0.0 3.1231026785714285e-05 1.5 3.1233258928571425e-05 1.5 3.1233816964285715e-05 0.0 3.1247767857142854e-05 0.0 3.1248325892857144e-05 1.5 3.125167410714286e-05 1.5 3.125223214285714e-05 0.0 3.1265624999999996e-05 0.0 3.1266183035714286e-05 1.5 3.126953125e-05 1.5 3.127008928571428e-05 0.0 3.128348214285714e-05 0.0 3.128404017857143e-05 1.5 3.128738839285714e-05 1.5 3.1287946428571426e-05 0.0 3.130133928571428e-05 0.0 3.130189732142857e-05 1.5 3.1305245535714285e-05 1.5 3.130580357142857e-05 0.0 3.131919642857143e-05 0.0 3.131975446428571e-05 1.5 3.132310267857143e-05 1.5 3.132366071428571e-05 0.0 3.133705357142857e-05 0.0 3.1337611607142855e-05 1.5 3.134095982142857e-05 1.5 3.134151785714285e-05 0.0 3.1354910714285714e-05 0.0 3.135546875e-05 1.5 3.135881696428571e-05 1.5 3.1359374999999995e-05 0.0 3.137276785714286e-05 0.0 3.137332589285714e-05 1.5 3.1376674107142854e-05 1.5 3.1377232142857144e-05 0.0 3.1390625e-05 0.0 3.139118303571428e-05 1.5 3.1394531249999996e-05 1.5 3.1395089285714286e-05 0.0 3.140848214285714e-05 0.0 3.1409040178571425e-05 1.5 3.141238839285714e-05 1.5 3.141294642857143e-05 0.0 3.1426339285714284e-05 0.0 3.142689732142857e-05 1.5 3.143024553571428e-05 1.5 3.143080357142857e-05 0.0 3.144363839285714e-05 0.0 3.1444196428571426e-05 1.5 3.144866071428571e-05 1.5 3.1449218749999997e-05 0.0 3.1461495535714285e-05 0.0 3.146205357142857e-05 1.5 3.1466517857142856e-05 1.5 3.146707589285714e-05 0.0 3.147935267857143e-05 0.0 3.147991071428571e-05 1.5 3.1484375e-05 1.5 3.148493303571428e-05 0.0 3.149720982142857e-05 0.0 3.149776785714285e-05 1.5 3.150223214285714e-05 1.5 3.1502790178571424e-05 0.0 3.151506696428571e-05 0.0 3.1515624999999995e-05 1.5 3.152008928571428e-05 1.5 3.1520647321428566e-05 0.0 3.1532924107142854e-05 0.0 3.153348214285714e-05 1.5 3.1537946428571425e-05 1.5 3.1538504464285715e-05 0.0 3.1550781249999997e-05 0.0 3.155133928571429e-05 1.5 3.155580357142857e-05 1.5 3.155636160714286e-05 0.0 3.156863839285714e-05 0.0 3.156919642857143e-05 1.5 3.157366071428571e-05 1.5 3.157421875e-05 0.0 3.158649553571428e-05 0.0 3.158705357142857e-05 1.5 3.159151785714285e-05 1.5 3.159207589285714e-05 0.0 3.1604352678571423e-05 0.0 3.1604910714285714e-05 1.5 3.1609375e-05 1.5 3.1609933035714284e-05 0.0 3.162165178571428e-05 0.0 3.1622209821428566e-05 1.5 3.1627790178571427e-05 1.5 3.162834821428571e-05 0.0 3.1639508928571425e-05 0.0 3.1640066964285715e-05 1.5 3.164564732142857e-05 1.5 3.164620535714285e-05 0.0 3.165736607142857e-05 0.0 3.165792410714286e-05 1.5 3.166350446428571e-05 1.5 3.1664062499999995e-05 0.0 3.167522321428571e-05 0.0 3.167578125e-05 1.5 3.1681361607142854e-05 1.5 3.1681919642857144e-05 0.0 3.169308035714285e-05 0.0 3.169363839285714e-05 1.5 3.1699218749999996e-05 1.5 3.1699776785714286e-05 0.0 3.17109375e-05 0.0 3.1711495535714284e-05 1.5 3.171707589285714e-05 1.5 3.171763392857143e-05 0.0 3.172879464285714e-05 0.0 3.1729352678571427e-05 1.5 3.173493303571428e-05 1.5 3.173549107142857e-05 0.0 3.1746651785714285e-05 0.0 3.174720982142857e-05 1.5 3.175279017857143e-05 1.5 3.175334821428571e-05 0.0 3.176450892857143e-05 0.0 3.176506696428571e-05 1.5 3.177064732142857e-05 1.5 3.1771205357142855e-05 0.0 3.178180803571429e-05 0.0 3.178236607142857e-05 1.5 3.17890625e-05 1.5 3.178962053571428e-05 0.0 3.179966517857143e-05 0.0 3.180022321428571e-05 1.5 3.180691964285714e-05 1.5 3.180747767857142e-05 0.0 3.181752232142857e-05 0.0 3.1818080357142855e-05 1.5 3.182477678571428e-05 1.5 3.182533482142857e-05 0.0 3.1835379464285714e-05 0.0 3.18359375e-05 1.5 3.1842633928571425e-05 1.5 3.1843191964285715e-05 0.0 3.1853236607142856e-05 0.0 3.185379464285714e-05 1.5 3.186049107142857e-05 1.5 3.186104910714286e-05 0.0 3.187109375e-05 0.0 3.187165178571428e-05 1.5 3.187834821428571e-05 1.5 3.187890625e-05 0.0 3.188895089285714e-05 0.0 3.1889508928571424e-05 1.5 3.189620535714285e-05 1.5 3.189676339285714e-05 0.0 3.190680803571428e-05 0.0 3.1907366071428566e-05 1.5 3.19140625e-05 1.5 3.1914620535714284e-05 0.0 3.1924665178571425e-05 0.0 3.192522321428571e-05 1.5 3.193191964285714e-05 1.5 3.1932477678571426e-05 0.0 3.194252232142857e-05 0.0 3.194308035714286e-05 1.5 3.195033482142857e-05 1.5 3.195089285714285e-05 0.0 3.195982142857143e-05 0.0 3.196037946428571e-05 1.5 3.196819196428571e-05 1.5 3.1968749999999994e-05 0.0 3.197767857142857e-05 0.0 3.197823660714285e-05 1.5 3.198604910714285e-05 1.5 3.1986607142857144e-05 0.0 3.199553571428571e-05 0.0 3.1996093749999995e-05 1.5 3.2003906249999996e-05 1.5 3.2004464285714286e-05 0.0 3.2013392857142854e-05 0.0 3.2013950892857144e-05 1.5 3.202176339285714e-05 1.5 3.202232142857143e-05 0.0 3.2031249999999996e-05 0.0 3.2031808035714286e-05 1.5 3.203962053571428e-05 1.5 3.204017857142857e-05 0.0 3.204910714285714e-05 0.0 3.204966517857143e-05 1.5 3.205747767857143e-05 1.5 3.205803571428571e-05 0.0 3.206696428571428e-05 0.0 3.206752232142857e-05 1.5 3.207533482142857e-05 1.5 3.2075892857142855e-05 0.0 3.208482142857142e-05 0.0 3.208537946428571e-05 1.5 3.2093191964285714e-05 1.5 3.209375e-05 0.0 )"
}
