C {devices/vsource.sym} 1400 -1610 0 0 {name=vpwm_sine_75 hide_texts=true value="dc 0 pwl(0.0 1.5 4.464285714285714e-09 1.5 5.022321428571428e-09 0.0 1.2834821428571427e-08 0.0 1.3392857142857143e-08 1.5 2.232142857142857e-08 1.5 2.2879464285714283e-08 0.0 3.069196428571428e-08 0.0 3.125e-08 1.5 4.0178571428571425e-08 1.5 4.073660714285714e-08 0.0 4.854910714285714e-08 0.0 4.910714285714285e-08 1.5 5.8035714285714284e-08 1.5 5.8593749999999995e-08 0.0 6.640625e-08 0.0 6.696428571428571e-08 1.5 7.589285714285714e-08 1.5 7.645089285714285e-08 0.0 8.426339285714285e-08 0.0 8.482142857142856e-08 1.5 9.374999999999999e-08 1.5 9.430803571428571e-08 0.0 1.021205357142857e-07 0.0 1.0267857142857142e-07 1.5 1.1160714285714285e-07 1.5 1.1216517857142857e-07 0.0 1.1997767857142856e-07 0.0 1.2053571428571428e-07 1.5 1.294642857142857e-07 1.5 1.3002232142857143e-07 0.0 1.378348214285714e-07 0.0 1.3839285714285713e-07 1.5 1.4732142857142856e-07 1.5 1.4787946428571428e-07 0.0 1.5569196428571426e-07 0.0 1.5624999999999999e-07 1.5 1.651785714285714e-07 1.5 1.6573660714285714e-07 0.0 1.7354910714285714e-07 0.0 1.7410714285714284e-07 1.5 1.8303571428571427e-07 1.5 1.8359375e-07 0.0 1.9140625e-07 0.0 1.919642857142857e-07 1.5 2.0089285714285712e-07 1.5 2.0145089285714284e-07 0.0 2.0926339285714285e-07 0.0 2.0982142857142854e-07 1.5 2.193080357142857e-07 1.5 2.1986607142857142e-07 0.0 2.2656249999999997e-07 0.0 2.271205357142857e-07 1.5 2.3716517857142855e-07 1.5 2.3772321428571427e-07 0.0 2.4441964285714285e-07 0.0 2.4497767857142855e-07 1.5 2.550223214285714e-07 1.5 2.555803571428571e-07 0.0 2.622767857142857e-07 0.0 2.628348214285714e-07 1.5 2.728794642857143e-07 1.5 2.734375e-07 0.0 2.8013392857142856e-07 0.0 2.8069196428571426e-07 1.5 2.9073660714285713e-07 1.5 2.9129464285714283e-07 0.0 2.979910714285714e-07 0.0 2.985491071428571e-07 1.5 3.0859375e-07 1.5 3.091517857142857e-07 0.0 3.1584821428571426e-07 0.0 3.1640624999999996e-07 1.5 3.2645089285714284e-07 1.5 3.2700892857142853e-07 0.0 3.337053571428571e-07 0.0 3.342633928571428e-07 1.5 3.443080357142857e-07 1.5 3.448660714285714e-07 0.0 3.5156249999999997e-07 0.0 3.5212053571428567e-07 1.5 3.6216517857142854e-07 1.5 3.6272321428571424e-07 0.0 3.694196428571428e-07 0.0 3.699776785714285e-07 1.5 3.800223214285714e-07 1.5 3.805803571428571e-07 0.0 3.872767857142857e-07 0.0 3.878348214285714e-07 1.5 3.9787946428571425e-07 1.5 3.984375e-07 0.0 4.0513392857142853e-07 0.0 4.056919642857143e-07 1.5 4.157366071428571e-07 1.5 4.1629464285714285e-07 0.0 4.229910714285714e-07 0.0 4.2354910714285713e-07 1.5 4.341517857142857e-07 1.5 4.347098214285714e-07 0.0 4.4029017857142853e-07 0.0 4.4084821428571423e-07 1.5 4.5200892857142855e-07 1.5 4.5256696428571425e-07 0.0 4.581473214285714e-07 0.0 4.587053571428571e-07 1.5 4.698660714285714e-07 1.5 4.704241071428571e-07 0.0 4.7600446428571424e-07 0.0 4.765625e-07 1.5 4.877232142857142e-07 1.5 4.8828125e-07 0.0 4.938616071428571e-07 0.0 4.944196428571428e-07 1.5 5.055803571428571e-07 1.5 5.061383928571429e-07 0.0 5.117187499999999e-07 0.0 5.122767857142856e-07 1.5 5.234374999999999e-07 1.5 5.239955357142857e-07 0.0 5.295758928571428e-07 0.0 5.301339285714285e-07 1.5 5.412946428571429e-07 1.5 5.418526785714286e-07 0.0 5.474330357142856e-07 0.0 5.479910714285713e-07 1.5 5.591517857142857e-07 1.5 5.597098214285714e-07 0.0 5.652901785714285e-07 0.0 5.658482142857142e-07 1.5 5.770089285714286e-07 1.5 5.775669642857143e-07 0.0 5.831473214285714e-07 0.0 5.83705357142857e-07 1.5 5.948660714285714e-07 1.5 5.954241071428571e-07 0.0 6.010044642857142e-07 0.0 6.015624999999999e-07 1.5 6.127232142857143e-07 1.5 6.1328125e-07 0.0 6.188616071428571e-07 0.0 6.194196428571429e-07 1.5 6.305803571428571e-07 1.5 6.311383928571428e-07 0.0 6.367187499999999e-07 0.0 6.372767857142857e-07 1.5 6.484375e-07 1.5 6.489955357142857e-07 0.0 6.545758928571428e-07 0.0 6.551339285714286e-07 1.5 6.662946428571428e-07 1.5 6.668526785714285e-07 0.0 6.718749999999999e-07 0.0 6.724330357142856e-07 1.5 6.847098214285714e-07 1.5 6.852678571428571e-07 0.0 6.897321428571428e-07 0.0 6.902901785714285e-07 1.5 7.025669642857142e-07 1.5 7.031249999999999e-07 0.0 7.075892857142856e-07 0.0 7.081473214285714e-07 1.5 7.204241071428571e-07 1.5 7.209821428571428e-07 0.0 7.254464285714285e-07 0.0 7.260044642857143e-07 1.5 7.382812499999999e-07 1.5 7.388392857142856e-07 0.0 7.433035714285713e-07 0.0 7.438616071428571e-07 1.5 7.561383928571428e-07 1.5 7.566964285714285e-07 0.0 7.611607142857142e-07 0.0 7.6171875e-07 1.5 7.739955357142857e-07 1.5 7.745535714285713e-07 0.0 7.79017857142857e-07 0.0 7.795758928571428e-07 1.5 7.918526785714285e-07 1.5 7.924107142857142e-07 0.0 7.96875e-07 0.0 7.974330357142857e-07 1.5 8.097098214285714e-07 1.5 8.102678571428571e-07 0.0 8.147321428571428e-07 0.0 8.152901785714285e-07 1.5 8.275669642857142e-07 1.5 8.281249999999999e-07 0.0 8.325892857142857e-07 0.0 8.331473214285714e-07 1.5 8.454241071428571e-07 1.5 8.459821428571428e-07 0.0 8.504464285714286e-07 0.0 8.510044642857142e-07 1.5 8.632812499999999e-07 1.5 8.638392857142856e-07 0.0 8.683035714285714e-07 0.0 8.688616071428571e-07 1.5 8.811383928571428e-07 1.5 8.816964285714285e-07 0.0 8.861607142857143e-07 0.0 8.8671875e-07 1.5 8.989955357142856e-07 1.5 8.995535714285713e-07 0.0 9.040178571428571e-07 0.0 9.045758928571428e-07 1.5 9.168526785714285e-07 1.5 9.174107142857142e-07 0.0 9.21875e-07 0.0 9.224330357142857e-07 1.5 9.352678571428571e-07 1.5 9.358258928571428e-07 0.0 9.391741071428571e-07 0.0 9.397321428571428e-07 1.5 9.53125e-07 1.5 9.536830357142856e-07 0.0 9.5703125e-07 0.0 9.575892857142857e-07 1.5 9.709821428571428e-07 1.5 9.715401785714285e-07 0.0 9.748883928571427e-07 0.0 9.754464285714284e-07 1.5 9.888392857142856e-07 1.5 9.893973214285713e-07 0.0 9.927455357142857e-07 0.0 9.933035714285714e-07 1.5 1.0066964285714285e-06 1.5 1.0072544642857142e-06 0.0 1.0106026785714284e-06 0.0 1.0111607142857141e-06 1.5 1.0245535714285713e-06 1.5 1.025111607142857e-06 0.0 1.0284598214285714e-06 0.0 1.029017857142857e-06 1.5 1.0424107142857142e-06 1.5 1.04296875e-06 0.0 1.0463169642857141e-06 0.0 1.0468749999999998e-06 1.5 1.060267857142857e-06 1.5 1.0608258928571427e-06 0.0 1.064174107142857e-06 0.0 1.0647321428571428e-06 1.5 1.078125e-06 1.5 1.0786830357142856e-06 0.0 1.0820312499999998e-06 0.0 1.0825892857142857e-06 1.5 1.0959821428571427e-06 1.5 1.0965401785714284e-06 0.0 1.0998883928571428e-06 0.0 1.1004464285714285e-06 1.5 1.1138392857142857e-06 1.5 1.1143973214285714e-06 0.0 1.1177455357142855e-06 0.0 1.1183035714285714e-06 1.5 1.1316964285714284e-06 1.5 1.1322544642857143e-06 0.0 1.1356026785714285e-06 0.0 1.1361607142857142e-06 1.5 1.1495535714285714e-06 1.5 1.150111607142857e-06 0.0 1.1534598214285712e-06 0.0 1.1540178571428572e-06 1.5 1.167410714285714e-06 1.5 1.16796875e-06 0.0 1.1713169642857142e-06 0.0 1.171875e-06 1.5 1.185267857142857e-06 1.5 1.1858258928571428e-06 0.0 1.1891741071428572e-06 0.0 1.1897321428571429e-06 1.5 1.2031249999999998e-06 1.5 1.2036830357142857e-06 0.0 1.20703125e-06 0.0 1.2075892857142856e-06 1.5 1.2209821428571428e-06 1.5 1.2215401785714285e-06 0.0 1.2248883928571429e-06 0.0 1.2254464285714286e-06 1.5 1.2388392857142857e-06 1.5 1.2393973214285714e-06 0.0 1.2427455357142856e-06 0.0 1.2433035714285713e-06 1.5 1.2566964285714285e-06 1.5 1.2572544642857142e-06 0.0 1.2600446428571429e-06 0.0 1.2606026785714286e-06 1.5 1.2751116071428571e-06 1.5 1.2756696428571428e-06 0.0 1.2779017857142856e-06 0.0 1.2784598214285713e-06 1.5 1.2929687499999999e-06 1.5 1.2935267857142856e-06 0.0 1.2957589285714286e-06 0.0 1.2963169642857143e-06 1.5 1.3108258928571428e-06 1.5 1.3113839285714285e-06 0.0 1.3136160714285713e-06 0.0 1.314174107142857e-06 1.5 1.3286830357142856e-06 1.5 1.3292410714285713e-06 0.0 1.3314732142857143e-06 0.0 1.33203125e-06 1.5 1.3465401785714285e-06 1.5 1.3470982142857142e-06 0.0 1.349330357142857e-06 0.0 1.3498883928571427e-06 1.5 1.3643973214285713e-06 1.5 1.364955357142857e-06 0.0 1.3671875e-06 0.0 1.3677455357142857e-06 1.5 1.3822544642857142e-06 1.5 1.3828125e-06 0.0 1.3850446428571427e-06 0.0 1.3856026785714284e-06 1.5 1.400111607142857e-06 1.5 1.4006696428571427e-06 0.0 1.4029017857142857e-06 0.0 1.4034598214285714e-06 1.5 1.41796875e-06 1.5 1.4185267857142856e-06 0.0 1.4207589285714284e-06 0.0 1.4213169642857141e-06 1.5 1.4358258928571427e-06 1.5 1.4363839285714284e-06 0.0 1.4386160714285714e-06 0.0 1.439174107142857e-06 1.5 1.4536830357142857e-06 1.5 1.4542410714285714e-06 0.0 1.4564732142857141e-06 0.0 1.4570312499999998e-06 1.5 1.4715401785714284e-06 1.5 1.472098214285714e-06 0.0 1.474330357142857e-06 0.0 1.4748883928571428e-06 1.5 1.4893973214285714e-06 1.5 1.489955357142857e-06 0.0 1.4921874999999998e-06 0.0 1.4927455357142855e-06 1.5 1.5072544642857141e-06 1.5 1.5078124999999998e-06 0.0 1.5100446428571428e-06 0.0 1.5106026785714285e-06 1.5 1.525111607142857e-06 1.5 1.5256696428571428e-06 0.0 1.5279017857142856e-06 0.0 1.5284598214285713e-06 1.5 1.5429687499999998e-06 1.5 1.5435267857142855e-06 0.0 1.5457589285714285e-06 0.0 1.5463169642857142e-06 1.5 1.5608258928571428e-06 1.5 1.5613839285714285e-06 0.0 1.5636160714285713e-06 0.0 1.564174107142857e-06 1.5 1.5786830357142855e-06 1.5 1.5792410714285712e-06 0.0 1.5814732142857142e-06 0.0 1.58203125e-06 1.5 1.5965401785714285e-06 1.5 1.5970982142857142e-06 0.0 1.599330357142857e-06 0.0 1.5998883928571427e-06 1.5 1.6143973214285712e-06 1.5 1.6149553571428571e-06 0.0 1.6171875e-06 0.0 1.6177455357142856e-06 1.5 1.6322544642857142e-06 1.5 1.6328124999999999e-06 0.0 1.6350446428571427e-06 0.0 1.6356026785714284e-06 1.5 1.650111607142857e-06 1.5 1.6506696428571428e-06 0.0 1.6529017857142856e-06 0.0 1.6534598214285713e-06 1.5 1.6679687499999999e-06 1.5 1.6685267857142856e-06 0.0 1.6707589285714284e-06 0.0 1.671316964285714e-06 1.5 1.6858258928571426e-06 1.5 1.6863839285714285e-06 0.0 1.6886160714285713e-06 0.0 1.689174107142857e-06 1.5 1.7036830357142856e-06 1.5 1.7042410714285713e-06 0.0 1.706473214285714e-06 0.0 1.7070312499999998e-06 1.5 1.7215401785714285e-06 1.5 1.7220982142857142e-06 0.0 1.724330357142857e-06 0.0 1.7248883928571427e-06 1.5 1.7393973214285713e-06 1.5 1.739955357142857e-06 0.0 1.7421874999999998e-06 0.0 1.7427455357142857e-06 1.5 1.7572544642857143e-06 1.5 1.7578125e-06 0.0 1.7600446428571427e-06 0.0 1.7606026785714284e-06 1.5 1.775111607142857e-06 1.5 1.7756696428571427e-06 0.0 1.7779017857142855e-06 0.0 1.7784598214285714e-06 1.5 1.79296875e-06 1.5 1.7935267857142857e-06 0.0 1.7957589285714284e-06 0.0 1.7963169642857141e-06 1.5 1.8108258928571427e-06 1.5 1.8113839285714284e-06 0.0 1.8136160714285712e-06 0.0 1.814174107142857e-06 1.5 1.8286830357142857e-06 1.5 1.8292410714285714e-06 0.0 1.8314732142857142e-06 0.0 1.8320312499999999e-06 1.5 1.8465401785714284e-06 1.5 1.8470982142857141e-06 0.0 1.8493303571428571e-06 0.0 1.8498883928571428e-06 1.5 1.8643973214285714e-06 1.5 1.864955357142857e-06 0.0 1.8671874999999999e-06 0.0 1.8677455357142856e-06 1.5 1.8822544642857141e-06 1.5 1.8828124999999998e-06 0.0 1.8850446428571428e-06 0.0 1.8856026785714285e-06 1.5 1.900111607142857e-06 1.5 1.9006696428571428e-06 0.0 1.9029017857142856e-06 0.0 1.9034598214285713e-06 1.5 1.91796875e-06 1.5 1.9185267857142855e-06 0.0 1.9207589285714283e-06 0.0 1.9213169642857142e-06 1.5 1.9358258928571428e-06 1.5 1.9363839285714283e-06 0.0 1.9386160714285715e-06 0.0 1.939174107142857e-06 1.5 1.9536830357142855e-06 1.5 1.9542410714285714e-06 0.0 1.9564732142857142e-06 0.0 1.9570312499999997e-06 1.5 1.9715401785714283e-06 1.5 1.972098214285714e-06 0.0 1.974330357142857e-06 0.0 1.974888392857143e-06 1.5 1.9893973214285714e-06 1.5 1.989955357142857e-06 0.0 1.9921874999999997e-06 0.0 1.9927455357142856e-06 1.5 2.007254464285714e-06 1.5 2.0078124999999997e-06 0.0 2.010044642857143e-06 0.0 2.0106026785714284e-06 1.5 2.025111607142857e-06 1.5 2.025669642857143e-06 0.0 2.0279017857142856e-06 0.0 2.028459821428571e-06 1.5 2.0429687499999997e-06 1.5 2.0435267857142856e-06 0.0 2.0457589285714284e-06 0.0 2.0463169642857143e-06 1.5 2.060825892857143e-06 1.5 2.0613839285714283e-06 0.0 2.063616071428571e-06 0.0 2.064174107142857e-06 1.5 2.0786830357142856e-06 1.5 2.079241071428571e-06 0.0 2.0814732142857143e-06 0.0 2.0820312499999998e-06 1.5 2.0965401785714283e-06 1.5 2.0970982142857143e-06 0.0 2.099330357142857e-06 0.0 2.0998883928571425e-06 1.5 2.114397321428571e-06 1.5 2.114955357142857e-06 0.0 2.1171875e-06 0.0 2.1177455357142857e-06 1.5 2.1322544642857143e-06 1.5 2.1328124999999997e-06 0.0 2.1350446428571425e-06 0.0 2.1356026785714284e-06 1.5 2.150111607142857e-06 1.5 2.1506696428571425e-06 0.0 2.1529017857142857e-06 0.0 2.153459821428571e-06 1.5 2.1679687499999998e-06 1.5 2.1685267857142857e-06 0.0 2.1707589285714285e-06 0.0 2.171316964285714e-06 1.5 2.1858258928571425e-06 1.5 2.1863839285714284e-06 0.0 2.188616071428571e-06 0.0 2.189174107142857e-06 1.5 2.2036830357142857e-06 1.5 2.204241071428571e-06 0.0 2.206473214285714e-06 0.0 2.20703125e-06 1.5 2.2215401785714284e-06 1.5 2.2220982142857143e-06 0.0 2.224330357142857e-06 0.0 2.2248883928571426e-06 1.5 2.239397321428571e-06 1.5 2.239955357142857e-06 0.0 2.2421875e-06 0.0 2.2427455357142854e-06 1.5 2.257254464285714e-06 1.5 2.2578125e-06 0.0 2.2600446428571426e-06 0.0 2.2606026785714285e-06 1.5 2.275111607142857e-06 1.5 2.2756696428571426e-06 0.0 2.2779017857142854e-06 0.0 2.2784598214285713e-06 1.5 2.29296875e-06 1.5 2.2935267857142857e-06 0.0 2.2957589285714285e-06 0.0 2.296316964285714e-06 1.5 2.3108258928571426e-06 1.5 2.3113839285714285e-06 0.0 2.3136160714285713e-06 0.0 2.314174107142857e-06 1.5 2.3286830357142857e-06 1.5 2.3292410714285712e-06 0.0 2.331473214285714e-06 0.0 2.33203125e-06 1.5 2.3465401785714285e-06 1.5 2.347098214285714e-06 0.0 2.3493303571428568e-06 0.0 2.3498883928571427e-06 1.5 2.3643973214285712e-06 1.5 2.364955357142857e-06 0.0 2.3671875e-06 0.0 2.3677455357142854e-06 1.5 2.382254464285714e-06 1.5 2.3828125e-06 0.0 2.3850446428571427e-06 0.0 2.3856026785714286e-06 1.5 2.400111607142857e-06 1.5 2.4006696428571426e-06 0.0 2.4029017857142854e-06 0.0 2.4034598214285713e-06 1.5 2.41796875e-06 1.5 2.4185267857142854e-06 0.0 2.4207589285714286e-06 0.0 2.421316964285714e-06 1.5 2.4358258928571427e-06 1.5 2.4363839285714286e-06 0.0 2.4386160714285714e-06 0.0 2.439174107142857e-06 1.5 2.4536830357142854e-06 1.5 2.4542410714285713e-06 0.0 2.456473214285714e-06 0.0 2.45703125e-06 1.5 2.4715401785714286e-06 1.5 2.472098214285714e-06 0.0 2.474330357142857e-06 0.0 2.4748883928571428e-06 1.5 2.4893973214285713e-06 1.5 2.489955357142857e-06 0.0 2.4921875e-06 0.0 2.4927455357142855e-06 1.5 2.507254464285714e-06 1.5 2.5078125e-06 0.0 2.5100446428571428e-06 0.0 2.5106026785714282e-06 1.5 2.525111607142857e-06 1.5 2.5256696428571427e-06 0.0 2.5279017857142855e-06 0.0 2.5284598214285714e-06 1.5 2.54296875e-06 1.5 2.5435267857142855e-06 0.0 2.5457589285714283e-06 0.0 2.546316964285714e-06 1.5 2.5608258928571427e-06 1.5 2.561383928571428e-06 0.0 2.5636160714285714e-06 0.0 2.564174107142857e-06 1.5 2.5786830357142855e-06 1.5 2.5792410714285714e-06 0.0 2.581473214285714e-06 0.0 2.5820312499999997e-06 1.5 2.5965401785714282e-06 1.5 2.597098214285714e-06 0.0 2.599330357142857e-06 0.0 2.599888392857143e-06 1.5 2.6143973214285714e-06 1.5 2.614955357142857e-06 0.0 2.6171874999999997e-06 0.0 2.6177455357142856e-06 1.5 2.632254464285714e-06 1.5 2.6328124999999996e-06 0.0 2.635044642857143e-06 0.0 2.6356026785714283e-06 1.5 2.650111607142857e-06 1.5 2.650669642857143e-06 0.0 2.6529017857142856e-06 0.0 2.653459821428571e-06 1.5 2.6679687499999996e-06 1.5 2.6685267857142855e-06 0.0 2.6707589285714283e-06 0.0 2.6713169642857142e-06 1.5 2.685825892857143e-06 1.5 2.6863839285714283e-06 0.0 2.688616071428571e-06 0.0 2.689174107142857e-06 1.5 2.7036830357142855e-06 1.5 2.704241071428571e-06 0.0 2.7064732142857142e-06 0.0 2.7070312499999997e-06 1.5 2.7215401785714283e-06 1.5 2.722098214285714e-06 0.0 2.724330357142857e-06 0.0 2.7248883928571425e-06 1.5 2.739397321428571e-06 1.5 2.739955357142857e-06 0.0 2.7421874999999997e-06 0.0 2.7427455357142856e-06 1.5 2.7566964285714283e-06 1.5 2.757254464285714e-06 0.0 2.7606026785714284e-06 0.0 2.761160714285714e-06 1.5 2.774553571428571e-06 1.5 2.775111607142857e-06 0.0 2.778459821428571e-06 0.0 2.779017857142857e-06 1.5 2.7924107142857142e-06 1.5 2.7929687499999997e-06 0.0 2.796316964285714e-06 0.0 2.796875e-06 1.5 2.810267857142857e-06 1.5 2.8108258928571424e-06 0.0 2.814174107142857e-06 0.0 2.8147321428571425e-06 1.5 2.8281249999999997e-06 1.5 2.8286830357142856e-06 0.0 2.83203125e-06 0.0 2.8325892857142857e-06 1.5 2.8459821428571425e-06 1.5 2.8465401785714284e-06 0.0 2.8498883928571426e-06 0.0 2.8504464285714285e-06 1.5 2.8638392857142856e-06 1.5 2.864397321428571e-06 0.0 2.8677455357142853e-06 0.0 2.868303571428571e-06 1.5 2.8816964285714284e-06 1.5 2.8822544642857143e-06 0.0 2.8856026785714285e-06 0.0 2.886160714285714e-06 1.5 2.899553571428571e-06 1.5 2.900111607142857e-06 0.0 2.9034598214285712e-06 0.0 2.904017857142857e-06 1.5 2.917410714285714e-06 1.5 2.9179687499999998e-06 0.0 2.921316964285714e-06 0.0 2.921875e-06 1.5 2.935267857142857e-06 1.5 2.9358258928571425e-06 0.0 2.939174107142857e-06 0.0 2.9397321428571426e-06 1.5 2.9531249999999998e-06 1.5 2.9536830357142857e-06 0.0 2.95703125e-06 0.0 2.9575892857142854e-06 1.5 2.9709821428571425e-06 1.5 2.9715401785714284e-06 0.0 2.9748883928571426e-06 0.0 2.9754464285714285e-06 1.5 2.9888392857142857e-06 1.5 2.989397321428571e-06 0.0 2.9927455357142854e-06 0.0 2.9933035714285713e-06 1.5 3.0066964285714284e-06 1.5 3.007254464285714e-06 0.0 3.0106026785714285e-06 0.0 3.011160714285714e-06 1.5 3.024553571428571e-06 1.5 3.025111607142857e-06 0.0 3.0284598214285713e-06 0.0 3.0290178571428568e-06 1.5 3.042410714285714e-06 1.5 3.04296875e-06 0.0 3.046316964285714e-06 0.0 3.046875e-06 1.5 3.060267857142857e-06 1.5 3.0608258928571426e-06 0.0 3.0641741071428568e-06 0.0 3.0647321428571427e-06 1.5 3.078125e-06 1.5 3.0786830357142853e-06 0.0 3.0825892857142854e-06 0.0 3.0831473214285713e-06 1.5 3.095424107142857e-06 1.5 3.0959821428571426e-06 0.0 3.100446428571428e-06 0.0 3.101004464285714e-06 1.5 3.11328125e-06 1.5 3.1138392857142854e-06 0.0 3.1183035714285714e-06 0.0 3.118861607142857e-06 1.5 3.1311383928571426e-06 1.5 3.1316964285714285e-06 0.0 3.136160714285714e-06 0.0 3.1367187499999996e-06 1.5 3.1489955357142854e-06 1.5 3.1495535714285713e-06 0.0 3.154017857142857e-06 0.0 3.1545758928571428e-06 1.5 3.1668526785714285e-06 1.5 3.167410714285714e-06 0.0 3.1718749999999996e-06 0.0 3.1724330357142855e-06 1.5 3.1847098214285713e-06 1.5 3.1852678571428568e-06 0.0 3.1897321428571428e-06 0.0 3.1902901785714283e-06 1.5 3.202566964285714e-06 1.5 3.203125e-06 0.0 3.2075892857142855e-06 0.0 3.208147321428571e-06 1.5 3.2204241071428568e-06 1.5 3.2209821428571427e-06 0.0 3.2254464285714283e-06 0.0 3.226004464285714e-06 1.5 3.23828125e-06 1.5 3.2388392857142854e-06 0.0 3.243303571428571e-06 0.0 3.243861607142857e-06 1.5 3.2561383928571427e-06 1.5 3.256696428571428e-06 0.0 3.261160714285714e-06 0.0 3.2617187499999997e-06 1.5 3.2739955357142854e-06 1.5 3.2745535714285713e-06 0.0 3.279017857142857e-06 0.0 3.279575892857143e-06 1.5 3.291852678571428e-06 1.5 3.292410714285714e-06 0.0 3.2968749999999997e-06 0.0 3.2974330357142856e-06 1.5 3.3097098214285713e-06 1.5 3.310267857142857e-06 0.0 3.3147321428571424e-06 0.0 3.3152901785714283e-06 1.5 3.327566964285714e-06 1.5 3.3281249999999996e-06 0.0 3.3325892857142856e-06 0.0 3.333147321428571e-06 1.5 3.3448660714285714e-06 1.5 3.345424107142857e-06 0.0 3.3510044642857142e-06 0.0 3.3515624999999997e-06 1.5 3.362723214285714e-06 1.5 3.3632812499999996e-06 0.0 3.368861607142857e-06 0.0 3.3694196428571425e-06 1.5 3.380580357142857e-06 1.5 3.3811383928571428e-06 0.0 3.3867187499999997e-06 0.0 3.3872767857142856e-06 1.5 3.3984374999999996e-06 1.5 3.3989955357142855e-06 0.0 3.4045758928571425e-06 0.0 3.4051339285714284e-06 1.5 3.4162946428571428e-06 1.5 3.4168526785714283e-06 0.0 3.4224330357142857e-06 0.0 3.422991071428571e-06 1.5 3.4341517857142855e-06 1.5 3.434709821428571e-06 0.0 3.4402901785714284e-06 0.0 3.440848214285714e-06 1.5 3.4520089285714283e-06 1.5 3.452566964285714e-06 0.0 3.458147321428571e-06 0.0 3.458705357142857e-06 1.5 3.469866071428571e-06 1.5 3.470424107142857e-06 0.0 3.476004464285714e-06 0.0 3.4765625e-06 1.5 3.487723214285714e-06 1.5 3.4882812499999997e-06 0.0 3.493861607142857e-06 0.0 3.4944196428571425e-06 1.5 3.505580357142857e-06 1.5 3.5061383928571424e-06 0.0 3.51171875e-06 0.0 3.5122767857142853e-06 1.5 3.5234374999999997e-06 1.5 3.5239955357142856e-06 0.0 3.5295758928571426e-06 0.0 3.5301339285714285e-06 1.5 3.5412946428571424e-06 1.5 3.5418526785714283e-06 0.0 3.5474330357142853e-06 0.0 3.547991071428571e-06 1.5 3.5591517857142856e-06 1.5 3.559709821428571e-06 0.0 3.5652901785714285e-06 0.0 3.565848214285714e-06 1.5 3.5770089285714283e-06 1.5 3.577566964285714e-06 0.0 3.5837053571428567e-06 0.0 3.5842633928571426e-06 1.5 3.5943080357142856e-06 1.5 3.594866071428571e-06 0.0 3.6015625e-06 0.0 3.6021205357142854e-06 1.5 3.6121651785714283e-06 1.5 3.612723214285714e-06 0.0 3.6194196428571426e-06 0.0 3.619977678571428e-06 1.5 3.630022321428571e-06 1.5 3.630580357142857e-06 0.0 3.6372767857142854e-06 0.0 3.6378348214285713e-06 1.5 3.647879464285714e-06 1.5 3.6484374999999997e-06 0.0 3.655133928571428e-06 0.0 3.655691964285714e-06 1.5 3.665736607142857e-06 1.5 3.6662946428571425e-06 0.0 3.6729910714285713e-06 0.0 3.6735491071428568e-06 1.5 3.6835937499999998e-06 1.5 3.6841517857142857e-06 0.0 3.690848214285714e-06 0.0 3.69140625e-06 1.5 3.7014508928571425e-06 1.5 3.7020089285714284e-06 0.0 3.7087053571428568e-06 0.0 3.7092633928571427e-06 1.5 3.7193080357142852e-06 1.5 3.719866071428571e-06 0.0 3.7265624999999995e-06 0.0 3.7271205357142854e-06 1.5 3.7371651785714284e-06 1.5 3.737723214285714e-06 0.0 3.7444196428571427e-06 0.0 3.744977678571428e-06 1.5 3.755022321428571e-06 1.5 3.755580357142857e-06 0.0 3.7622767857142854e-06 0.0 3.7628348214285714e-06 1.5 3.772879464285714e-06 1.5 3.7734375e-06 0.0 3.780133928571428e-06 0.0 3.780691964285714e-06 1.5 3.790736607142857e-06 1.5 3.7912946428571426e-06 0.0 3.7979910714285714e-06 0.0 3.798549107142857e-06 1.5 3.808035714285714e-06 1.5 3.80859375e-06 0.0 3.81640625e-06 0.0 3.816964285714285e-06 1.5 3.825892857142857e-06 1.5 3.826450892857143e-06 0.0 3.834263392857142e-06 0.0 3.834821428571428e-06 1.5 3.843749999999999e-06 1.5 3.844308035714285e-06 0.0 3.8521205357142855e-06 0.0 3.852678571428571e-06 1.5 3.861607142857143e-06 1.5 3.8621651785714285e-06 0.0 3.869977678571429e-06 0.0 3.870535714285714e-06 1.5 3.879464285714286e-06 1.5 3.880022321428571e-06 0.0 3.887834821428571e-06 0.0 3.888392857142857e-06 1.5 3.897321428571428e-06 1.5 3.897879464285714e-06 0.0 3.905691964285714e-06 0.0 3.90625e-06 1.5 3.915178571428571e-06 1.5 3.915736607142857e-06 0.0 3.9235491071428565e-06 0.0 3.924107142857142e-06 1.5 3.933035714285714e-06 1.5 3.9335937499999995e-06 0.0 3.94140625e-06 0.0 3.9419642857142856e-06 1.5 3.950892857142857e-06 1.5 3.951450892857143e-06 0.0 3.959263392857143e-06 0.0 3.959821428571428e-06 1.5 3.96875e-06 1.5 3.969308035714286e-06 0.0 3.977120535714285e-06 0.0 3.977678571428571e-06 1.5 3.986607142857142e-06 1.5 3.987165178571428e-06 0.0 3.994977678571428e-06 0.0 3.995535714285714e-06 1.5 4.004464285714285e-06 1.5 4.005022321428571e-06 0.0 4.0133928571428566e-06 0.0 4.0139508928571425e-06 1.5 4.021763392857143e-06 1.5 4.0223214285714286e-06 0.0 4.03125e-06 0.0 4.031808035714286e-06 1.5 4.039620535714286e-06 1.5 4.040178571428571e-06 0.0 4.049107142857143e-06 0.0 4.049665178571428e-06 1.5 4.057477678571428e-06 1.5 4.058035714285714e-06 0.0 4.066964285714285e-06 0.0 4.067522321428571e-06 1.5 4.075334821428571e-06 1.5 4.075892857142857e-06 0.0 4.084821428571428e-06 0.0 4.085379464285714e-06 1.5 4.093191964285714e-06 1.5 4.0937499999999996e-06 0.0 4.102678571428571e-06 0.0 4.103236607142857e-06 1.5 4.111049107142857e-06 1.5 4.111607142857143e-06 0.0 4.120535714285714e-06 0.0 4.12109375e-06 1.5 4.12890625e-06 1.5 4.129464285714285e-06 0.0 4.138392857142857e-06 0.0 4.138950892857143e-06 1.5 4.146763392857142e-06 1.5 4.147321428571428e-06 0.0 4.156249999999999e-06 0.0 4.156808035714285e-06 1.5 4.1646205357142855e-06 1.5 4.165178571428571e-06 0.0 4.1741071428571426e-06 0.0 4.1746651785714285e-06 1.5 4.182477678571429e-06 1.5 4.183035714285714e-06 0.0 4.191964285714286e-06 0.0 4.192522321428571e-06 1.5 4.200334821428571e-06 1.5 4.200892857142857e-06 0.0 4.209821428571428e-06 0.0 4.210379464285714e-06 1.5 4.218191964285714e-06 1.5 4.21875e-06 0.0 4.228236607142857e-06 0.0 4.228794642857142e-06 1.5 4.235491071428571e-06 1.5 4.2360491071428565e-06 0.0 4.2460937499999994e-06 0.0 4.246651785714285e-06 1.5 4.253348214285714e-06 1.5 4.25390625e-06 0.0 4.263950892857143e-06 0.0 4.2645089285714285e-06 1.5 4.271205357142857e-06 1.5 4.271763392857143e-06 0.0 4.281808035714286e-06 0.0 4.282366071428571e-06 1.5 4.2890625e-06 1.5 4.289620535714285e-06 0.0 4.299665178571428e-06 0.0 4.300223214285714e-06 1.5 4.306919642857142e-06 1.5 4.307477678571428e-06 0.0 4.317522321428571e-06 0.0 4.318080357142857e-06 1.5 4.3247767857142856e-06 1.5 4.3253348214285715e-06 0.0 4.335379464285714e-06 0.0 4.3359374999999995e-06 1.5 4.342633928571428e-06 1.5 4.343191964285714e-06 0.0 4.353236607142857e-06 0.0 4.353794642857143e-06 1.5 4.360491071428571e-06 1.5 4.361049107142857e-06 0.0 4.37109375e-06 0.0 4.371651785714285e-06 1.5 4.378348214285714e-06 1.5 4.378906249999999e-06 0.0 4.388950892857142e-06 0.0 4.389508928571428e-06 1.5 4.3962053571428565e-06 1.5 4.3967633928571425e-06 0.0 4.4068080357142854e-06 0.0 4.407366071428571e-06 1.5 4.4140625e-06 1.5 4.414620535714286e-06 0.0 4.424665178571429e-06 0.0 4.425223214285714e-06 1.5 4.431919642857143e-06 1.5 4.432477678571428e-06 0.0 4.442522321428571e-06 0.0 4.443080357142857e-06 1.5 4.449218749999999e-06 1.5 4.449776785714285e-06 0.0 4.4609375e-06 0.0 4.461495535714285e-06 1.5 4.4670758928571425e-06 1.5 4.467633928571428e-06 0.0 4.478794642857142e-06 0.0 4.479352678571428e-06 1.5 4.484933035714286e-06 1.5 4.485491071428571e-06 0.0 4.4966517857142855e-06 0.0 4.497209821428571e-06 1.5 4.502790178571428e-06 1.5 4.503348214285714e-06 0.0 4.514508928571428e-06 0.0 4.515066964285714e-06 1.5 4.520647321428571e-06 1.5 4.521205357142857e-06 0.0 4.532366071428571e-06 0.0 4.532924107142857e-06 1.5 4.538504464285714e-06 1.5 4.539062499999999e-06 0.0 4.550223214285714e-06 0.0 4.55078125e-06 1.5 4.556361607142857e-06 1.5 4.5569196428571425e-06 0.0 4.5680803571428565e-06 0.0 4.568638392857142e-06 1.5 4.57421875e-06 1.5 4.574776785714286e-06 0.0 4.5859375e-06 0.0 4.5864955357142856e-06 1.5 4.592075892857142e-06 1.5 4.592633928571428e-06 0.0 4.603794642857143e-06 0.0 4.604352678571428e-06 1.5 4.609933035714285e-06 1.5 4.610491071428571e-06 0.0 4.621651785714285e-06 0.0 4.622209821428571e-06 1.5 4.6277901785714285e-06 1.5 4.628348214285714e-06 0.0 4.639508928571428e-06 0.0 4.640066964285714e-06 1.5 4.645647321428571e-06 1.5 4.646205357142857e-06 0.0 4.6573660714285715e-06 0.0 4.6579241071428566e-06 1.5 4.663504464285714e-06 1.5 4.6640625e-06 0.0 4.675223214285714e-06 0.0 4.67578125e-06 1.5 4.681361607142857e-06 1.5 4.681919642857142e-06 0.0 4.693638392857143e-06 0.0 4.694196428571428e-06 1.5 4.6986607142857135e-06 1.5 4.6992187499999995e-06 0.0 4.711495535714285e-06 0.0 4.712053571428571e-06 1.5 4.716517857142857e-06 1.5 4.717075892857143e-06 0.0 4.729352678571428e-06 0.0 4.729910714285714e-06 1.5 4.734375e-06 1.5 4.734933035714286e-06 0.0 4.747209821428571e-06 0.0 4.747767857142857e-06 1.5 4.752232142857142e-06 1.5 4.752790178571428e-06 0.0 4.765066964285714e-06 0.0 4.765625e-06 1.5 4.770089285714285e-06 1.5 4.770647321428571e-06 0.0 4.782924107142857e-06 0.0 4.783482142857142e-06 1.5 4.7879464285714285e-06 1.5 4.788504464285714e-06 0.0 4.800781249999999e-06 0.0 4.801339285714285e-06 1.5 4.805803571428571e-06 1.5 4.806361607142857e-06 0.0 4.8186383928571425e-06 0.0 4.8191964285714285e-06 1.5 4.823660714285714e-06 1.5 4.82421875e-06 0.0 4.836495535714286e-06 0.0 4.837053571428571e-06 1.5 4.841517857142857e-06 1.5 4.842075892857142e-06 0.0 4.854352678571428e-06 0.0 4.854910714285714e-06 1.5 4.8593749999999995e-06 1.5 4.8599330357142854e-06 0.0 4.872209821428571e-06 0.0 4.872767857142857e-06 1.5 4.877232142857143e-06 1.5 4.877790178571429e-06 0.0 4.8900669642857135e-06 0.0 4.8906249999999994e-06 1.5 4.895089285714285e-06 1.5 4.895647321428571e-06 0.0 4.907924107142857e-06 0.0 4.908482142857143e-06 1.5 4.912946428571428e-06 1.5 4.913504464285714e-06 0.0 4.92578125e-06 0.0 4.926339285714285e-06 1.5 4.930803571428571e-06 1.5 4.9313616071428564e-06 0.0 4.943638392857142e-06 0.0 4.944196428571428e-06 1.5 4.948102678571429e-06 1.5 4.948660714285714e-06 0.0 4.962053571428571e-06 0.0 4.962611607142857e-06 1.5 4.965959821428571e-06 1.5 4.966517857142857e-06 0.0 4.979910714285714e-06 0.0 4.9804687499999995e-06 1.5 4.983816964285714e-06 1.5 4.984375e-06 0.0 4.997767857142857e-06 0.0 4.998325892857143e-06 1.5 5.0016741071428564e-06 1.5 5.002232142857142e-06 0.0 5.015625e-06 0.0 5.016183035714285e-06 1.5 5.01953125e-06 1.5 5.0200892857142855e-06 0.0 5.033482142857142e-06 0.0 5.034040178571428e-06 1.5 5.037388392857143e-06 1.5 5.037946428571428e-06 0.0 5.0513392857142854e-06 0.0 5.051897321428571e-06 1.5 5.055245535714285e-06 1.5 5.055803571428571e-06 0.0 5.069196428571429e-06 0.0 5.069754464285714e-06 1.5 5.073102678571428e-06 1.5 5.073660714285714e-06 0.0 5.087053571428571e-06 0.0 5.087611607142857e-06 1.5 5.0909598214285714e-06 1.5 5.0915178571428565e-06 0.0 5.104910714285714e-06 0.0 5.10546875e-06 1.5 5.108816964285714e-06 1.5 5.109375e-06 0.0 5.122767857142856e-06 0.0 5.123325892857142e-06 1.5 5.126674107142857e-06 1.5 5.127232142857143e-06 0.0 5.140625e-06 0.0 5.1411830357142855e-06 1.5 5.144531249999999e-06 1.5 5.145089285714285e-06 0.0 5.158482142857143e-06 0.0 5.159040178571428e-06 1.5 5.1623883928571424e-06 1.5 5.162946428571428e-06 0.0 5.176339285714285e-06 0.0 5.176897321428571e-06 1.5 5.180245535714286e-06 1.5 5.180803571428571e-06 0.0 5.194196428571428e-06 0.0 5.194754464285714e-06 1.5 5.198102678571428e-06 1.5 5.198660714285714e-06 0.0 5.2120535714285714e-06 0.0 5.2126116071428565e-06 1.5 5.215959821428571e-06 1.5 5.216517857142857e-06 0.0 5.229910714285714e-06 0.0 5.23046875e-06 1.5 5.233816964285714e-06 1.5 5.234374999999999e-06 0.0 5.247767857142857e-06 0.0 5.248325892857143e-06 1.5 5.251674107142857e-06 1.5 5.2522321428571425e-06 0.0 5.265624999999999e-06 0.0 5.266183035714285e-06 1.5 5.26953125e-06 1.5 5.270089285714286e-06 0.0 5.284040178571428e-06 0.0 5.284598214285714e-06 1.5 5.286830357142857e-06 1.5 5.287388392857142e-06 0.0 5.301897321428571e-06 0.0 5.3024553571428566e-06 1.5 5.304687499999999e-06 1.5 5.305245535714285e-06 0.0 5.319754464285714e-06 0.0 5.3203125e-06 1.5 5.3225446428571425e-06 1.5 5.3231026785714284e-06 0.0 5.337611607142857e-06 0.0 5.338169642857143e-06 1.5 5.340401785714286e-06 1.5 5.340959821428571e-06 0.0 5.355468749999999e-06 0.0 5.356026785714285e-06 1.5 5.358258928571428e-06 1.5 5.358816964285714e-06 0.0 5.3733258928571425e-06 0.0 5.373883928571428e-06 1.5 5.376116071428571e-06 1.5 5.376674107142857e-06 0.0 5.391183035714286e-06 0.0 5.391741071428571e-06 1.5 5.3939732142857135e-06 1.5 5.394531249999999e-06 0.0 5.409040178571428e-06 0.0 5.409598214285714e-06 1.5 5.411830357142857e-06 1.5 5.412388392857143e-06 0.0 5.426897321428571e-06 0.0 5.427455357142857e-06 1.5 5.4296875e-06 1.5 5.430245535714285e-06 0.0 5.444754464285714e-06 0.0 5.445312499999999e-06 1.5 5.447544642857142e-06 1.5 5.448102678571428e-06 0.0 5.462611607142857e-06 0.0 5.4631696428571425e-06 1.5 5.465401785714285e-06 1.5 5.465959821428571e-06 0.0 5.48046875e-06 0.0 5.481026785714286e-06 1.5 5.4832589285714285e-06 1.5 5.4838169642857136e-06 0.0 5.498325892857142e-06 0.0 5.498883928571428e-06 1.5 5.501116071428571e-06 1.5 5.501674107142857e-06 0.0 5.516183035714285e-06 0.0 5.516741071428571e-06 1.5 5.518973214285714e-06 1.5 5.51953125e-06 0.0 5.5340401785714285e-06 0.0 5.5345982142857135e-06 1.5 5.536830357142857e-06 1.5 5.537388392857142e-06 0.0 5.551897321428571e-06 0.0 5.552455357142857e-06 1.5 5.5546874999999995e-06 1.5 5.555245535714285e-06 0.0 5.569754464285714e-06 0.0 5.5703125e-06 1.5 5.572544642857143e-06 1.5 5.5731026785714286e-06 0.0 5.587611607142857e-06 0.0 5.588169642857142e-06 1.5 5.590401785714285e-06 1.5 5.590959821428571e-06 0.0 5.6054687499999995e-06 0.0 5.606026785714285e-06 1.5 5.608258928571428e-06 1.5 5.608816964285714e-06 0.0 5.623325892857143e-06 0.0 5.6238839285714285e-06 1.5 5.626116071428571e-06 1.5 5.626674107142856e-06 0.0 5.641183035714285e-06 0.0 5.641741071428571e-06 1.5 5.643973214285714e-06 1.5 5.6445312499999996e-06 0.0 5.659040178571428e-06 0.0 5.659598214285714e-06 1.5 5.661830357142857e-06 1.5 5.662388392857143e-06 0.0 5.676897321428571e-06 0.0 5.677455357142856e-06 1.5 5.6796875e-06 1.5 5.680245535714285e-06 0.0 5.694754464285714e-06 0.0 5.6953124999999995e-06 1.5 5.697544642857142e-06 1.5 5.698102678571428e-06 0.0 5.712611607142857e-06 0.0 5.713169642857143e-06 1.5 5.7154017857142855e-06 1.5 5.715959821428571e-06 0.0 5.73046875e-06 0.0 5.731026785714285e-06 1.5 5.733258928571428e-06 1.5 5.733816964285714e-06 0.0 5.748325892857142e-06 0.0 5.748883928571428e-06 1.5 5.751116071428571e-06 1.5 5.751674107142857e-06 0.0 5.7661830357142854e-06 0.0 5.766741071428571e-06 1.5 5.768973214285714e-06 1.5 5.769531249999999e-06 0.0 5.784040178571428e-06 0.0 5.784598214285714e-06 1.5 5.7868303571428565e-06 1.5 5.787388392857142e-06 0.0 5.801897321428571e-06 0.0 5.802455357142857e-06 1.5 5.8046875e-06 1.5 5.8052455357142855e-06 0.0 5.819754464285714e-06 0.0 5.820312499999999e-06 1.5 5.822544642857143e-06 1.5 5.823102678571428e-06 0.0 5.8376116071428564e-06 0.0 5.838169642857142e-06 1.5 5.840401785714285e-06 1.5 5.840959821428571e-06 0.0 5.85546875e-06 0.0 5.8560267857142855e-06 1.5 5.858258928571428e-06 1.5 5.858816964285714e-06 0.0 5.873325892857143e-06 0.0 5.873883928571428e-06 1.5 5.876116071428571e-06 1.5 5.8766741071428565e-06 0.0 5.891183035714285e-06 0.0 5.891741071428571e-06 1.5 5.893973214285714e-06 1.5 5.89453125e-06 0.0 5.909040178571428e-06 0.0 5.909598214285714e-06 1.5 5.911830357142857e-06 1.5 5.912388392857142e-06 0.0 5.926897321428571e-06 0.0 5.9274553571428565e-06 1.5 5.929687499999999e-06 1.5 5.930245535714285e-06 0.0 5.944754464285714e-06 0.0 5.9453125e-06 1.5 5.9475446428571425e-06 1.5 5.948102678571428e-06 0.0 5.962611607142857e-06 0.0 5.963169642857143e-06 1.5 5.965401785714286e-06 1.5 5.965959821428571e-06 0.0 5.980468749999999e-06 0.0 5.981026785714285e-06 1.5 5.983258928571428e-06 1.5 5.983816964285714e-06 0.0 5.9983258928571424e-06 0.0 5.998883928571428e-06 1.5 6.001116071428571e-06 1.5 6.001674107142857e-06 0.0 6.016183035714286e-06 0.0 6.016741071428571e-06 1.5 6.0189732142857134e-06 1.5 6.019531249999999e-06 0.0 6.034040178571428e-06 0.0 6.034598214285714e-06 1.5 6.036830357142857e-06 1.5 6.0373883928571425e-06 0.0 6.051897321428571e-06 0.0 6.052455357142857e-06 1.5 6.0546875e-06 1.5 6.055245535714286e-06 0.0 6.069754464285714e-06 0.0 6.070312499999999e-06 1.5 6.072544642857142e-06 1.5 6.073102678571428e-06 0.0 6.087611607142857e-06 0.0 6.0881696428571425e-06 1.5 6.090401785714285e-06 1.5 6.090959821428571e-06 0.0 6.10546875e-06 0.0 6.106026785714286e-06 1.5 6.1082589285714285e-06 1.5 6.1088169642857135e-06 0.0 6.123325892857142e-06 0.0 6.123883928571428e-06 1.5 6.126116071428571e-06 1.5 6.126674107142857e-06 0.0 6.141183035714285e-06 0.0 6.141741071428571e-06 1.5 6.143973214285714e-06 1.5 6.14453125e-06 0.0 6.159040178571428e-06 0.0 6.1595982142857135e-06 1.5 6.161830357142857e-06 1.5 6.162388392857142e-06 0.0 6.176897321428571e-06 0.0 6.177455357142857e-06 1.5 6.1796874999999994e-06 1.5 6.180245535714285e-06 0.0 6.194754464285714e-06 0.0 6.1953125e-06 1.5 6.197544642857143e-06 1.5 6.1981026785714285e-06 0.0 6.212611607142857e-06 0.0 6.213169642857142e-06 1.5 6.215401785714285e-06 1.5 6.215959821428571e-06 0.0 6.230468749999999e-06 0.0 6.231026785714285e-06 1.5 6.233258928571428e-06 1.5 6.233816964285714e-06 0.0 6.2483258928571426e-06 0.0 6.2488839285714285e-06 1.5 6.251116071428571e-06 1.5 6.251674107142856e-06 0.0 6.266183035714285e-06 0.0 6.266741071428571e-06 1.5 6.268973214285714e-06 1.5 6.2695312499999995e-06 0.0 6.284040178571428e-06 0.0 6.284598214285714e-06 1.5 6.286830357142857e-06 1.5 6.287388392857143e-06 0.0 6.301897321428571e-06 0.0 6.302455357142856e-06 1.5 6.3046875e-06 1.5 6.305245535714285e-06 0.0 6.3197544642857136e-06 0.0 6.3203124999999995e-06 1.5 6.322544642857142e-06 1.5 6.323102678571428e-06 0.0 6.337611607142857e-06 0.0 6.338169642857143e-06 1.5 6.3404017857142854e-06 1.5 6.340959821428571e-06 0.0 6.35546875e-06 0.0 6.356026785714285e-06 1.5 6.358258928571428e-06 1.5 6.358816964285714e-06 0.0 6.373325892857142e-06 0.0 6.373883928571428e-06 1.5 6.376116071428571e-06 1.5 6.376674107142857e-06 0.0 6.391183035714285e-06 0.0 6.391741071428571e-06 1.5 6.393973214285714e-06 1.5 6.394531249999999e-06 0.0 6.409040178571428e-06 0.0 6.409598214285714e-06 1.5 6.411830357142856e-06 1.5 6.412388392857142e-06 0.0 6.426897321428571e-06 0.0 6.427455357142857e-06 1.5 6.4296875e-06 1.5 6.4302455357142855e-06 0.0 6.444754464285714e-06 0.0 6.445312499999999e-06 1.5 6.447544642857143e-06 1.5 6.448102678571428e-06 0.0 6.462611607142856e-06 0.0 6.463169642857142e-06 1.5 6.465401785714285e-06 1.5 6.465959821428571e-06 0.0 6.4804687499999995e-06 0.0 6.4810267857142855e-06 1.5 6.483258928571428e-06 1.5 6.483816964285714e-06 0.0 6.498325892857143e-06 0.0 6.498883928571428e-06 1.5 6.5011160714285706e-06 1.5 6.5016741071428565e-06 0.0 6.516183035714285e-06 0.0 6.516741071428571e-06 1.5 6.518973214285714e-06 1.5 6.51953125e-06 0.0 6.534040178571428e-06 0.0 6.534598214285714e-06 1.5 6.536830357142857e-06 1.5 6.537388392857142e-06 0.0 6.5518973214285705e-06 0.0 6.5524553571428564e-06 1.5 6.554687499999999e-06 1.5 6.555245535714285e-06 0.0 6.569754464285714e-06 0.0 6.5703125e-06 1.5 6.572544642857142e-06 1.5 6.573102678571428e-06 0.0 6.587611607142857e-06 0.0 6.588169642857143e-06 1.5 6.5904017857142856e-06 1.5 6.590959821428571e-06 0.0 6.605468749999999e-06 0.0 6.606026785714285e-06 1.5 6.608258928571428e-06 1.5 6.608816964285714e-06 0.0 6.623325892857142e-06 0.0 6.623883928571428e-06 1.5 6.626116071428571e-06 1.5 6.626674107142857e-06 0.0 6.6411830357142855e-06 0.0 6.641741071428571e-06 1.5 6.643973214285713e-06 1.5 6.644531249999999e-06 0.0 6.659040178571428e-06 0.0 6.659598214285714e-06 1.5 6.6618303571428566e-06 1.5 6.6623883928571425e-06 0.0 6.676897321428571e-06 0.0 6.677455357142857e-06 1.5 6.6796875e-06 1.5 6.680245535714286e-06 0.0 6.694754464285714e-06 0.0 6.695312499999999e-06 1.5 6.697544642857142e-06 1.5 6.698102678571428e-06 0.0 6.7126116071428565e-06 0.0 6.7131696428571424e-06 1.5 6.715401785714285e-06 1.5 6.715959821428571e-06 0.0 6.73046875e-06 0.0 6.731026785714286e-06 1.5 6.733258928571428e-06 1.5 6.7338169642857135e-06 0.0 6.748325892857142e-06 0.0 6.748883928571428e-06 1.5 6.751116071428571e-06 1.5 6.751674107142857e-06 0.0 6.766183035714285e-06 0.0 6.766741071428571e-06 1.5 6.76953125e-06 1.5 6.770089285714285e-06 0.0 6.7834821428571425e-06 0.0 6.784040178571428e-06 1.5 6.787388392857142e-06 1.5 6.787946428571428e-06 0.0 6.801339285714286e-06 0.0 6.801897321428571e-06 1.5 6.805245535714285e-06 1.5 6.805803571428571e-06 0.0 6.819196428571428e-06 0.0 6.819754464285714e-06 1.5 6.8231026785714285e-06 1.5 6.8236607142857135e-06 0.0 6.837053571428571e-06 0.0 6.837611607142857e-06 1.5 6.840959821428571e-06 1.5 6.841517857142857e-06 0.0 6.8549107142857134e-06 0.0 6.855468749999999e-06 1.5 6.858816964285714e-06 1.5 6.859375e-06 0.0 6.872767857142857e-06 0.0 6.8733258928571425e-06 1.5 6.876674107142856e-06 1.5 6.877232142857142e-06 0.0 6.890625e-06 0.0 6.891183035714285e-06 1.5 6.8945312499999994e-06 1.5 6.895089285714285e-06 0.0 6.908482142857142e-06 0.0 6.909040178571428e-06 1.5 6.912388392857143e-06 1.5 6.912946428571428e-06 0.0 6.926339285714285e-06 0.0 6.926897321428571e-06 1.5 6.930245535714285e-06 1.5 6.930803571428571e-06 0.0 6.9441964285714284e-06 0.0 6.9447544642857135e-06 1.5 6.948102678571428e-06 1.5 6.948660714285714e-06 0.0 6.962053571428571e-06 0.0 6.962611607142857e-06 1.5 6.965959821428571e-06 1.5 6.966517857142856e-06 0.0 6.979910714285714e-06 0.0 6.98046875e-06 1.5 6.983816964285714e-06 1.5 6.9843749999999995e-06 0.0 6.997767857142856e-06 0.0 6.998325892857142e-06 1.5 7.001674107142857e-06 1.5 7.002232142857143e-06 0.0 7.0156249999999994e-06 0.0 7.016183035714285e-06 1.5 7.019531249999999e-06 1.5 7.020089285714285e-06 0.0 7.033482142857143e-06 0.0 7.034040178571428e-06 1.5 7.037388392857142e-06 1.5 7.037946428571428e-06 0.0 7.051339285714285e-06 0.0 7.051897321428571e-06 1.5 7.0552455357142854e-06 1.5 7.0558035714285705e-06 0.0 7.069196428571428e-06 0.0 7.069754464285714e-06 1.5 7.073102678571428e-06 1.5 7.073660714285714e-06 0.0 7.087053571428571e-06 0.0 7.087611607142856e-06 1.5 7.090959821428571e-06 1.5 7.091517857142857e-06 0.0 7.104352678571428e-06 0.0 7.104910714285714e-06 1.5 7.109374999999999e-06 1.5 7.109933035714285e-06 0.0 7.122209821428571e-06 0.0 7.122767857142857e-06 1.5 7.127232142857142e-06 1.5 7.127790178571428e-06 0.0 7.140066964285714e-06 0.0 7.140624999999999e-06 1.5 7.1450892857142855e-06 1.5 7.1456473214285706e-06 0.0 7.157924107142856e-06 0.0 7.158482142857142e-06 1.5 7.162946428571428e-06 1.5 7.163504464285714e-06 0.0 7.1757812499999995e-06 0.0 7.176339285714285e-06 1.5 7.180803571428571e-06 1.5 7.181361607142857e-06 0.0 7.193638392857143e-06 0.0 7.194196428571428e-06 1.5 7.198660714285714e-06 1.5 7.199218749999999e-06 0.0 7.211495535714285e-06 0.0 7.212053571428571e-06 1.5 7.2165178571428565e-06 1.5 7.217075892857142e-06 0.0 7.229352678571428e-06 0.0 7.229910714285714e-06 1.5 7.234375e-06 1.5 7.2349330357142856e-06 0.0 7.2472098214285705e-06 0.0 7.247767857142856e-06 1.5 7.252232142857142e-06 1.5 7.252790178571428e-06 0.0 7.265066964285714e-06 0.0 7.2656249999999996e-06 1.5 7.270089285714285e-06 1.5 7.270647321428571e-06 0.0 7.282924107142857e-06 0.0 7.283482142857143e-06 1.5 7.287946428571428e-06 1.5 7.288504464285713e-06 0.0 7.300781249999999e-06 0.0 7.301339285714285e-06 1.5 7.305803571428571e-06 1.5 7.3063616071428566e-06 0.0 7.318638392857142e-06 0.0 7.319196428571428e-06 1.5 7.323660714285714e-06 1.5 7.32421875e-06 0.0 7.3364955357142855e-06 0.0 7.3370535714285706e-06 1.5 7.341517857142857e-06 1.5 7.342075892857142e-06 0.0 7.354352678571428e-06 0.0 7.354910714285714e-06 1.5 7.359933035714285e-06 1.5 7.360491071428571e-06 0.0 7.371651785714285e-06 0.0 7.372209821428571e-06 1.5 7.377790178571428e-06 1.5 7.3783482142857135e-06 0.0 7.389508928571428e-06 0.0 7.390066964285714e-06 1.5 7.395647321428571e-06 1.5 7.396205357142857e-06 0.0 7.407366071428571e-06 0.0 7.4079241071428565e-06 1.5 7.413504464285714e-06 1.5 7.4140625e-06 0.0 7.425223214285714e-06 0.0 7.42578125e-06 1.5 7.431361607142856e-06 1.5 7.431919642857142e-06 0.0 7.443080357142857e-06 0.0 7.443638392857142e-06 1.5 7.449218749999999e-06 1.5 7.449776785714285e-06 0.0 7.460937499999999e-06 0.0 7.461495535714285e-06 1.5 7.4670758928571425e-06 1.5 7.4676339285714285e-06 0.0 7.478794642857142e-06 0.0 7.479352678571428e-06 1.5 7.484933035714285e-06 1.5 7.485491071428571e-06 0.0 7.496651785714286e-06 0.0 7.497209821428571e-06 1.5 7.502790178571428e-06 1.5 7.503348214285714e-06 0.0 7.514508928571428e-06 0.0 7.515066964285714e-06 1.5 7.520647321428571e-06 1.5 7.521205357142856e-06 0.0 7.532366071428571e-06 0.0 7.532924107142857e-06 1.5 7.5385044642857135e-06 1.5 7.5390624999999994e-06 0.0 7.550223214285713e-06 0.0 7.550781249999999e-06 1.5 7.556361607142857e-06 1.5 7.556919642857143e-06 0.0 7.5680803571428566e-06 0.0 7.5686383928571425e-06 1.5 7.57421875e-06 1.5 7.574776785714285e-06 0.0 7.5859375e-06 0.0 7.586495535714285e-06 1.5 7.592633928571428e-06 1.5 7.593191964285714e-06 0.0 7.603236607142857e-06 0.0 7.603794642857142e-06 1.5 7.610491071428571e-06 1.5 7.611049107142856e-06 0.0 7.621093749999999e-06 0.0 7.621651785714285e-06 1.5 7.628348214285714e-06 1.5 7.6289062499999995e-06 0.0 7.638950892857142e-06 0.0 7.639508928571428e-06 1.5 7.646205357142857e-06 1.5 7.646763392857142e-06 0.0 7.656808035714285e-06 0.0 7.657366071428572e-06 1.5 7.664062499999999e-06 1.5 7.664620535714286e-06 0.0 7.674665178571429e-06 0.0 7.675223214285714e-06 1.5 7.681919642857143e-06 1.5 7.682477678571428e-06 0.0 7.692522321428571e-06 0.0 7.693080357142856e-06 1.5 7.699776785714285e-06 1.5 7.70033482142857e-06 0.0 7.710379464285713e-06 0.0 7.7109375e-06 1.5 7.717633928571428e-06 1.5 7.718191964285715e-06 0.0 7.728236607142856e-06 0.0 7.728794642857143e-06 1.5 7.73549107142857e-06 1.5 7.736049107142857e-06 0.0 7.74609375e-06 0.0 7.746651785714285e-06 1.5 7.753348214285714e-06 1.5 7.75390625e-06 0.0 7.763950892857142e-06 0.0 7.764508928571427e-06 1.5 7.771205357142856e-06 1.5 7.771763392857141e-06 0.0 7.781808035714284e-06 0.0 7.782366071428571e-06 1.5 7.789062499999999e-06 1.5 7.789620535714286e-06 0.0 7.799665178571428e-06 0.0 7.800223214285714e-06 1.5 7.806919642857143e-06 1.5 7.807477678571428e-06 0.0 7.816964285714286e-06 0.0 7.81752232142857e-06 1.5 7.82533482142857e-06 1.5 7.825892857142857e-06 0.0 7.834821428571428e-06 0.0 7.835379464285713e-06 1.5 7.843191964285714e-06 1.5 7.84375e-06 0.0 7.85267857142857e-06 0.0 7.853236607142857e-06 1.5 7.861049107142856e-06 1.5 7.861607142857142e-06 0.0 7.870535714285714e-06 0.0 7.87109375e-06 1.5 7.878906249999999e-06 1.5 7.879464285714286e-06 0.0 7.888392857142857e-06 0.0 7.888950892857142e-06 1.5 7.896763392857143e-06 1.5 7.897321428571428e-06 0.0 7.906249999999999e-06 0.0 7.906808035714286e-06 1.5 7.914620535714285e-06 1.5 7.91517857142857e-06 0.0 7.924107142857143e-06 0.0 7.924665178571428e-06 1.5 7.932477678571427e-06 1.5 7.933035714285714e-06 0.0 7.941964285714285e-06 0.0 7.94252232142857e-06 1.5 7.950334821428571e-06 1.5 7.950892857142857e-06 0.0 7.959821428571428e-06 0.0 7.960379464285714e-06 1.5 7.968191964285714e-06 1.5 7.968749999999999e-06 0.0 7.97767857142857e-06 0.0 7.978236607142857e-06 1.5 7.986049107142856e-06 1.5 7.986607142857143e-06 0.0 7.995535714285714e-06 0.0 7.996093749999999e-06 1.5 8.00390625e-06 1.5 8.004464285714285e-06 0.0 8.013392857142856e-06 0.0 8.013950892857141e-06 1.5 8.021763392857142e-06 1.5 8.022321428571428e-06 0.0 8.030691964285714e-06 0.0 8.031249999999999e-06 1.5 8.040178571428572e-06 1.5 8.040736607142857e-06 0.0 8.048549107142856e-06 0.0 8.049107142857143e-06 1.5 8.058035714285714e-06 1.5 8.058593749999999e-06 0.0 8.06640625e-06 0.0 8.066964285714285e-06 1.5 8.075892857142856e-06 1.5 8.076450892857143e-06 0.0 8.084263392857142e-06 0.0 8.084821428571427e-06 1.5 8.09375e-06 1.5 8.094308035714285e-06 0.0 8.102120535714285e-06 0.0 8.102678571428571e-06 1.5 8.111607142857143e-06 1.5 8.112165178571428e-06 0.0 8.119977678571429e-06 0.0 8.120535714285714e-06 1.5 8.129464285714285e-06 1.5 8.130022321428572e-06 0.0 8.137834821428571e-06 0.0 8.138392857142856e-06 1.5 8.147321428571427e-06 1.5 8.147879464285714e-06 0.0 8.155691964285713e-06 0.0 8.15625e-06 1.5 8.165178571428571e-06 1.5 8.165736607142856e-06 0.0 8.173549107142857e-06 0.0 8.174107142857142e-06 1.5 8.183035714285714e-06 1.5 8.183593749999999e-06 0.0 8.19140625e-06 0.0 8.191964285714285e-06 1.5 8.200892857142856e-06 1.5 8.201450892857143e-06 0.0 8.209263392857142e-06 0.0 8.209821428571429e-06 1.5 8.21875e-06 1.5 8.219308035714285e-06 0.0 8.227120535714284e-06 0.0 8.227678571428571e-06 1.5 8.236607142857142e-06 1.5 8.237165178571427e-06 0.0 8.244419642857142e-06 0.0 8.244977678571428e-06 1.5 8.255022321428571e-06 1.5 8.255580357142856e-06 0.0 8.262276785714286e-06 0.0 8.26283482142857e-06 1.5 8.272879464285714e-06 1.5 8.273437499999999e-06 0.0 8.280133928571428e-06 0.0 8.280691964285713e-06 1.5 8.290736607142856e-06 1.5 8.291294642857143e-06 0.0 8.29799107142857e-06 0.0 8.298549107142857e-06 1.5 8.30859375e-06 1.5 8.309151785714285e-06 0.0 8.315848214285714e-06 0.0 8.31640625e-06 1.5 8.326450892857142e-06 1.5 8.327008928571427e-06 0.0 8.333705357142857e-06 0.0 8.334263392857142e-06 1.5 8.344308035714285e-06 1.5 8.344866071428571e-06 0.0 8.351562499999999e-06 0.0 8.352120535714286e-06 1.5 8.362165178571429e-06 1.5 8.362723214285714e-06 0.0 8.369419642857143e-06 0.0 8.369977678571428e-06 1.5 8.380022321428571e-06 1.5 8.380580357142856e-06 0.0 8.387276785714285e-06 0.0 8.38783482142857e-06 1.5 8.397879464285713e-06 1.5 8.3984375e-06 0.0 8.405133928571428e-06 0.0 8.405691964285714e-06 1.5 8.415736607142857e-06 1.5 8.416294642857142e-06 0.0 8.422991071428572e-06 0.0 8.423549107142857e-06 1.5 8.43359375e-06 1.5 8.434151785714285e-06 0.0 8.440848214285714e-06 0.0 8.441406249999999e-06 1.5 8.451450892857142e-06 1.5 8.452008928571429e-06 0.0 8.458705357142856e-06 0.0 8.459263392857143e-06 1.5 8.469866071428571e-06 1.5 8.470424107142856e-06 0.0 8.476004464285713e-06 0.0 8.4765625e-06 1.5 8.487723214285713e-06 1.5 8.48828125e-06 0.0 8.493861607142856e-06 0.0 8.494419642857143e-06 1.5 8.505580357142857e-06 1.5 8.506138392857142e-06 0.0 8.51171875e-06 0.0 8.512276785714285e-06 1.5 8.5234375e-06 1.5 8.523995535714285e-06 0.0 8.529575892857142e-06 0.0 8.530133928571427e-06 1.5 8.541294642857142e-06 1.5 8.541852678571429e-06 0.0 8.547433035714284e-06 0.0 8.547991071428571e-06 1.5 8.559151785714284e-06 1.5 8.559709821428571e-06 0.0 8.565290178571428e-06 0.0 8.565848214285714e-06 1.5 8.577008928571428e-06 1.5 8.577566964285713e-06 0.0 8.58314732142857e-06 0.0 8.583705357142856e-06 1.5 8.59486607142857e-06 1.5 8.595424107142856e-06 0.0 8.601004464285713e-06 0.0 8.6015625e-06 1.5 8.612723214285713e-06 1.5 8.61328125e-06 0.0 8.618861607142857e-06 0.0 8.619419642857142e-06 1.5 8.630580357142857e-06 1.5 8.631138392857142e-06 0.0 8.63671875e-06 0.0 8.637276785714285e-06 1.5 8.6484375e-06 1.5 8.648995535714284e-06 0.0 8.654575892857142e-06 0.0 8.655133928571429e-06 1.5 8.666294642857142e-06 1.5 8.666852678571428e-06 0.0 8.672433035714286e-06 0.0 8.672991071428571e-06 1.5 8.684151785714286e-06 1.5 8.68470982142857e-06 0.0 8.690290178571428e-06 0.0 8.690848214285713e-06 1.5 8.702566964285713e-06 1.5 8.703125e-06 0.0 8.707589285714285e-06 0.0 8.70814732142857e-06 1.5 8.720424107142857e-06 1.5 8.720982142857142e-06 0.0 8.725446428571428e-06 0.0 8.726004464285714e-06 1.5 8.73828125e-06 1.5 8.738839285714284e-06 0.0 8.74330357142857e-06 0.0 8.743861607142857e-06 1.5 8.756138392857142e-06 1.5 8.756696428571428e-06 0.0 8.761160714285714e-06 0.0 8.761718749999999e-06 1.5 8.773995535714286e-06 1.5 8.77455357142857e-06 0.0 8.779017857142856e-06 0.0 8.779575892857141e-06 1.5 8.791852678571428e-06 1.5 8.792410714285713e-06 0.0 8.796874999999999e-06 0.0 8.797433035714285e-06 1.5 8.80970982142857e-06 1.5 8.810267857142857e-06 0.0 8.814732142857143e-06 0.0 8.815290178571428e-06 1.5 8.827566964285714e-06 1.5 8.828125e-06 0.0 8.832589285714285e-06 0.0 8.83314732142857e-06 1.5 8.845424107142857e-06 1.5 8.845982142857142e-06 0.0 8.850446428571427e-06 0.0 8.851004464285714e-06 1.5 8.863281249999999e-06 1.5 8.863839285714286e-06 0.0 8.868303571428571e-06 0.0 8.868861607142856e-06 1.5 8.881138392857143e-06 1.5 8.881696428571428e-06 0.0 8.886160714285714e-06 0.0 8.886718749999999e-06 1.5 8.898995535714285e-06 1.5 8.89955357142857e-06 0.0 8.904017857142856e-06 0.0 8.904575892857143e-06 1.5 8.916852678571428e-06 1.5 8.917410714285714e-06 0.0 8.921875e-06 0.0 8.922433035714285e-06 1.5 8.93470982142857e-06 1.5 8.935267857142857e-06 0.0 8.939732142857142e-06 0.0 8.940290178571427e-06 1.5 8.952566964285714e-06 1.5 8.953124999999999e-06 0.0 8.957589285714285e-06 0.0 8.958147321428571e-06 1.5 8.970982142857141e-06 1.5 8.971540178571428e-06 0.0 8.974888392857142e-06 0.0 8.975446428571429e-06 1.5 8.988839285714285e-06 1.5 8.98939732142857e-06 0.0 8.992745535714284e-06 0.0 8.993303571428571e-06 1.5 9.006696428571428e-06 1.5 9.007254464285713e-06 0.0 9.010602678571428e-06 0.0 9.011160714285713e-06 1.5 9.02455357142857e-06 1.5 9.025111607142857e-06 0.0 9.02845982142857e-06 0.0 9.029017857142856e-06 1.5 9.042410714285714e-06 1.5 9.04296875e-06 0.0 9.046316964285713e-06 0.0 9.046875e-06 1.5 9.060267857142856e-06 1.5 9.060825892857141e-06 0.0 9.064174107142857e-06 0.0 9.064732142857142e-06 1.5 9.078124999999999e-06 1.5 9.078683035714285e-06 0.0 9.08203125e-06 0.0 9.082589285714284e-06 1.5 9.095982142857143e-06 1.5 9.096540178571428e-06 0.0 9.099888392857142e-06 0.0 9.100446428571428e-06 1.5 9.113839285714285e-06 1.5 9.11439732142857e-06 0.0 9.117745535714286e-06 0.0 9.11830357142857e-06 1.5 9.131696428571427e-06 1.5 9.132254464285714e-06 0.0 9.135602678571428e-06 0.0 9.136160714285713e-06 1.5 9.149553571428571e-06 1.5 9.150111607142856e-06 0.0 9.15345982142857e-06 0.0 9.154017857142857e-06 1.5 9.167410714285714e-06 1.5 9.167968749999999e-06 0.0 9.171316964285714e-06 0.0 9.171875e-06 1.5 9.185267857142856e-06 1.5 9.185825892857143e-06 0.0 9.189174107142857e-06 0.0 9.189732142857142e-06 1.5 9.203125e-06 1.5 9.203683035714285e-06 0.0 9.207031249999999e-06 0.0 9.207589285714286e-06 1.5 9.220982142857142e-06 1.5 9.221540178571427e-06 0.0 9.224888392857143e-06 0.0 9.225446428571428e-06 1.5 9.238839285714285e-06 1.5 9.239397321428571e-06 0.0 9.242745535714285e-06 0.0 9.24330357142857e-06 1.5 9.256696428571429e-06 1.5 9.257254464285714e-06 0.0 9.260602678571428e-06 0.0 9.261160714285714e-06 1.5 9.274553571428571e-06 1.5 9.275111607142856e-06 0.0 9.278459821428572e-06 0.0 9.279017857142857e-06 1.5 9.29296875e-06 1.5 9.293526785714285e-06 0.0 9.295758928571427e-06 0.0 9.296316964285714e-06 1.5 9.310825892857142e-06 1.5 9.311383928571428e-06 0.0 9.313616071428571e-06 0.0 9.314174107142856e-06 1.5 9.328683035714285e-06 1.5 9.329241071428572e-06 0.0 9.331473214285713e-06 0.0 9.332031249999999e-06 1.5 9.346540178571427e-06 1.5 9.347098214285714e-06 0.0 9.349330357142856e-06 0.0 9.349888392857143e-06 1.5 9.364397321428571e-06 1.5 9.364955357142856e-06 0.0 9.3671875e-06 0.0 9.367745535714285e-06 1.5 9.382254464285713e-06 1.5 9.382812499999999e-06 0.0 9.385044642857142e-06 0.0 9.385602678571427e-06 1.5 9.400111607142856e-06 1.5 9.400669642857143e-06 0.0 9.402901785714284e-06 0.0 9.403459821428571e-06 1.5 9.41796875e-06 1.5 9.418526785714285e-06 0.0 9.420758928571428e-06 0.0 9.421316964285714e-06 1.5 9.435825892857142e-06 1.5 9.436383928571427e-06 0.0 9.43861607142857e-06 0.0 9.439174107142856e-06 1.5 9.453683035714284e-06 1.5 9.454241071428571e-06 0.0 9.456473214285713e-06 0.0 9.45703125e-06 1.5 9.471540178571428e-06 1.5 9.472098214285714e-06 0.0 9.474330357142857e-06 0.0 9.474888392857142e-06 1.5 9.48939732142857e-06 1.5 9.489955357142856e-06 0.0 9.4921875e-06 0.0 9.492745535714285e-06 1.5 9.507254464285713e-06 1.5 9.5078125e-06 0.0 9.510044642857142e-06 0.0 9.510602678571429e-06 1.5 9.525111607142857e-06 1.5 9.525669642857142e-06 0.0 9.527901785714286e-06 0.0 9.528459821428571e-06 1.5 9.54296875e-06 1.5 9.543526785714285e-06 0.0 9.545758928571428e-06 0.0 9.546316964285713e-06 1.5 9.560825892857142e-06 1.5 9.561383928571429e-06 0.0 9.56361607142857e-06 0.0 9.564174107142857e-06 1.5 9.578683035714286e-06 1.5 9.579241071428571e-06 0.0 9.581473214285713e-06 0.0 9.58203125e-06 1.5 9.596540178571428e-06 1.5 9.597098214285713e-06 0.0 9.599330357142857e-06 0.0 9.599888392857142e-06 1.5 9.61439732142857e-06 1.5 9.614955357142857e-06 0.0 9.617187499999999e-06 0.0 9.617745535714284e-06 1.5 9.632254464285713e-06 1.5 9.6328125e-06 0.0 9.635044642857141e-06 0.0 9.635602678571428e-06 1.5 9.650111607142857e-06 1.5 9.650669642857142e-06 0.0 9.652901785714285e-06 0.0 9.65345982142857e-06 1.5 9.667968749999999e-06 1.5 9.668526785714286e-06 0.0 9.670758928571428e-06 0.0 9.671316964285713e-06 1.5 9.685825892857141e-06 1.5 9.686383928571428e-06 0.0 9.68861607142857e-06 0.0 9.689174107142857e-06 1.5 9.703683035714285e-06 1.5 9.70424107142857e-06 0.0 9.706473214285714e-06 0.0 9.70703125e-06 1.5 9.721540178571428e-06 1.5 9.722098214285713e-06 0.0 9.724330357142856e-06 0.0 9.724888392857142e-06 1.5 9.73939732142857e-06 1.5 9.739955357142857e-06 0.0 9.742187499999999e-06 0.0 9.742745535714286e-06 1.5 9.757254464285714e-06 1.5 9.7578125e-06 0.0 9.760044642857143e-06 0.0 9.760602678571428e-06 1.5 9.775111607142856e-06 1.5 9.775669642857141e-06 0.0 9.777901785714285e-06 0.0 9.77845982142857e-06 1.5 9.792968749999999e-06 1.5 9.793526785714286e-06 0.0 9.795758928571427e-06 0.0 9.796316964285714e-06 1.5 9.810825892857143e-06 1.5 9.811383928571428e-06 0.0 9.813616071428571e-06 0.0 9.814174107142857e-06 1.5 9.828683035714285e-06 1.5 9.82924107142857e-06 0.0 9.831473214285714e-06 0.0 9.832031249999999e-06 1.5 9.846540178571427e-06 1.5 9.847098214285714e-06 0.0 9.849330357142856e-06 0.0 9.849888392857143e-06 1.5 9.864397321428571e-06 1.5 9.864955357142856e-06 0.0 9.8671875e-06 0.0 9.867745535714285e-06 1.5 9.882254464285714e-06 1.5 9.882812499999999e-06 0.0 9.885044642857142e-06 0.0 9.885602678571428e-06 1.5 9.900111607142856e-06 1.5 9.900669642857143e-06 0.0 9.902901785714285e-06 0.0 9.903459821428572e-06 1.5 9.91796875e-06 1.5 9.918526785714285e-06 0.0 9.920758928571427e-06 0.0 9.921316964285714e-06 1.5 9.935825892857142e-06 1.5 9.936383928571427e-06 0.0 9.938616071428571e-06 0.0 9.939174107142856e-06 1.5 9.953683035714285e-06 1.5 9.954241071428571e-06 0.0 9.956473214285713e-06 0.0 9.957031249999999e-06 1.5 9.971540178571427e-06 1.5 9.972098214285714e-06 0.0 9.974330357142856e-06 0.0 9.974888392857143e-06 1.5 9.989397321428571e-06 1.5 9.989955357142856e-06 0.0 9.9921875e-06 0.0 9.992745535714285e-06 1.5 1.0007254464285713e-05 1.5 1.0007812499999998e-05 0.0 1.0010044642857142e-05 0.0 1.0010602678571427e-05 1.5 1.0025111607142856e-05 1.5 1.0025669642857142e-05 0.0 1.0027901785714284e-05 0.0 1.0028459821428571e-05 1.5 1.004296875e-05 1.5 1.0043526785714285e-05 0.0 1.0045758928571428e-05 0.0 1.0046316964285714e-05 1.5 1.0060825892857142e-05 1.5 1.0061383928571427e-05 0.0 1.006361607142857e-05 0.0 1.0064174107142856e-05 1.5 1.0078683035714284e-05 1.5 1.0079241071428571e-05 0.0 1.0081473214285713e-05 0.0 1.008203125e-05 1.5 1.0096540178571428e-05 1.5 1.0097098214285713e-05 0.0 1.0099330357142857e-05 0.0 1.0099888392857142e-05 1.5 1.011439732142857e-05 1.5 1.0114955357142856e-05 0.0 1.01171875e-05 0.0 1.0117745535714284e-05 1.5 1.0132254464285713e-05 1.5 1.01328125e-05 0.0 1.0135044642857142e-05 0.0 1.0135602678571429e-05 1.5 1.0150111607142857e-05 1.5 1.0150669642857142e-05 0.0 1.0152901785714286e-05 0.0 1.015345982142857e-05 1.5 1.016796875e-05 1.5 1.0168526785714284e-05 0.0 1.0170758928571428e-05 0.0 1.0171316964285713e-05 1.5 1.0185825892857142e-05 1.5 1.0186383928571428e-05 0.0 1.018861607142857e-05 0.0 1.0189174107142857e-05 1.5 1.0203683035714286e-05 1.5 1.020424107142857e-05 0.0 1.0206473214285713e-05 0.0 1.020703125e-05 1.5 1.0221540178571428e-05 1.5 1.0222098214285713e-05 0.0 1.0224330357142857e-05 0.0 1.0224888392857142e-05 1.5 1.023939732142857e-05 1.5 1.0239955357142857e-05 0.0 1.0242187499999999e-05 0.0 1.0242745535714284e-05 1.5 1.0257254464285713e-05 1.5 1.02578125e-05 0.0 1.0260044642857141e-05 0.0 1.0260602678571428e-05 1.5 1.0275111607142857e-05 1.5 1.0275669642857142e-05 0.0 1.0277901785714285e-05 0.0 1.027845982142857e-05 1.5 1.0292968749999999e-05 1.5 1.0293526785714286e-05 0.0 1.0295758928571428e-05 0.0 1.0296316964285713e-05 1.5 1.0310825892857141e-05 1.5 1.0311383928571428e-05 0.0 1.031361607142857e-05 0.0 1.0314174107142857e-05 1.5 1.0328683035714285e-05 1.5 1.032924107142857e-05 0.0 1.0331473214285714e-05 0.0 1.0332031249999999e-05 1.5 1.0346540178571428e-05 1.5 1.0347098214285713e-05 0.0 1.0349330357142856e-05 0.0 1.0349888392857141e-05 1.5 1.036439732142857e-05 1.5 1.0364955357142857e-05 0.0 1.0367187499999999e-05 0.0 1.0367745535714285e-05 1.5 1.0382254464285714e-05 1.5 1.0382812499999999e-05 0.0 1.0385044642857143e-05 0.0 1.0385602678571428e-05 1.5 1.0400111607142856e-05 1.5 1.0400669642857141e-05 0.0 1.0402901785714285e-05 0.0 1.040345982142857e-05 1.5 1.0417968749999999e-05 1.5 1.0418526785714285e-05 0.0 1.0420758928571427e-05 0.0 1.0421316964285714e-05 1.5 1.0435825892857143e-05 1.5 1.0436383928571428e-05 0.0 1.0438616071428571e-05 0.0 1.0439174107142856e-05 1.5 1.0453683035714285e-05 1.5 1.045424107142857e-05 0.0 1.0456473214285714e-05 0.0 1.0457031249999999e-05 1.5 1.0471540178571427e-05 1.5 1.0472098214285714e-05 0.0 1.0474330357142856e-05 0.0 1.0474888392857143e-05 1.5 1.0489397321428571e-05 1.5 1.0489955357142856e-05 0.0 1.04921875e-05 0.0 1.0492745535714285e-05 1.5 1.0507254464285714e-05 1.5 1.0507812499999999e-05 0.0 1.0510044642857142e-05 0.0 1.0510602678571427e-05 1.5 1.0525111607142856e-05 1.5 1.0525669642857143e-05 0.0 1.0527901785714285e-05 0.0 1.0528459821428571e-05 1.5 1.054296875e-05 1.5 1.0543526785714285e-05 0.0 1.0545758928571427e-05 0.0 1.0546316964285714e-05 1.5 1.0560825892857142e-05 1.5 1.0561383928571427e-05 0.0 1.0563616071428571e-05 0.0 1.0564174107142856e-05 1.5 1.0578683035714285e-05 1.5 1.0579241071428571e-05 0.0 1.0581473214285713e-05 0.0 1.0582031249999998e-05 1.5 1.0596540178571427e-05 1.5 1.0597098214285714e-05 0.0 1.0599330357142856e-05 0.0 1.0599888392857142e-05 1.5 1.0614397321428571e-05 1.5 1.0614955357142856e-05 0.0 1.06171875e-05 0.0 1.0617745535714285e-05 1.5 1.0632254464285713e-05 1.5 1.0632812499999998e-05 0.0 1.0635044642857142e-05 0.0 1.0635602678571427e-05 1.5 1.0650111607142856e-05 1.5 1.0650669642857142e-05 0.0 1.0652901785714284e-05 0.0 1.0653459821428571e-05 1.5 1.066796875e-05 1.5 1.0668526785714285e-05 0.0 1.0670758928571428e-05 0.0 1.0671316964285713e-05 1.5 1.0685825892857142e-05 1.5 1.0686383928571427e-05 0.0 1.068861607142857e-05 0.0 1.0689174107142856e-05 1.5 1.0703683035714284e-05 1.5 1.0704241071428571e-05 0.0 1.0706473214285713e-05 0.0 1.070703125e-05 1.5 1.0721540178571428e-05 1.5 1.0722098214285713e-05 0.0 1.0724330357142857e-05 0.0 1.0724888392857142e-05 1.5 1.073939732142857e-05 1.5 1.0739955357142856e-05 0.0 1.07421875e-05 0.0 1.0742745535714284e-05 1.5 1.0757254464285713e-05 1.5 1.07578125e-05 0.0 1.0760044642857142e-05 0.0 1.0760602678571428e-05 1.5 1.0775111607142857e-05 1.5 1.0775669642857142e-05 0.0 1.0777901785714286e-05 0.0 1.077845982142857e-05 1.5 1.0792410714285714e-05 1.5 1.079296875e-05 0.0 1.0796316964285713e-05 0.0 1.0796875e-05 1.5 1.0810267857142857e-05 1.5 1.0810825892857142e-05 0.0 1.0814174107142857e-05 0.0 1.0814732142857142e-05 1.5 1.0828124999999999e-05 1.5 1.0828683035714286e-05 0.0 1.083203125e-05 0.0 1.0832589285714285e-05 1.5 1.0845982142857141e-05 1.5 1.0846540178571428e-05 0.0 1.0849888392857142e-05 0.0 1.0850446428571429e-05 1.5 1.0863839285714285e-05 1.5 1.086439732142857e-05 0.0 1.0867745535714284e-05 0.0 1.086830357142857e-05 1.5 1.0881696428571428e-05 1.5 1.0882254464285714e-05 0.0 1.0885602678571428e-05 0.0 1.0886160714285713e-05 1.5 1.089955357142857e-05 1.5 1.0900111607142857e-05 0.0 1.090345982142857e-05 0.0 1.0904017857142857e-05 1.5 1.0917410714285714e-05 1.5 1.0917968749999999e-05 0.0 1.0921316964285713e-05 0.0 1.0921875e-05 1.5 1.0935267857142856e-05 1.5 1.0935825892857141e-05 0.0 1.0939174107142857e-05 0.0 1.0939732142857142e-05 1.5 1.0953124999999999e-05 1.5 1.0953683035714285e-05 0.0 1.0957031249999999e-05 0.0 1.0957589285714284e-05 1.5 1.0970982142857143e-05 1.5 1.0971540178571428e-05 0.0 1.0974888392857141e-05 0.0 1.0975446428571428e-05 1.5 1.0988839285714285e-05 1.5 1.098939732142857e-05 0.0 1.0992745535714285e-05 0.0 1.099330357142857e-05 1.5 1.1006696428571427e-05 1.5 1.1007254464285714e-05 0.0 1.1010602678571428e-05 0.0 1.1011160714285713e-05 1.5 1.1024553571428571e-05 1.5 1.1025111607142856e-05 0.0 1.102845982142857e-05 0.0 1.1029017857142857e-05 1.5 1.1042410714285714e-05 1.5 1.1042968749999999e-05 0.0 1.1046316964285714e-05 0.0 1.1046875e-05 1.5 1.1060267857142856e-05 1.5 1.1060825892857143e-05 0.0 1.1064174107142856e-05 0.0 1.1064732142857141e-05 1.5 1.1078125e-05 1.5 1.1078683035714285e-05 0.0 1.1082031249999999e-05 0.0 1.1082589285714285e-05 1.5 1.1095982142857142e-05 1.5 1.1096540178571427e-05 0.0 1.1099888392857143e-05 0.0 1.1100446428571428e-05 1.5 1.111328125e-05 1.5 1.1113839285714285e-05 0.0 1.111830357142857e-05 0.0 1.1118861607142857e-05 1.5 1.1131138392857142e-05 1.5 1.1131696428571429e-05 0.0 1.1136160714285714e-05 0.0 1.113671875e-05 1.5 1.1148995535714284e-05 1.5 1.1149553571428571e-05 0.0 1.1154017857142856e-05 0.0 1.1154575892857142e-05 1.5 1.1166852678571428e-05 1.5 1.1167410714285713e-05 0.0 1.1171874999999999e-05 0.0 1.1172433035714286e-05 1.5 1.118470982142857e-05 1.5 1.1185267857142856e-05 0.0 1.1189732142857143e-05 0.0 1.1190290178571428e-05 1.5 1.1202566964285713e-05 1.5 1.1203125e-05 0.0 1.1207589285714285e-05 0.0 1.120814732142857e-05 1.5 1.1220424107142857e-05 1.5 1.1220982142857142e-05 0.0 1.1225446428571427e-05 0.0 1.1226004464285714e-05 1.5 1.123828125e-05 1.5 1.1238839285714284e-05 0.0 1.124330357142857e-05 0.0 1.1243861607142857e-05 1.5 1.1256138392857141e-05 1.5 1.1256696428571428e-05 0.0 1.1261160714285714e-05 0.0 1.1261718749999999e-05 1.5 1.1273995535714285e-05 1.5 1.127455357142857e-05 0.0 1.1279017857142856e-05 0.0 1.1279575892857143e-05 1.5 1.1291852678571428e-05 1.5 1.1292410714285713e-05 0.0 1.1296874999999998e-05 0.0 1.1297433035714285e-05 1.5 1.130970982142857e-05 1.5 1.1310267857142857e-05 0.0 1.1314732142857142e-05 0.0 1.1315290178571428e-05 1.5 1.1327566964285714e-05 1.5 1.1328125e-05 0.0 1.1332589285714285e-05 0.0 1.133314732142857e-05 1.5 1.1345424107142856e-05 1.5 1.1345982142857142e-05 0.0 1.1350446428571427e-05 0.0 1.1351004464285714e-05 1.5 1.1363281249999999e-05 1.5 1.1363839285714286e-05 0.0 1.1368303571428571e-05 0.0 1.1368861607142856e-05 1.5 1.1380580357142856e-05 1.5 1.1381138392857143e-05 0.0 1.1386718749999999e-05 0.0 1.1387276785714285e-05 1.5 1.1398437499999998e-05 1.5 1.1398995535714285e-05 0.0 1.1404575892857143e-05 0.0 1.1405133928571428e-05 1.5 1.1416294642857142e-05 1.5 1.1416852678571427e-05 0.0 1.1422433035714285e-05 0.0 1.142299107142857e-05 1.5 1.1434151785714285e-05 1.5 1.143470982142857e-05 0.0 1.1440290178571427e-05 0.0 1.1440848214285714e-05 1.5 1.1452008928571427e-05 1.5 1.1452566964285714e-05 0.0 1.1458147321428571e-05 0.0 1.1458705357142856e-05 1.5 1.1469866071428571e-05 1.5 1.1470424107142856e-05 0.0 1.1476004464285714e-05 0.0 1.1476562499999999e-05 1.5 1.1487723214285713e-05 1.5 1.1488281249999998e-05 0.0 1.1493861607142856e-05 0.0 1.1494419642857143e-05 1.5 1.1505580357142856e-05 1.5 1.1506138392857142e-05 0.0 1.151171875e-05 0.0 1.1512276785714285e-05 1.5 1.15234375e-05 1.5 1.1523995535714285e-05 0.0 1.1529575892857142e-05 0.0 1.1530133928571427e-05 1.5 1.1541294642857142e-05 1.5 1.1541852678571427e-05 0.0 1.1547433035714285e-05 0.0 1.1547991071428571e-05 1.5 1.1559151785714284e-05 1.5 1.1559709821428571e-05 0.0 1.1565290178571429e-05 0.0 1.1565848214285714e-05 1.5 1.1577008928571428e-05 1.5 1.1577566964285713e-05 0.0 1.1583147321428571e-05 0.0 1.1583705357142856e-05 1.5 1.159486607142857e-05 1.5 1.1595424107142856e-05 0.0 1.1601004464285713e-05 0.0 1.16015625e-05 1.5 1.1612165178571428e-05 1.5 1.1612723214285713e-05 0.0 1.1619419642857142e-05 0.0 1.1619977678571427e-05 1.5 1.163002232142857e-05 1.5 1.1630580357142857e-05 0.0 1.1637276785714285e-05 0.0 1.1637834821428571e-05 1.5 1.1647879464285713e-05 1.5 1.16484375e-05 0.0 1.1655133928571427e-05 0.0 1.1655691964285714e-05 1.5 1.1665736607142857e-05 1.5 1.1666294642857142e-05 0.0 1.1672991071428571e-05 0.0 1.1673549107142856e-05 1.5 1.1683593749999999e-05 1.5 1.1684151785714286e-05 0.0 1.1690848214285713e-05 0.0 1.169140625e-05 1.5 1.1701450892857141e-05 1.5 1.1702008928571428e-05 0.0 1.1708705357142856e-05 0.0 1.1709263392857142e-05 1.5 1.1719308035714285e-05 1.5 1.171986607142857e-05 0.0 1.17265625e-05 0.0 1.1727120535714285e-05 1.5 1.1737165178571428e-05 1.5 1.1737723214285713e-05 0.0 1.1744419642857142e-05 0.0 1.1744977678571427e-05 1.5 1.175502232142857e-05 1.5 1.1755580357142857e-05 0.0 1.1762276785714284e-05 0.0 1.1762834821428571e-05 1.5 1.1772879464285714e-05 1.5 1.1773437499999999e-05 0.0 1.1780133928571428e-05 0.0 1.1780691964285713e-05 1.5 1.1790736607142856e-05 1.5 1.1791294642857141e-05 0.0 1.179799107142857e-05 0.0 1.1798549107142856e-05 1.5 1.1808593749999999e-05 1.5 1.1809151785714285e-05 0.0 1.1815848214285713e-05 0.0 1.181640625e-05 1.5 1.1825892857142856e-05 1.5 1.1826450892857143e-05 0.0 1.1834263392857142e-05 0.0 1.1834821428571427e-05 1.5 1.184375e-05 1.5 1.1844308035714285e-05 0.0 1.1852120535714284e-05 0.0 1.1852678571428571e-05 1.5 1.1861607142857142e-05 1.5 1.1862165178571427e-05 0.0 1.1869977678571428e-05 0.0 1.1870535714285713e-05 1.5 1.1879464285714285e-05 1.5 1.1880022321428571e-05 0.0 1.188783482142857e-05 0.0 1.1888392857142856e-05 1.5 1.1897321428571429e-05 1.5 1.1897879464285714e-05 0.0 1.1905691964285713e-05 0.0 1.190625e-05 1.5 1.1915178571428571e-05 1.5 1.1915736607142856e-05 0.0 1.1923549107142857e-05 0.0 1.1924107142857142e-05 1.5 1.1933035714285713e-05 1.5 1.193359375e-05 0.0 1.194140625e-05 0.0 1.1941964285714284e-05 1.5 1.1950892857142856e-05 1.5 1.1951450892857142e-05 0.0 1.1959263392857142e-05 0.0 1.1959821428571428e-05 1.5 1.196875e-05 1.5 1.1969308035714285e-05 0.0 1.1977120535714286e-05 0.0 1.197767857142857e-05 1.5 1.1986607142857142e-05 1.5 1.1987165178571427e-05 0.0 1.1994977678571428e-05 0.0 1.1995535714285713e-05 1.5 1.2004464285714284e-05 1.5 1.2005022321428571e-05 0.0 1.201283482142857e-05 0.0 1.2013392857142857e-05 1.5 1.2022321428571428e-05 1.5 1.2022879464285713e-05 0.0 1.2030691964285713e-05 0.0 1.203125e-05 1.5 1.2039620535714285e-05 1.5 1.204017857142857e-05 0.0 1.2049107142857142e-05 0.0 1.2049665178571428e-05 1.5 1.2057477678571428e-05 1.5 1.2058035714285713e-05 0.0 1.2066964285714284e-05 0.0 1.206752232142857e-05 1.5 1.207533482142857e-05 1.5 1.2075892857142857e-05 0.0 1.2084821428571428e-05 0.0 1.2085379464285713e-05 1.5 1.2093191964285714e-05 1.5 1.209375e-05 0.0 1.210267857142857e-05 0.0 1.2103236607142857e-05 1.5 1.2111049107142856e-05 1.5 1.2111607142857142e-05 0.0 1.2120535714285713e-05 0.0 1.212109375e-05 1.5 1.2128906249999999e-05 1.5 1.2129464285714286e-05 0.0 1.2138392857142857e-05 0.0 1.2138950892857142e-05 1.5 1.2146763392857143e-05 1.5 1.2147321428571428e-05 0.0 1.2156249999999999e-05 0.0 1.2156808035714284e-05 1.5 1.2164620535714285e-05 1.5 1.216517857142857e-05 0.0 1.2174107142857141e-05 0.0 1.2174665178571428e-05 1.5 1.2182477678571427e-05 1.5 1.2183035714285714e-05 0.0 1.2191964285714285e-05 0.0 1.219252232142857e-05 1.5 1.220033482142857e-05 1.5 1.2200892857142857e-05 0.0 1.2209821428571428e-05 0.0 1.2210379464285713e-05 1.5 1.2218191964285714e-05 1.5 1.2218749999999999e-05 0.0 1.222767857142857e-05 0.0 1.2228236607142857e-05 1.5 1.2236049107142856e-05 1.5 1.2236607142857141e-05 0.0 1.2245535714285714e-05 0.0 1.2246093749999999e-05 1.5 1.2253348214285713e-05 1.5 1.2253906249999998e-05 0.0 1.2263950892857141e-05 0.0 1.2264508928571428e-05 1.5 1.2271205357142856e-05 1.5 1.2271763392857142e-05 0.0 1.2281808035714285e-05 0.0 1.228236607142857e-05 1.5 1.22890625e-05 1.5 1.2289620535714285e-05 0.0 1.2299665178571428e-05 0.0 1.2300223214285713e-05 1.5 1.2306919642857142e-05 1.5 1.2307477678571427e-05 0.0 1.231752232142857e-05 0.0 1.2318080357142857e-05 1.5 1.2324776785714284e-05 1.5 1.2325334821428571e-05 0.0 1.2335379464285714e-05 0.0 1.2335937499999999e-05 1.5 1.2342633928571428e-05 1.5 1.2343191964285713e-05 0.0 1.2353236607142856e-05 0.0 1.2353794642857141e-05 1.5 1.236049107142857e-05 1.5 1.2361049107142856e-05 0.0 1.2371093749999999e-05 0.0 1.2371651785714285e-05 1.5 1.2378348214285713e-05 1.5 1.237890625e-05 0.0 1.2388950892857143e-05 0.0 1.2389508928571428e-05 1.5 1.2396205357142857e-05 1.5 1.2396763392857142e-05 0.0 1.2406808035714285e-05 0.0 1.240736607142857e-05 1.5 1.24140625e-05 1.5 1.2414620535714284e-05 0.0 1.2424665178571427e-05 0.0 1.2425223214285714e-05 1.5 1.2431919642857142e-05 1.5 1.2432477678571428e-05 0.0 1.244252232142857e-05 0.0 1.2443080357142856e-05 1.5 1.2449776785714284e-05 1.5 1.245033482142857e-05 0.0 1.2460379464285714e-05 0.0 1.2460937499999999e-05 1.5 1.2467633928571428e-05 1.5 1.2468191964285713e-05 0.0 1.2478794642857141e-05 0.0 1.2479352678571428e-05 1.5 1.2484933035714285e-05 1.5 1.248549107142857e-05 0.0 1.2496651785714285e-05 0.0 1.249720982142857e-05 1.5 1.2502790178571428e-05 1.5 1.2503348214285713e-05 0.0 1.2514508928571427e-05 0.0 1.2515066964285714e-05 1.5 1.252064732142857e-05 1.5 1.2521205357142857e-05 0.0 1.253236607142857e-05 0.0 1.2532924107142857e-05 1.5 1.2538504464285714e-05 1.5 1.2539062499999999e-05 0.0 1.2550223214285714e-05 0.0 1.2550781249999999e-05 1.5 1.2556361607142856e-05 1.5 1.2556919642857141e-05 0.0 1.2568080357142856e-05 0.0 1.2568638392857141e-05 1.5 1.2574218749999999e-05 1.5 1.2574776785714285e-05 0.0 1.2585937499999998e-05 0.0 1.2586495535714285e-05 1.5 1.2592075892857143e-05 1.5 1.2592633928571428e-05 0.0 1.2603794642857142e-05 0.0 1.2604352678571428e-05 1.5 1.2609933035714285e-05 1.5 1.261049107142857e-05 0.0 1.2621651785714285e-05 0.0 1.262220982142857e-05 1.5 1.2627790178571427e-05 1.5 1.2628348214285714e-05 0.0 1.2639508928571427e-05 0.0 1.2640066964285714e-05 1.5 1.2645647321428571e-05 1.5 1.2646205357142856e-05 0.0 1.2657366071428571e-05 0.0 1.2657924107142856e-05 1.5 1.2663504464285714e-05 1.5 1.2664062499999999e-05 0.0 1.2675223214285713e-05 0.0 1.2675781249999999e-05 1.5 1.2681361607142856e-05 1.5 1.2681919642857143e-05 0.0 1.2693080357142856e-05 0.0 1.2693638392857143e-05 1.5 1.269921875e-05 1.5 1.2699776785714285e-05 0.0 1.2711495535714285e-05 0.0 1.271205357142857e-05 1.5 1.2716517857142856e-05 1.5 1.2717075892857142e-05 0.0 1.2729352678571427e-05 0.0 1.2729910714285714e-05 1.5 1.2734375e-05 1.5 1.2734933035714285e-05 0.0 1.2747209821428571e-05 0.0 1.2747767857142856e-05 1.5 1.2752232142857142e-05 1.5 1.2752790178571427e-05 0.0 1.2765066964285714e-05 0.0 1.2765624999999999e-05 1.5 1.2770089285714284e-05 1.5 1.2770647321428571e-05 0.0 1.2782924107142856e-05 0.0 1.2783482142857143e-05 1.5 1.2787946428571428e-05 1.5 1.2788504464285713e-05 0.0 1.280078125e-05 0.0 1.2801339285714285e-05 1.5 1.280580357142857e-05 1.5 1.2806361607142856e-05 0.0 1.2818638392857142e-05 0.0 1.2819196428571427e-05 1.5 1.2823660714285713e-05 1.5 1.282421875e-05 0.0 1.2836495535714285e-05 0.0 1.2837053571428571e-05 1.5 1.2841517857142857e-05 1.5 1.2842075892857142e-05 0.0 1.2854352678571427e-05 0.0 1.2854910714285714e-05 1.5 1.2859375e-05 1.5 1.2859933035714284e-05 0.0 1.2872209821428571e-05 0.0 1.2872767857142856e-05 1.5 1.2877232142857141e-05 1.5 1.2877790178571428e-05 0.0 1.2890066964285713e-05 0.0 1.2890624999999998e-05 1.5 1.2895089285714286e-05 1.5 1.289564732142857e-05 0.0 1.2907924107142855e-05 0.0 1.2908482142857142e-05 1.5 1.2912946428571428e-05 1.5 1.2913504464285713e-05 0.0 1.292578125e-05 0.0 1.2926339285714285e-05 1.5 1.293080357142857e-05 1.5 1.2931361607142857e-05 0.0 1.2943638392857142e-05 0.0 1.2944196428571427e-05 1.5 1.2948660714285714e-05 1.5 1.294921875e-05 0.0 1.2961495535714284e-05 0.0 1.2962053571428571e-05 1.5 1.2966517857142856e-05 1.5 1.2967075892857142e-05 0.0 1.2979910714285713e-05 0.0 1.2980468749999998e-05 1.5 1.2983816964285714e-05 1.5 1.2984374999999999e-05 0.0 1.2997767857142856e-05 0.0 1.2998325892857142e-05 1.5 1.3001674107142856e-05 1.5 1.3002232142857141e-05 0.0 1.3015625e-05 0.0 1.3016183035714285e-05 1.5 1.3019531249999998e-05 1.5 1.3020089285714285e-05 0.0 1.3033482142857142e-05 0.0 1.3034040178571427e-05 1.5 1.3037388392857142e-05 1.5 1.3037946428571427e-05 0.0 1.3051339285714284e-05 0.0 1.3051897321428571e-05 1.5 1.3055245535714285e-05 1.5 1.305580357142857e-05 0.0 1.3069196428571428e-05 0.0 1.3069754464285713e-05 1.5 1.3073102678571427e-05 1.5 1.3073660714285714e-05 0.0 1.308705357142857e-05 0.0 1.3087611607142856e-05 1.5 1.3090959821428571e-05 1.5 1.3091517857142856e-05 0.0 1.3104910714285713e-05 0.0 1.310546875e-05 1.5 1.3108816964285713e-05 1.5 1.3109374999999998e-05 0.0 1.3122767857142857e-05 0.0 1.3123325892857142e-05 1.5 1.3126674107142856e-05 1.5 1.3127232142857142e-05 0.0 1.3140625e-05 0.0 1.3141183035714284e-05 1.5 1.314453125e-05 1.5 1.3145089285714285e-05 0.0 1.3158482142857142e-05 0.0 1.3159040178571428e-05 1.5 1.3162388392857142e-05 1.5 1.3162946428571427e-05 0.0 1.3176339285714286e-05 0.0 1.317689732142857e-05 1.5 1.3180245535714284e-05 1.5 1.3180803571428571e-05 0.0 1.3194196428571428e-05 0.0 1.3194754464285713e-05 1.5 1.3198102678571428e-05 1.5 1.3198660714285713e-05 0.0 1.321205357142857e-05 0.0 1.3212611607142857e-05 1.5 1.321595982142857e-05 1.5 1.3216517857142856e-05 0.0 1.3229910714285713e-05 0.0 1.323046875e-05 1.5 1.3233816964285713e-05 1.5 1.3234375e-05 0.0 1.3247767857142857e-05 0.0 1.3248325892857142e-05 1.5 1.3251674107142855e-05 1.5 1.3252232142857142e-05 0.0 1.3265624999999999e-05 0.0 1.3266183035714284e-05 1.5 1.326953125e-05 1.5 1.3270089285714284e-05 0.0 1.3283482142857141e-05 0.0 1.3284040178571428e-05 1.5 1.3287388392857142e-05 1.5 1.3287946428571427e-05 0.0 1.330189732142857e-05 0.0 1.3302455357142855e-05 1.5 1.3304687499999999e-05 1.5 1.3305245535714284e-05 0.0 1.3319754464285713e-05 0.0 1.33203125e-05 1.5 1.3322544642857141e-05 1.5 1.3323102678571428e-05 0.0 1.3337611607142857e-05 0.0 1.3338169642857142e-05 1.5 1.3340401785714285e-05 1.5 1.334095982142857e-05 0.0 1.3355468749999999e-05 0.0 1.3356026785714284e-05 1.5 1.3358258928571428e-05 1.5 1.3358816964285713e-05 0.0 1.3373325892857141e-05 0.0 1.3373883928571428e-05 1.5 1.337611607142857e-05 1.5 1.3376674107142857e-05 0.0 1.3391183035714285e-05 0.0 1.339174107142857e-05 1.5 1.3393973214285714e-05 1.5 1.3394531249999999e-05 0.0 1.3409040178571428e-05 0.0 1.3409598214285713e-05 1.5 1.3411830357142856e-05 1.5 1.3412388392857141e-05 0.0 1.342689732142857e-05 0.0 1.3427455357142857e-05 1.5 1.3429687499999999e-05 1.5 1.3430245535714285e-05 0.0 1.3444754464285714e-05 0.0 1.3445312499999999e-05 1.5 1.3447544642857143e-05 1.5 1.3448102678571428e-05 0.0 1.3462611607142856e-05 0.0 1.3463169642857141e-05 1.5 1.3465401785714285e-05 1.5 1.346595982142857e-05 0.0 1.3480468749999999e-05 0.0 1.3481026785714285e-05 1.5 1.3483258928571427e-05 1.5 1.3483816964285714e-05 0.0 1.3498325892857143e-05 0.0 1.3498883928571428e-05 1.5 1.350111607142857e-05 1.5 1.3501674107142856e-05 0.0 1.3516183035714285e-05 0.0 1.351674107142857e-05 1.5 1.3518973214285714e-05 1.5 1.3519531249999999e-05 0.0 1.3534040178571427e-05 0.0 1.3534598214285714e-05 1.5 1.3536830357142856e-05 1.5 1.3537388392857143e-05 0.0 1.3551897321428571e-05 0.0 1.3552455357142856e-05 1.5 1.3554687499999998e-05 1.5 1.3555245535714285e-05 0.0 1.3569754464285714e-05 0.0 1.3570312499999999e-05 1.5 1.3572544642857142e-05 1.5 1.3573102678571427e-05 0.0 1.3587611607142856e-05 0.0 1.3588169642857143e-05 1.5 1.3590401785714285e-05 1.5 1.359095982142857e-05 0.0 1.3605468749999998e-05 0.0 1.3606026785714285e-05 1.5 1.3608258928571427e-05 1.5 1.3608816964285714e-05 0.0 1.3623325892857142e-05 0.0 1.3623883928571427e-05 1.5 1.3626116071428571e-05 1.5 1.3626674107142856e-05 0.0 1.3641183035714285e-05 0.0 1.364174107142857e-05 1.5 1.3643973214285713e-05 1.5 1.3644531249999998e-05 0.0 1.3659040178571427e-05 0.0 1.3659598214285714e-05 1.5 1.3661830357142856e-05 1.5 1.3662388392857142e-05 0.0 1.3676897321428571e-05 0.0 1.3677455357142856e-05 1.5 1.36796875e-05 1.5 1.3680245535714285e-05 0.0 1.3694754464285713e-05 0.0 1.3695312499999998e-05 1.5 1.3697544642857142e-05 1.5 1.3698102678571427e-05 0.0 1.3712611607142856e-05 0.0 1.3713169642857142e-05 1.5 1.3715401785714284e-05 1.5 1.3715959821428571e-05 0.0 1.373046875e-05 0.0 1.3731026785714285e-05 1.5 1.3733258928571428e-05 1.5 1.3733816964285713e-05 0.0 1.3748325892857142e-05 0.0 1.3748883928571427e-05 1.5 1.375111607142857e-05 1.5 1.3751674107142856e-05 0.0 1.3766183035714284e-05 0.0 1.3766741071428571e-05 1.5 1.3768973214285713e-05 1.5 1.376953125e-05 0.0 1.3784040178571428e-05 0.0 1.3784598214285713e-05 1.5 1.3786830357142857e-05 1.5 1.3787388392857142e-05 0.0 1.380189732142857e-05 0.0 1.3802455357142856e-05 1.5 1.38046875e-05 1.5 1.3805245535714284e-05 0.0 1.3819754464285713e-05 0.0 1.38203125e-05 1.5 1.3822544642857142e-05 1.5 1.3823102678571428e-05 0.0 1.3837611607142857e-05 0.0 1.3838169642857142e-05 1.5 1.3840401785714284e-05 1.5 1.384095982142857e-05 0.0 1.385546875e-05 0.0 1.3856026785714284e-05 1.5 1.3858258928571428e-05 1.5 1.3858816964285713e-05 0.0 1.3873325892857142e-05 0.0 1.3873883928571428e-05 1.5 1.387611607142857e-05 1.5 1.3876674107142855e-05 0.0 1.3891183035714284e-05 0.0 1.389174107142857e-05 1.5 1.3893973214285713e-05 1.5 1.389453125e-05 0.0 1.3909040178571428e-05 0.0 1.3909598214285713e-05 1.5 1.3911830357142857e-05 1.5 1.3912388392857142e-05 0.0 1.392689732142857e-05 0.0 1.3927455357142857e-05 1.5 1.3929687499999999e-05 1.5 1.3930245535714284e-05 0.0 1.3944754464285713e-05 0.0 1.39453125e-05 1.5 1.3947544642857141e-05 1.5 1.3948102678571428e-05 0.0 1.3962611607142857e-05 0.0 1.3963169642857142e-05 1.5 1.3965401785714285e-05 1.5 1.396595982142857e-05 0.0 1.3980468749999999e-05 0.0 1.3981026785714284e-05 1.5 1.3983258928571428e-05 1.5 1.3983816964285713e-05 0.0 1.3998325892857141e-05 0.0 1.3998883928571428e-05 1.5 1.400111607142857e-05 1.5 1.4001674107142857e-05 0.0 1.4016183035714285e-05 0.0 1.401674107142857e-05 1.5 1.4018973214285714e-05 1.5 1.4019531249999999e-05 0.0 1.4034040178571428e-05 0.0 1.4034598214285713e-05 1.5 1.4036830357142856e-05 1.5 1.4037388392857141e-05 0.0 1.405189732142857e-05 0.0 1.4052455357142857e-05 1.5 1.4054687499999999e-05 1.5 1.4055245535714285e-05 0.0 1.4069754464285714e-05 0.0 1.4070312499999999e-05 1.5 1.4072544642857143e-05 1.5 1.4073102678571428e-05 0.0 1.4087611607142856e-05 0.0 1.4088169642857141e-05 1.5 1.4090401785714285e-05 1.5 1.409095982142857e-05 0.0 1.4105468749999999e-05 0.0 1.4106026785714285e-05 1.5 1.4108258928571427e-05 1.5 1.4108816964285714e-05 0.0 1.4123325892857143e-05 0.0 1.4123883928571428e-05 1.5 1.4126116071428571e-05 1.5 1.4126674107142856e-05 0.0 1.4141183035714285e-05 0.0 1.414174107142857e-05 1.5 1.4143973214285714e-05 1.5 1.4144531249999999e-05 0.0 1.4159040178571427e-05 0.0 1.4159598214285714e-05 1.5 1.4161830357142856e-05 1.5 1.4162388392857143e-05 0.0 1.4176897321428571e-05 0.0 1.4177455357142856e-05 1.5 1.4179687499999998e-05 1.5 1.4180245535714285e-05 0.0 1.4194754464285714e-05 0.0 1.4195312499999999e-05 1.5 1.4197544642857142e-05 1.5 1.4198102678571427e-05 0.0 1.4212611607142856e-05 0.0 1.4213169642857143e-05 1.5 1.4215401785714285e-05 1.5 1.421595982142857e-05 0.0 1.4230468749999998e-05 0.0 1.4231026785714285e-05 1.5 1.4233258928571427e-05 1.5 1.4233816964285714e-05 0.0 1.4248325892857142e-05 0.0 1.4248883928571427e-05 1.5 1.4251116071428571e-05 1.5 1.4251674107142856e-05 0.0 1.4266183035714285e-05 0.0 1.426674107142857e-05 1.5 1.4268973214285713e-05 1.5 1.4269531249999998e-05 0.0 1.4284040178571427e-05 0.0 1.4284598214285714e-05 1.5 1.4286830357142856e-05 1.5 1.4287388392857142e-05 0.0 1.4301897321428571e-05 0.0 1.4302455357142856e-05 1.5 1.43046875e-05 1.5 1.4305245535714285e-05 0.0 1.4319754464285713e-05 0.0 1.4320312499999998e-05 1.5 1.4322544642857142e-05 1.5 1.4323102678571427e-05 0.0 1.4337611607142856e-05 0.0 1.4338169642857142e-05 1.5 1.4340401785714284e-05 1.5 1.4340959821428571e-05 0.0 1.435546875e-05 0.0 1.4356026785714285e-05 1.5 1.4358258928571428e-05 1.5 1.4358816964285713e-05 0.0 1.4373325892857142e-05 0.0 1.4373883928571427e-05 1.5 1.437611607142857e-05 1.5 1.4376674107142856e-05 0.0 1.4391183035714284e-05 0.0 1.4391741071428571e-05 1.5 1.4393973214285713e-05 1.5 1.439453125e-05 0.0 1.4409040178571428e-05 0.0 1.4409598214285713e-05 1.5 1.4411830357142857e-05 1.5 1.4412388392857142e-05 0.0 1.442689732142857e-05 0.0 1.4427455357142856e-05 1.5 1.44296875e-05 1.5 1.4430245535714284e-05 0.0 1.4444754464285713e-05 0.0 1.44453125e-05 1.5 1.4447544642857142e-05 1.5 1.4448102678571428e-05 0.0 1.4462611607142857e-05 0.0 1.4463169642857142e-05 1.5 1.4465401785714284e-05 1.5 1.446595982142857e-05 0.0 1.448046875e-05 0.0 1.4481026785714284e-05 1.5 1.4483258928571428e-05 1.5 1.4483816964285713e-05 0.0 1.4498325892857142e-05 0.0 1.4498883928571428e-05 1.5 1.450111607142857e-05 1.5 1.4501674107142855e-05 0.0 1.4516183035714284e-05 0.0 1.451674107142857e-05 1.5 1.4518973214285713e-05 1.5 1.451953125e-05 0.0 1.4534040178571428e-05 0.0 1.4534598214285713e-05 1.5 1.4536830357142857e-05 1.5 1.4537388392857142e-05 0.0 1.455189732142857e-05 0.0 1.4552455357142857e-05 1.5 1.4554687499999999e-05 1.5 1.4555245535714284e-05 0.0 1.4569754464285712e-05 0.0 1.45703125e-05 1.5 1.4572544642857141e-05 1.5 1.4573102678571428e-05 0.0 1.4587611607142857e-05 0.0 1.4588169642857142e-05 1.5 1.4590401785714285e-05 1.5 1.459095982142857e-05 0.0 1.4605468749999999e-05 0.0 1.4606026785714284e-05 1.5 1.4608258928571428e-05 1.5 1.4608816964285713e-05 0.0 1.4623325892857141e-05 0.0 1.4623883928571428e-05 1.5 1.462611607142857e-05 1.5 1.4626674107142857e-05 0.0 1.4641183035714285e-05 0.0 1.464174107142857e-05 1.5 1.4643973214285714e-05 1.5 1.4644531249999999e-05 0.0 1.4659040178571428e-05 0.0 1.4659598214285713e-05 1.5 1.4661830357142856e-05 1.5 1.4662388392857141e-05 0.0 1.467689732142857e-05 0.0 1.4677455357142857e-05 1.5 1.4679687499999999e-05 1.5 1.4680245535714285e-05 0.0 1.4694754464285714e-05 0.0 1.4695312499999999e-05 1.5 1.4697544642857143e-05 1.5 1.4698102678571428e-05 0.0 1.4712611607142856e-05 0.0 1.4713169642857141e-05 1.5 1.4715401785714285e-05 1.5 1.471595982142857e-05 0.0 1.4730468749999998e-05 0.0 1.4731026785714285e-05 1.5 1.4733258928571427e-05 1.5 1.4733816964285714e-05 0.0 1.4748325892857143e-05 0.0 1.4748883928571428e-05 1.5 1.4751116071428571e-05 1.5 1.4751674107142856e-05 0.0 1.4766183035714285e-05 0.0 1.476674107142857e-05 1.5 1.4768973214285714e-05 1.5 1.4769531249999999e-05 0.0 1.4784040178571427e-05 0.0 1.4784598214285714e-05 1.5 1.4786830357142856e-05 1.5 1.4787388392857143e-05 0.0 1.4801339285714284e-05 0.0 1.4801897321428571e-05 1.5 1.4805245535714285e-05 1.5 1.480580357142857e-05 0.0 1.4819196428571427e-05 0.0 1.4819754464285713e-05 1.5 1.4823102678571427e-05 1.5 1.4823660714285714e-05 0.0 1.483705357142857e-05 0.0 1.4837611607142856e-05 1.5 1.484095982142857e-05 1.5 1.4841517857142856e-05 0.0 1.4854910714285713e-05 0.0 1.4855468749999998e-05 1.5 1.4858816964285714e-05 1.5 1.4859374999999999e-05 0.0 1.4872767857142855e-05 0.0 1.4873325892857142e-05 1.5 1.4876674107142856e-05 1.5 1.4877232142857141e-05 0.0 1.4890625e-05 0.0 1.4891183035714284e-05 1.5 1.4894531249999998e-05 1.5 1.4895089285714285e-05 0.0 1.4908482142857142e-05 0.0 1.4909040178571427e-05 1.5 1.4912388392857142e-05 1.5 1.4912946428571427e-05 0.0 1.4926339285714284e-05 0.0 1.492689732142857e-05 1.5 1.4930245535714285e-05 1.5 1.493080357142857e-05 0.0 1.4944196428571428e-05 0.0 1.4944754464285713e-05 1.5 1.4948102678571427e-05 1.5 1.4948660714285714e-05 0.0 1.496205357142857e-05 0.0 1.4962611607142855e-05 1.5 1.4965959821428571e-05 1.5 1.4966517857142856e-05 0.0 1.4979910714285713e-05 0.0 1.498046875e-05 1.5 1.4983816964285713e-05 1.5 1.4984374999999998e-05 0.0 1.4997767857142857e-05 0.0 1.4998325892857142e-05 1.5 1.5001674107142856e-05 1.5 1.5002232142857142e-05 0.0 1.5015624999999999e-05 0.0 1.5016183035714284e-05 1.5 1.501953125e-05 1.5 1.5020089285714285e-05 0.0 1.5033482142857141e-05 0.0 1.5034040178571428e-05 1.5 1.5037388392857142e-05 1.5 1.5037946428571427e-05 0.0 1.5051339285714285e-05 0.0 1.505189732142857e-05 1.5 1.5055245535714284e-05 1.5 1.5055803571428571e-05 0.0 1.5069196428571428e-05 0.0 1.5069754464285713e-05 1.5 1.5073102678571428e-05 1.5 1.5073660714285713e-05 0.0 1.508705357142857e-05 0.0 1.5087611607142857e-05 1.5 1.509095982142857e-05 1.5 1.5091517857142856e-05 0.0 1.5104910714285712e-05 0.0 1.5105468749999999e-05 1.5 1.5108816964285713e-05 1.5 1.5109375e-05 0.0 1.512220982142857e-05 0.0 1.5122767857142856e-05 1.5 1.5127232142857142e-05 1.5 1.5127790178571427e-05 0.0 1.5140066964285714e-05 0.0 1.5140624999999999e-05 1.5 1.5145089285714284e-05 1.5 1.5145647321428571e-05 0.0 1.5157924107142856e-05 0.0 1.5158482142857141e-05 1.5 1.5162946428571428e-05 1.5 1.5163504464285713e-05 0.0 1.5175781249999998e-05 0.0 1.5176339285714285e-05 1.5 1.518080357142857e-05 1.5 1.5181361607142856e-05 0.0 1.5193638392857142e-05 0.0 1.5194196428571427e-05 1.5 1.5198660714285713e-05 1.5 1.519921875e-05 0.0 1.5211495535714285e-05 0.0 1.521205357142857e-05 1.5 1.5216517857142855e-05 1.5 1.5217075892857142e-05 0.0 1.5229352678571427e-05 0.0 1.5229910714285714e-05 1.5 1.5234375e-05 1.5 1.5234933035714284e-05 0.0 1.5247209821428571e-05 0.0 1.5247767857142856e-05 1.5 1.5252232142857142e-05 1.5 1.5252790178571427e-05 0.0 1.5265066964285713e-05 0.0 1.5265625e-05 1.5 1.5270089285714284e-05 1.5 1.527064732142857e-05 0.0 1.5282924107142856e-05 0.0 1.5283482142857142e-05 1.5 1.5287946428571426e-05 1.5 1.5288504464285713e-05 0.0 1.5300781249999998e-05 0.0 1.5301339285714285e-05 1.5 1.5305803571428572e-05 1.5 1.5306361607142855e-05 0.0 1.531863839285714e-05 0.0 1.5319196428571427e-05 1.5 1.5323660714285714e-05 1.5 1.5324218749999998e-05 0.0 1.5336495535714286e-05 0.0 1.533705357142857e-05 1.5 1.5341517857142857e-05 1.5 1.5342075892857143e-05 0.0 1.535435267857143e-05 0.0 1.535491071428571e-05 1.5 1.5359375e-05 1.5 1.5359933035714286e-05 0.0 1.537220982142857e-05 0.0 1.5372767857142857e-05 1.5 1.537723214285714e-05 1.5 1.5377790178571428e-05 0.0 1.5389508928571426e-05 0.0 1.5390066964285713e-05 1.5 1.539564732142857e-05 1.5 1.5396205357142857e-05 0.0 1.5407366071428572e-05 0.0 1.5407924107142855e-05 1.5 1.5413504464285713e-05 1.5 1.54140625e-05 0.0 1.5425223214285714e-05 0.0 1.5425781249999998e-05 1.5 1.5431361607142855e-05 1.5 1.5431919642857142e-05 0.0 1.5443080357142857e-05 0.0 1.5443638392857143e-05 1.5 1.5449218749999997e-05 1.5 1.5449776785714284e-05 0.0 1.54609375e-05 0.0 1.5461495535714286e-05 1.5 1.5467075892857143e-05 1.5 1.5467633928571426e-05 0.0 1.547879464285714e-05 0.0 1.5479352678571428e-05 1.5 1.5484933035714285e-05 1.5 1.548549107142857e-05 0.0 1.5496651785714284e-05 0.0 1.549720982142857e-05 1.5 1.5502790178571428e-05 1.5 1.5503348214285714e-05 0.0 1.5514508928571426e-05 0.0 1.5515066964285713e-05 1.5 1.552064732142857e-05 1.5 1.5521205357142857e-05 0.0 1.553236607142857e-05 0.0 1.5532924107142855e-05 1.5 1.5538504464285712e-05 1.5 1.55390625e-05 0.0 1.5550223214285714e-05 0.0 1.5550781249999997e-05 1.5 1.5556361607142855e-05 1.5 1.555691964285714e-05 0.0 1.5568080357142856e-05 0.0 1.5568638392857143e-05 1.5 1.557421875e-05 1.5 1.5574776785714284e-05 0.0 1.55859375e-05 0.0 1.5586495535714285e-05 1.5 1.5592075892857143e-05 1.5 1.5592633928571426e-05 0.0 1.560379464285714e-05 0.0 1.5604352678571428e-05 1.5 1.5609933035714285e-05 1.5 1.5610491071428572e-05 0.0 1.562109375e-05 0.0 1.5621651785714283e-05 1.5 1.5628348214285714e-05 1.5 1.5628906249999997e-05 0.0 1.5638950892857142e-05 0.0 1.563950892857143e-05 1.5 1.5646205357142856e-05 1.5 1.5646763392857143e-05 0.0 1.5656808035714284e-05 0.0 1.565736607142857e-05 1.5 1.56640625e-05 1.5 1.5664620535714285e-05 0.0 1.5674665178571427e-05 0.0 1.5675223214285714e-05 1.5 1.568191964285714e-05 1.5 1.5682477678571428e-05 0.0 1.569252232142857e-05 0.0 1.5693080357142856e-05 1.5 1.5699776785714283e-05 1.5 1.570033482142857e-05 0.0 1.5710379464285715e-05 0.0 1.5710937499999998e-05 1.5 1.571763392857143e-05 1.5 1.5718191964285712e-05 0.0 1.5728236607142857e-05 0.0 1.572879464285714e-05 1.5 1.573549107142857e-05 1.5 1.5736049107142855e-05 0.0 1.574609375e-05 0.0 1.5746651785714286e-05 1.5 1.5753348214285714e-05 1.5 1.575390625e-05 0.0 1.5763950892857142e-05 0.0 1.576450892857143e-05 1.5 1.5771205357142856e-05 1.5 1.5771763392857143e-05 0.0 1.5781808035714284e-05 0.0 1.578236607142857e-05 1.5 1.57890625e-05 1.5 1.5789620535714285e-05 0.0 1.5799665178571426e-05 0.0 1.5800223214285713e-05 1.5 1.580691964285714e-05 1.5 1.5807477678571427e-05 0.0 1.581752232142857e-05 0.0 1.5818080357142856e-05 1.5 1.5824776785714283e-05 1.5 1.582533482142857e-05 0.0 1.5835379464285714e-05 0.0 1.5835937499999998e-05 1.5 1.5843191964285712e-05 1.5 1.584375e-05 0.0 1.585267857142857e-05 0.0 1.5853236607142857e-05 1.5 1.5861049107142854e-05 1.5 1.586160714285714e-05 0.0 1.5870535714285712e-05 0.0 1.587109375e-05 1.5 1.587890625e-05 1.5 1.5879464285714284e-05 0.0 1.5888392857142855e-05 0.0 1.588895089285714e-05 1.5 1.5896763392857142e-05 1.5 1.5897321428571426e-05 0.0 1.590625e-05 0.0 1.5906808035714284e-05 1.5 1.5914620535714285e-05 1.5 1.591517857142857e-05 0.0 1.5924107142857143e-05 0.0 1.5924665178571426e-05 1.5 1.5932477678571427e-05 1.5 1.5933035714285714e-05 0.0 1.5941964285714285e-05 0.0 1.5942522321428572e-05 1.5 1.595033482142857e-05 1.5 1.5950892857142856e-05 0.0 1.5959821428571427e-05 0.0 1.5960379464285714e-05 1.5 1.5968191964285712e-05 1.5 1.596875e-05 0.0 1.597767857142857e-05 0.0 1.5978236607142856e-05 1.5 1.5986049107142857e-05 1.5 1.598660714285714e-05 0.0 1.5995535714285712e-05 0.0 1.599609375e-05 1.5 1.600390625e-05 1.5 1.6004464285714283e-05 0.0 1.6013392857142854e-05 0.0 1.601395089285714e-05 1.5 1.6021763392857142e-05 1.5 1.602232142857143e-05 0.0 1.603125e-05 0.0 1.6031808035714283e-05 1.5 1.6039620535714284e-05 1.5 1.604017857142857e-05 0.0 1.6049107142857142e-05 0.0 1.6049665178571426e-05 1.5 1.6058035714285714e-05 1.5 1.605859375e-05 0.0 1.6066406249999998e-05 0.0 1.6066964285714285e-05 1.5 1.6075892857142856e-05 1.5 1.6076450892857143e-05 0.0 1.608426339285714e-05 0.0 1.6084821428571427e-05 1.5 1.6093749999999998e-05 1.5 1.6094308035714285e-05 0.0 1.6102120535714286e-05 0.0 1.610267857142857e-05 1.5 1.611160714285714e-05 1.5 1.6112165178571427e-05 0.0 1.6119977678571428e-05 0.0 1.612053571428571e-05 1.5 1.6129464285714286e-05 1.5 1.613002232142857e-05 0.0 1.613783482142857e-05 0.0 1.6138392857142857e-05 1.5 1.614732142857143e-05 1.5 1.6147879464285712e-05 0.0 1.6155691964285713e-05 0.0 1.615625e-05 1.5 1.616517857142857e-05 1.5 1.6165736607142858e-05 0.0 1.6173549107142855e-05 0.0 1.6174107142857142e-05 1.5 1.6183035714285713e-05 1.5 1.618359375e-05 0.0 1.6191406249999998e-05 0.0 1.6191964285714284e-05 1.5 1.6200892857142855e-05 1.5 1.6201450892857142e-05 0.0 1.6209263392857143e-05 0.0 1.6209821428571427e-05 1.5 1.6218749999999998e-05 1.5 1.6219308035714285e-05 0.0 1.6227120535714286e-05 0.0 1.622767857142857e-05 1.5 1.623660714285714e-05 1.5 1.6237165178571427e-05 0.0 1.6244977678571428e-05 0.0 1.6245535714285715e-05 1.5 1.6254464285714286e-05 1.5 1.625502232142857e-05 0.0 1.626283482142857e-05 0.0 1.6263392857142857e-05 1.5 1.627287946428571e-05 1.5 1.6273437499999998e-05 0.0 1.6280133928571426e-05 0.0 1.6280691964285713e-05 1.5 1.6290736607142857e-05 1.5 1.629129464285714e-05 0.0 1.629799107142857e-05 0.0 1.6298549107142855e-05 1.5 1.630859375e-05 1.5 1.6309151785714283e-05 0.0 1.6315848214285714e-05 0.0 1.6316406249999997e-05 1.5 1.6326450892857142e-05 1.5 1.632700892857143e-05 0.0 1.6333705357142856e-05 0.0 1.6334263392857143e-05 1.5 1.6344308035714284e-05 1.5 1.634486607142857e-05 0.0 1.63515625e-05 0.0 1.6352120535714285e-05 1.5 1.6362165178571427e-05 1.5 1.6362723214285713e-05 0.0 1.636941964285714e-05 0.0 1.6369977678571428e-05 1.5 1.638002232142857e-05 1.5 1.6380580357142856e-05 0.0 1.6387276785714283e-05 0.0 1.638783482142857e-05 1.5 1.6397879464285715e-05 1.5 1.6398437499999998e-05 0.0 1.640513392857143e-05 0.0 1.6405691964285712e-05 1.5 1.6415736607142857e-05 1.5 1.641629464285714e-05 0.0 1.642299107142857e-05 0.0 1.6423549107142855e-05 1.5 1.643359375e-05 1.5 1.6434151785714286e-05 0.0 1.6440848214285714e-05 0.0 1.644140625e-05 1.5 1.645145089285714e-05 1.5 1.645200892857143e-05 0.0 1.6458705357142856e-05 0.0 1.6459263392857143e-05 1.5 1.6469308035714284e-05 1.5 1.646986607142857e-05 0.0 1.6476562499999998e-05 0.0 1.6477120535714285e-05 1.5 1.6487723214285713e-05 1.5 1.648828125e-05 0.0 1.6493861607142857e-05 0.0 1.649441964285714e-05 1.5 1.6505580357142855e-05 1.5 1.6506138392857142e-05 0.0 1.651171875e-05 0.0 1.6512276785714286e-05 1.5 1.6523437499999998e-05 1.5 1.6523995535714284e-05 0.0 1.6529575892857142e-05 0.0 1.653013392857143e-05 1.5 1.6541294642857143e-05 1.5 1.6541852678571427e-05 0.0 1.6547433035714284e-05 0.0 1.654799107142857e-05 1.5 1.6559151785714286e-05 1.5 1.655970982142857e-05 0.0 1.6565290178571426e-05 0.0 1.6565848214285713e-05 1.5 1.6577008928571428e-05 1.5 1.6577566964285715e-05 0.0 1.658314732142857e-05 0.0 1.6583705357142855e-05 1.5 1.659486607142857e-05 1.5 1.6595424107142857e-05 0.0 1.6601004464285714e-05 0.0 1.6601562499999998e-05 1.5 1.6612723214285713e-05 1.5 1.661328125e-05 0.0 1.6618861607142857e-05 0.0 1.661941964285714e-05 1.5 1.6630580357142855e-05 1.5 1.663113839285714e-05 0.0 1.663671875e-05 0.0 1.6637276785714286e-05 1.5 1.6648437499999997e-05 1.5 1.6648995535714284e-05 0.0 1.665457589285714e-05 0.0 1.6655133928571428e-05 1.5 1.6666294642857143e-05 1.5 1.6666852678571426e-05 0.0 1.6672433035714284e-05 0.0 1.667299107142857e-05 1.5 1.6684151785714285e-05 1.5 1.668470982142857e-05 0.0 1.6690290178571426e-05 0.0 1.6690848214285713e-05 1.5 1.6702008928571428e-05 1.5 1.6702566964285714e-05 0.0 1.6708147321428572e-05 0.0 1.6708705357142855e-05 1.5 1.6720424107142857e-05 1.5 1.672098214285714e-05 0.0 1.6725446428571427e-05 0.0 1.6726004464285714e-05 1.5 1.673828125e-05 1.5 1.6738839285714286e-05 0.0 1.674330357142857e-05 0.0 1.6743861607142856e-05 1.5 1.675613839285714e-05 1.5 1.6756696428571428e-05 0.0 1.6761160714285712e-05 0.0 1.676171875e-05 1.5 1.6773995535714284e-05 1.5 1.677455357142857e-05 0.0 1.6779017857142854e-05 0.0 1.677957589285714e-05 1.5 1.6791852678571426e-05 1.5 1.6792410714285713e-05 0.0 1.6796875e-05 0.0 1.6797433035714283e-05 1.5 1.680970982142857e-05 1.5 1.6810267857142855e-05 0.0 1.6814732142857142e-05 0.0 1.6815290178571426e-05 1.5 1.6827566964285714e-05 1.5 1.6828124999999997e-05 0.0 1.6832589285714285e-05 0.0 1.683314732142857e-05 1.5 1.6845424107142856e-05 1.5 1.6845982142857143e-05 0.0 1.6850446428571427e-05 0.0 1.6851004464285714e-05 1.5 1.686328125e-05 1.5 1.6863839285714285e-05 0.0 1.686830357142857e-05 0.0 1.6868861607142856e-05 1.5 1.688113839285714e-05 1.5 1.6881696428571428e-05 0.0 1.688616071428571e-05 0.0 1.688671875e-05 1.5 1.6898995535714283e-05 1.5 1.689955357142857e-05 0.0 1.6904017857142857e-05 0.0 1.690457589285714e-05 1.5 1.691685267857143e-05 1.5 1.6917410714285712e-05 0.0 1.6921875e-05 0.0 1.6922433035714283e-05 1.5 1.693470982142857e-05 1.5 1.6935267857142855e-05 0.0 1.6939732142857142e-05 0.0 1.694029017857143e-05 1.5 1.6952566964285714e-05 1.5 1.6953125e-05 0.0 1.6957589285714284e-05 0.0 1.695814732142857e-05 1.5 1.6970424107142856e-05 1.5 1.6970982142857143e-05 0.0 1.6975446428571427e-05 0.0 1.6976004464285713e-05 1.5 1.6988839285714285e-05 1.5 1.6989397321428572e-05 0.0 1.6992745535714286e-05 0.0 1.699330357142857e-05 1.5 1.7006696428571427e-05 1.5 1.7007254464285714e-05 0.0 1.7010602678571428e-05 0.0 1.7011160714285715e-05 1.5 1.702455357142857e-05 1.5 1.7025111607142856e-05 0.0 1.702845982142857e-05 0.0 1.7029017857142857e-05 1.5 1.7042410714285712e-05 1.5 1.704296875e-05 0.0 1.7046316964285713e-05 0.0 1.7046875e-05 1.5 1.7060267857142854e-05 1.5 1.706082589285714e-05 0.0 1.7064174107142855e-05 0.0 1.706473214285714e-05 1.5 1.7078125e-05 1.5 1.7078683035714283e-05 0.0 1.7082031249999997e-05 0.0 1.7082589285714284e-05 1.5 1.7095982142857142e-05 1.5 1.7096540178571426e-05 0.0 1.7099888392857143e-05 0.0 1.7100446428571426e-05 1.5 1.7113839285714285e-05 1.5 1.711439732142857e-05 0.0 1.7117745535714285e-05 0.0 1.711830357142857e-05 1.5 1.7131696428571427e-05 1.5 1.7132254464285714e-05 0.0 1.7135602678571428e-05 0.0 1.7136160714285714e-05 1.5 1.714955357142857e-05 1.5 1.7150111607142856e-05 0.0 1.715345982142857e-05 0.0 1.7154017857142857e-05 1.5 1.716741071428571e-05 1.5 1.716796875e-05 0.0 1.7171316964285712e-05 0.0 1.7171875e-05 1.5 1.7185267857142857e-05 1.5 1.718582589285714e-05 0.0 1.7189174107142855e-05 0.0 1.718973214285714e-05 1.5 1.7203125e-05 1.5 1.7203683035714283e-05 0.0 1.720703125e-05 0.0 1.7207589285714284e-05 1.5 1.7220982142857142e-05 1.5 1.722154017857143e-05 0.0 1.7224888392857143e-05 0.0 1.7225446428571426e-05 1.5 1.7238839285714284e-05 1.5 1.723939732142857e-05 0.0 1.7242745535714285e-05 0.0 1.724330357142857e-05 1.5 1.7256696428571427e-05 1.5 1.7257254464285713e-05 0.0 1.7260602678571427e-05 0.0 1.7261160714285714e-05 1.5 1.727455357142857e-05 1.5 1.7275111607142856e-05 0.0 1.727845982142857e-05 0.0 1.7279017857142856e-05 1.5 1.7292410714285715e-05 1.5 1.7292968749999998e-05 0.0 1.7296316964285712e-05 0.0 1.7296875e-05 1.5 1.731082589285714e-05 1.5 1.7311383928571427e-05 0.0 1.731361607142857e-05 0.0 1.7314174107142858e-05 1.5 1.7328683035714286e-05 1.5 1.732924107142857e-05 0.0 1.7331473214285713e-05 0.0 1.733203125e-05 1.5 1.734654017857143e-05 1.5 1.7347098214285712e-05 0.0 1.7349330357142855e-05 0.0 1.7349888392857142e-05 1.5 1.736439732142857e-05 1.5 1.7364955357142858e-05 0.0 1.7367187499999998e-05 0.0 1.7367745535714285e-05 1.5 1.7382254464285713e-05 1.5 1.73828125e-05 0.0 1.738504464285714e-05 0.0 1.7385602678571427e-05 1.5 1.7400111607142855e-05 1.5 1.7400669642857142e-05 0.0 1.7402901785714286e-05 0.0 1.740345982142857e-05 1.5 1.7417968749999998e-05 1.5 1.7418526785714284e-05 0.0 1.7420758928571428e-05 0.0 1.742131696428571e-05 1.5 1.743582589285714e-05 1.5 1.7436383928571427e-05 0.0 1.743861607142857e-05 0.0 1.7439174107142857e-05 1.5 1.7453683035714286e-05 1.5 1.745424107142857e-05 0.0 1.7456473214285713e-05 0.0 1.745703125e-05 1.5 1.7471540178571428e-05 1.5 1.747209821428571e-05 0.0 1.7474330357142855e-05 0.0 1.7474888392857142e-05 1.5 1.748939732142857e-05 1.5 1.7489955357142857e-05 0.0 1.7492187499999997e-05 0.0 1.7492745535714284e-05 1.5 1.7507254464285713e-05 1.5 1.75078125e-05 0.0 1.7510044642857143e-05 0.0 1.7510602678571427e-05 1.5 1.7525111607142855e-05 1.5 1.7525669642857142e-05 0.0 1.7527901785714285e-05 0.0 1.752845982142857e-05 1.5 1.7542968749999997e-05 1.5 1.7543526785714284e-05 0.0 1.7545758928571428e-05 0.0 1.7546316964285715e-05 1.5 1.7560825892857143e-05 1.5 1.7561383928571426e-05 0.0 1.756361607142857e-05 0.0 1.7564174107142857e-05 1.5 1.7578683035714285e-05 1.5 1.757924107142857e-05 0.0 1.7581473214285712e-05 0.0 1.758203125e-05 1.5 1.7596540178571428e-05 1.5 1.7597098214285715e-05 0.0 1.7599330357142855e-05 0.0 1.759988839285714e-05 1.5 1.761439732142857e-05 1.5 1.7614955357142857e-05 0.0 1.7617187499999997e-05 0.0 1.7617745535714284e-05 1.5 1.7632254464285712e-05 1.5 1.76328125e-05 0.0 1.7635044642857143e-05 0.0 1.7635602678571426e-05 1.5 1.7650111607142855e-05 1.5 1.765066964285714e-05 0.0 1.7652901785714285e-05 0.0 1.765345982142857e-05 1.5 1.7667968749999997e-05 1.5 1.7668526785714284e-05 0.0 1.7670758928571427e-05 0.0 1.7671316964285714e-05 1.5 1.7685825892857143e-05 1.5 1.7686383928571426e-05 0.0 1.768861607142857e-05 0.0 1.7689174107142857e-05 1.5 1.7703683035714285e-05 1.5 1.7704241071428572e-05 0.0 1.7706473214285712e-05 0.0 1.770703125e-05 1.5 1.7721540178571427e-05 1.5 1.7722098214285714e-05 0.0 1.7724330357142854e-05 0.0 1.772488839285714e-05 1.5 1.773939732142857e-05 1.5 1.7739955357142856e-05 0.0 1.77421875e-05 0.0 1.7742745535714283e-05 1.5 1.7757254464285712e-05 1.5 1.77578125e-05 0.0 1.7760044642857142e-05 0.0 1.7760602678571426e-05 1.5 1.7775111607142854e-05 1.5 1.777566964285714e-05 0.0 1.7777901785714285e-05 0.0 1.777845982142857e-05 1.5 1.779296875e-05 1.5 1.7793526785714283e-05 0.0 1.7795758928571427e-05 0.0 1.7796316964285714e-05 1.5 1.7810825892857142e-05 1.5 1.7811383928571426e-05 0.0 1.781361607142857e-05 0.0 1.7814174107142856e-05 1.5 1.7828683035714285e-05 1.5 1.782924107142857e-05 0.0 1.7831473214285712e-05 0.0 1.783203125e-05 1.5 1.7846540178571427e-05 1.5 1.7847098214285714e-05 0.0 1.7849330357142857e-05 0.0 1.784988839285714e-05 1.5 1.786439732142857e-05 1.5 1.7864955357142856e-05 0.0 1.78671875e-05 0.0 1.7867745535714283e-05 1.5 1.7882254464285712e-05 1.5 1.78828125e-05 0.0 1.7885044642857142e-05 0.0 1.788560267857143e-05 1.5 1.7900111607142857e-05 1.5 1.790066964285714e-05 0.0 1.7902901785714284e-05 0.0 1.790345982142857e-05 1.5 1.791796875e-05 1.5 1.7918526785714283e-05 0.0 1.7920758928571427e-05 0.0 1.7921316964285713e-05 1.5 1.7935825892857142e-05 1.5 1.793638392857143e-05 0.0 1.793861607142857e-05 0.0 1.7939174107142856e-05 1.5 1.7953683035714284e-05 1.5 1.795424107142857e-05 0.0 1.795647321428571e-05 0.0 1.7957031249999998e-05 1.5 1.7971540178571427e-05 1.5 1.7972098214285713e-05 0.0 1.7974330357142857e-05 0.0 1.797488839285714e-05 1.5 1.798939732142857e-05 1.5 1.7989955357142856e-05 0.0 1.79921875e-05 0.0 1.7992745535714283e-05 1.5 1.800725446428571e-05 1.5 1.8007812499999998e-05 0.0 1.8010044642857142e-05 0.0 1.801060267857143e-05 1.5 1.8025111607142857e-05 1.5 1.802566964285714e-05 0.0 1.8027901785714284e-05 0.0 1.802845982142857e-05 1.5 1.804296875e-05 1.5 1.8043526785714283e-05 0.0 1.8045758928571426e-05 0.0 1.8046316964285713e-05 1.5 1.8060825892857142e-05 1.5 1.806138392857143e-05 0.0 1.806361607142857e-05 0.0 1.8064174107142855e-05 1.5 1.8078683035714284e-05 1.5 1.807924107142857e-05 0.0 1.8081473214285714e-05 0.0 1.8082031249999998e-05 1.5 1.8096540178571426e-05 1.5 1.8097098214285713e-05 0.0 1.8099330357142857e-05 0.0 1.809988839285714e-05 1.5 1.811439732142857e-05 1.5 1.8114955357142855e-05 0.0 1.81171875e-05 0.0 1.8117745535714286e-05 1.5 1.8132254464285714e-05 1.5 1.8132812499999998e-05 0.0 1.813504464285714e-05 0.0 1.8135602678571428e-05 1.5 1.8150111607142857e-05 1.5 1.815066964285714e-05 0.0 1.8152901785714284e-05 0.0 1.815345982142857e-05 1.5 1.816796875e-05 1.5 1.8168526785714286e-05 0.0 1.8170758928571426e-05 0.0 1.8171316964285713e-05 1.5 1.818582589285714e-05 1.5 1.8186383928571428e-05 0.0 1.8188616071428572e-05 0.0 1.8189174107142855e-05 1.5 1.8203683035714284e-05 1.5 1.820424107142857e-05 0.0 1.8206473214285714e-05 0.0 1.8207031249999997e-05 1.5 1.8221540178571426e-05 1.5 1.8222098214285713e-05 0.0 1.8224330357142856e-05 0.0 1.8224888392857143e-05 1.5 1.8239397321428572e-05 1.5 1.8239955357142855e-05 0.0 1.82421875e-05 0.0 1.8242745535714285e-05 1.5 1.8257254464285714e-05 1.5 1.8257812499999997e-05 0.0 1.826004464285714e-05 0.0 1.8260602678571428e-05 1.5 1.8275111607142856e-05 1.5 1.8275669642857143e-05 0.0 1.8277901785714283e-05 0.0 1.827845982142857e-05 1.5 1.829296875e-05 1.5 1.8293526785714285e-05 0.0 1.8295758928571426e-05 0.0 1.8296316964285712e-05 1.5 1.831082589285714e-05 1.5 1.8311383928571428e-05 0.0 1.831361607142857e-05 0.0 1.8314174107142855e-05 1.5 1.8328683035714283e-05 1.5 1.832924107142857e-05 0.0 1.8331473214285714e-05 0.0 1.8332031249999997e-05 1.5 1.8346540178571426e-05 1.5 1.8347098214285712e-05 0.0 1.8349330357142856e-05 0.0 1.8349888392857143e-05 1.5 1.836439732142857e-05 1.5 1.8364955357142855e-05 0.0 1.83671875e-05 0.0 1.8367745535714285e-05 1.5 1.8382254464285714e-05 1.5 1.8382812499999997e-05 0.0 1.838504464285714e-05 0.0 1.8385602678571427e-05 1.5 1.8400111607142856e-05 1.5 1.8400669642857143e-05 0.0 1.8402901785714283e-05 0.0 1.840345982142857e-05 1.5 1.841796875e-05 1.5 1.8418526785714285e-05 0.0 1.842075892857143e-05 0.0 1.8421316964285712e-05 1.5 1.843582589285714e-05 1.5 1.8436383928571427e-05 0.0 1.843861607142857e-05 0.0 1.8439174107142854e-05 1.5 1.8453683035714283e-05 1.5 1.845424107142857e-05 0.0 1.8456473214285713e-05 0.0 1.845703125e-05 1.5 1.847154017857143e-05 1.5 1.8472098214285712e-05 0.0 1.8474330357142856e-05 0.0 1.8474888392857142e-05 1.5 1.848939732142857e-05 1.5 1.8489955357142854e-05 0.0 1.8492187499999998e-05 0.0 1.8492745535714285e-05 1.5 1.8507254464285713e-05 1.5 1.85078125e-05 0.0 1.851004464285714e-05 0.0 1.8510602678571427e-05 1.5 1.8525111607142856e-05 1.5 1.8525669642857142e-05 0.0 1.8527901785714286e-05 0.0 1.852845982142857e-05 1.5 1.8542968749999998e-05 1.5 1.8543526785714285e-05 0.0 1.854575892857143e-05 0.0 1.8546316964285712e-05 1.5 1.856082589285714e-05 1.5 1.8561383928571427e-05 0.0 1.856361607142857e-05 0.0 1.8564174107142857e-05 1.5 1.8578683035714286e-05 1.5 1.857924107142857e-05 0.0 1.8581473214285713e-05 0.0 1.858203125e-05 1.5 1.859654017857143e-05 1.5 1.8597098214285712e-05 0.0 1.8599330357142855e-05 0.0 1.8599888392857142e-05 1.5 1.861439732142857e-05 1.5 1.8614955357142857e-05 0.0 1.8617187499999998e-05 0.0 1.8617745535714284e-05 1.5 1.8632254464285713e-05 1.5 1.86328125e-05 0.0 1.863504464285714e-05 0.0 1.8635602678571427e-05 1.5 1.8650111607142855e-05 1.5 1.8650669642857142e-05 0.0 1.8652901785714286e-05 0.0 1.865345982142857e-05 1.5 1.8667968749999998e-05 1.5 1.8668526785714284e-05 0.0 1.8670758928571428e-05 0.0 1.867131696428571e-05 1.5 1.868582589285714e-05 1.5 1.8686383928571427e-05 0.0 1.868861607142857e-05 0.0 1.8689174107142857e-05 1.5 1.8703683035714286e-05 1.5 1.870424107142857e-05 0.0 1.8706473214285713e-05 0.0 1.870703125e-05 1.5 1.8721540178571428e-05 1.5 1.872209821428571e-05 0.0 1.8724330357142855e-05 0.0 1.8724888392857142e-05 1.5 1.873939732142857e-05 1.5 1.8739955357142857e-05 0.0 1.8742187499999997e-05 0.0 1.8742745535714284e-05 1.5 1.8757254464285713e-05 1.5 1.87578125e-05 0.0 1.8760044642857143e-05 0.0 1.8760602678571426e-05 1.5 1.8775111607142855e-05 1.5 1.8775669642857142e-05 0.0 1.8777901785714285e-05 0.0 1.877845982142857e-05 1.5 1.8792968749999997e-05 1.5 1.8793526785714284e-05 0.0 1.8795758928571428e-05 0.0 1.8796316964285714e-05 1.5 1.8810267857142856e-05 1.5 1.8810825892857143e-05 0.0 1.8814174107142857e-05 0.0 1.881473214285714e-05 1.5 1.8828125e-05 1.5 1.8828683035714285e-05 0.0 1.883203125e-05 0.0 1.8832589285714286e-05 1.5 1.884598214285714e-05 1.5 1.8846540178571428e-05 0.0 1.884988839285714e-05 0.0 1.8850446428571428e-05 1.5 1.8863839285714283e-05 1.5 1.886439732142857e-05 0.0 1.8867745535714284e-05 0.0 1.886830357142857e-05 1.5 1.8881696428571426e-05 1.5 1.8882254464285712e-05 0.0 1.8885602678571426e-05 0.0 1.8886160714285713e-05 1.5 1.889955357142857e-05 1.5 1.8900111607142855e-05 0.0 1.8903459821428572e-05 0.0 1.8904017857142855e-05 1.5 1.8917410714285714e-05 1.5 1.891796875e-05 0.0 1.8921316964285714e-05 0.0 1.8921874999999997e-05 1.5 1.8935267857142856e-05 1.5 1.8935825892857143e-05 0.0 1.8939174107142856e-05 0.0 1.8939732142857143e-05 1.5 1.8953124999999998e-05 1.5 1.8953683035714285e-05 0.0 1.895703125e-05 0.0 1.8957589285714285e-05 1.5 1.897098214285714e-05 1.5 1.8971540178571427e-05 0.0 1.897488839285714e-05 0.0 1.8975446428571428e-05 1.5 1.8988839285714283e-05 1.5 1.898939732142857e-05 0.0 1.8992745535714283e-05 0.0 1.899330357142857e-05 1.5 1.900669642857143e-05 1.5 1.9007254464285712e-05 0.0 1.9010602678571426e-05 0.0 1.9011160714285712e-05 1.5 1.902455357142857e-05 1.5 1.9025111607142854e-05 0.0 1.902845982142857e-05 0.0 1.9029017857142855e-05 1.5 1.9042410714285713e-05 1.5 1.904296875e-05 0.0 1.9046316964285714e-05 0.0 1.9046874999999997e-05 1.5 1.9060267857142856e-05 1.5 1.9060825892857142e-05 0.0 1.9064174107142856e-05 0.0 1.9064732142857143e-05 1.5 1.9078124999999998e-05 1.5 1.9078683035714285e-05 0.0 1.908203125e-05 0.0 1.9082589285714285e-05 1.5 1.909598214285714e-05 1.5 1.9096540178571427e-05 0.0 1.909988839285714e-05 0.0 1.9100446428571427e-05 1.5 1.9113839285714286e-05 1.5 1.911439732142857e-05 0.0 1.9117745535714283e-05 0.0 1.911830357142857e-05 1.5 1.9131696428571428e-05 1.5 1.913225446428571e-05 0.0 1.9136160714285712e-05 0.0 1.913671875e-05 1.5 1.9148995535714284e-05 1.5 1.914955357142857e-05 0.0 1.9154017857142854e-05 0.0 1.915457589285714e-05 1.5 1.9166852678571426e-05 1.5 1.9167410714285713e-05 0.0 1.9171875e-05 0.0 1.9172433035714284e-05 1.5 1.918470982142857e-05 1.5 1.9185267857142855e-05 0.0 1.9189732142857142e-05 0.0 1.9190290178571426e-05 1.5 1.9202566964285714e-05 1.5 1.9203124999999998e-05 0.0 1.9207589285714285e-05 0.0 1.920814732142857e-05 1.5 1.9220424107142856e-05 1.5 1.922098214285714e-05 0.0 1.9225446428571427e-05 0.0 1.9226004464285714e-05 1.5 1.923828125e-05 1.5 1.9238839285714286e-05 0.0 1.924330357142857e-05 0.0 1.9243861607142856e-05 1.5 1.925613839285714e-05 1.5 1.9256696428571428e-05 0.0 1.9261160714285712e-05 0.0 1.926171875e-05 1.5 1.9273995535714283e-05 1.5 1.927455357142857e-05 0.0 1.9279017857142854e-05 0.0 1.927957589285714e-05 1.5 1.9291852678571426e-05 1.5 1.9292410714285713e-05 0.0 1.9296875e-05 0.0 1.9297433035714283e-05 1.5 1.930970982142857e-05 1.5 1.9310267857142855e-05 0.0 1.9314732142857142e-05 0.0 1.931529017857143e-05 1.5 1.9327566964285714e-05 1.5 1.9328124999999997e-05 0.0 1.9332589285714284e-05 0.0 1.933314732142857e-05 1.5 1.9345424107142856e-05 1.5 1.9345982142857143e-05 0.0 1.9350446428571427e-05 0.0 1.9351004464285714e-05 1.5 1.936328125e-05 1.5 1.9363839285714285e-05 0.0 1.936830357142857e-05 0.0 1.9368861607142856e-05 1.5 1.938113839285714e-05 1.5 1.9381696428571428e-05 0.0 1.938616071428571e-05 0.0 1.9386718749999998e-05 1.5 1.93984375e-05 1.5 1.9398995535714283e-05 0.0 1.940457589285714e-05 0.0 1.9405133928571427e-05 1.5 1.9416294642857142e-05 1.5 1.941685267857143e-05 0.0 1.9422433035714283e-05 0.0 1.942299107142857e-05 1.5 1.9434151785714284e-05 1.5 1.943470982142857e-05 0.0 1.944029017857143e-05 0.0 1.9440848214285712e-05 1.5 1.9452008928571427e-05 1.5 1.9452566964285713e-05 0.0 1.945814732142857e-05 0.0 1.9458705357142854e-05 1.5 1.946986607142857e-05 1.5 1.9470424107142856e-05 0.0 1.9476004464285713e-05 0.0 1.94765625e-05 1.5 1.948772321428571e-05 1.5 1.9488281249999998e-05 0.0 1.9493861607142855e-05 0.0 1.9494419642857142e-05 1.5 1.9505580357142857e-05 1.5 1.950613839285714e-05 0.0 1.9511718749999998e-05 0.0 1.9512276785714285e-05 1.5 1.95234375e-05 1.5 1.9523995535714283e-05 0.0 1.952957589285714e-05 0.0 1.9530133928571427e-05 1.5 1.954129464285714e-05 1.5 1.954185267857143e-05 0.0 1.9547433035714286e-05 0.0 1.954799107142857e-05 1.5 1.9559151785714284e-05 1.5 1.955970982142857e-05 0.0 1.9565290178571428e-05 0.0 1.956584821428571e-05 1.5 1.9577008928571426e-05 1.5 1.9577566964285713e-05 0.0 1.958314732142857e-05 0.0 1.9583705357142857e-05 1.5 1.959486607142857e-05 1.5 1.9595424107142855e-05 0.0 1.9601004464285713e-05 0.0 1.96015625e-05 1.5 1.9612723214285714e-05 1.5 1.9613281249999998e-05 0.0 1.9618861607142855e-05 0.0 1.9619419642857142e-05 1.5 1.963002232142857e-05 1.5 1.9630580357142857e-05 0.0 1.9637276785714284e-05 0.0 1.963783482142857e-05 1.5 1.9647879464285712e-05 1.5 1.96484375e-05 0.0 1.9655133928571427e-05 0.0 1.9655691964285713e-05 1.5 1.9665736607142855e-05 1.5 1.966629464285714e-05 0.0 1.967299107142857e-05 0.0 1.9673549107142856e-05 1.5 1.9683593749999997e-05 1.5 1.9684151785714284e-05 0.0 1.969084821428571e-05 0.0 1.9691406249999998e-05 1.5 1.9701450892857143e-05 1.5 1.9702008928571426e-05 0.0 1.9708705357142857e-05 0.0 1.970926339285714e-05 1.5 1.9719308035714285e-05 1.5 1.9719866071428572e-05 0.0 1.97265625e-05 0.0 1.9727120535714286e-05 1.5 1.9737165178571427e-05 1.5 1.9737723214285714e-05 0.0 1.974441964285714e-05 0.0 1.9744977678571428e-05 1.5 1.975502232142857e-05 1.5 1.9755580357142856e-05 0.0 1.9762276785714284e-05 0.0 1.976283482142857e-05 1.5 1.9772879464285712e-05 1.5 1.97734375e-05 0.0 1.9780133928571426e-05 0.0 1.9780691964285713e-05 1.5 1.9790736607142854e-05 1.5 1.979129464285714e-05 0.0 1.979799107142857e-05 0.0 1.9798549107142855e-05 1.5 1.980859375e-05 1.5 1.9809151785714283e-05 0.0 1.9815848214285714e-05 0.0 1.9816406249999998e-05 1.5 1.9826450892857142e-05 1.5 1.9827008928571426e-05 0.0 1.9833705357142857e-05 0.0 1.983426339285714e-05 1.5 1.9844308035714285e-05 1.5 1.984486607142857e-05 0.0 1.9852120535714286e-05 0.0 1.985267857142857e-05 1.5 1.986160714285714e-05 1.5 1.9862165178571427e-05 0.0 1.9869977678571428e-05 0.0 1.987053571428571e-05 1.5 1.9879464285714286e-05 1.5 1.988002232142857e-05 0.0 1.988783482142857e-05 0.0 1.9888392857142857e-05 1.5 1.9897321428571428e-05 1.5 1.989787946428571e-05 0.0 1.9905691964285713e-05 0.0 1.990625e-05 1.5 1.991517857142857e-05 1.5 1.9915736607142857e-05 0.0 1.9923549107142855e-05 0.0 1.992410714285714e-05 1.5 1.9933035714285713e-05 1.5 1.993359375e-05 0.0 1.9941406249999997e-05 0.0 1.9941964285714284e-05 1.5 1.9950892857142855e-05 1.5 1.9951450892857142e-05 0.0 1.9959263392857143e-05 0.0 1.9959821428571426e-05 1.5 1.9968749999999997e-05 1.5 1.9969308035714284e-05 0.0 1.9977120535714285e-05 0.0 1.997767857142857e-05 1.5 1.998660714285714e-05 1.5 1.9987165178571427e-05 0.0 1.9994977678571428e-05 0.0 1.9995535714285714e-05 1.5 2.0004464285714286e-05 1.5 2.000502232142857e-05 0.0 2.001283482142857e-05 0.0 2.0013392857142857e-05 1.5 2.0022321428571428e-05 1.5 2.002287946428571e-05 0.0 2.0030691964285712e-05 0.0 2.003125e-05 1.5 2.004017857142857e-05 1.5 2.0040736607142857e-05 0.0 2.0048549107142855e-05 0.0 2.004910714285714e-05 1.5 2.0058035714285712e-05 1.5 2.005859375e-05 0.0 2.0066964285714284e-05 0.0 2.006752232142857e-05 1.5 2.007533482142857e-05 1.5 2.0075892857142855e-05 0.0 2.0084821428571426e-05 0.0 2.0085379464285713e-05 1.5 2.0093191964285714e-05 1.5 2.0093749999999997e-05 0.0 2.0102678571428568e-05 0.0 2.0103236607142855e-05 1.5 2.0111049107142856e-05 1.5 2.0111607142857143e-05 0.0 2.0120535714285714e-05 0.0 2.0121093749999997e-05 1.5 2.012890625e-05 1.5 2.0129464285714285e-05 0.0 2.0138392857142856e-05 0.0 2.0138950892857143e-05 1.5 2.014676339285714e-05 1.5 2.0147321428571427e-05 0.0 2.015625e-05 0.0 2.0156808035714285e-05 1.5 2.0164620535714283e-05 1.5 2.016517857142857e-05 0.0 2.017410714285714e-05 0.0 2.0174665178571428e-05 1.5 2.018247767857143e-05 1.5 2.0183035714285712e-05 0.0 2.0191964285714283e-05 0.0 2.019252232142857e-05 1.5 2.020033482142857e-05 1.5 2.0200892857142854e-05 0.0 2.0209821428571426e-05 0.0 2.0210379464285712e-05 1.5 2.0218191964285713e-05 1.5 2.021875e-05 0.0 2.022767857142857e-05 0.0 2.0228236607142855e-05 1.5 2.0236049107142856e-05 1.5 2.0236607142857143e-05 0.0 2.0245535714285714e-05 0.0 2.0246093749999997e-05 1.5 2.0253906249999998e-05 1.5 2.0254464285714285e-05 0.0 2.0263392857142856e-05 0.0 2.0263950892857143e-05 1.5 2.027176339285714e-05 1.5 2.0272321428571427e-05 0.0 2.0281808035714285e-05 0.0 2.028236607142857e-05 1.5 2.02890625e-05 1.5 2.0289620535714283e-05 0.0 2.0299665178571427e-05 0.0 2.0300223214285714e-05 1.5 2.030691964285714e-05 1.5 2.030747767857143e-05 0.0 2.031752232142857e-05 0.0 2.0318080357142856e-05 1.5 2.0324776785714284e-05 1.5 2.032533482142857e-05 0.0 2.0335379464285712e-05 0.0 2.03359375e-05 1.5 2.0342633928571426e-05 1.5 2.0343191964285713e-05 0.0 2.0353236607142854e-05 0.0 2.035379464285714e-05 1.5 2.036049107142857e-05 1.5 2.0361049107142855e-05 0.0 2.037109375e-05 0.0 2.0371651785714283e-05 1.5 2.0378348214285714e-05 1.5 2.0378906249999998e-05 0.0 2.0388950892857142e-05 0.0 2.0389508928571426e-05 1.5 2.0396205357142857e-05 1.5 2.039676339285714e-05 0.0 2.0406808035714285e-05 0.0 2.040736607142857e-05 1.5 2.04140625e-05 1.5 2.0414620535714286e-05 0.0 2.0424665178571427e-05 0.0 2.0425223214285714e-05 1.5 2.043191964285714e-05 1.5 2.0432477678571428e-05 0.0 2.044252232142857e-05 0.0 2.0443080357142856e-05 1.5 2.0449776785714284e-05 1.5 2.045033482142857e-05 0.0 2.046037946428571e-05 0.0 2.04609375e-05 1.5 2.0467633928571426e-05 1.5 2.0468191964285713e-05 0.0 2.0478236607142854e-05 0.0 2.047879464285714e-05 1.5 2.0485491071428568e-05 1.5 2.0486049107142855e-05 0.0 2.049609375e-05 0.0 2.0496651785714283e-05 1.5 2.0502790178571427e-05 1.5 2.0503348214285714e-05 0.0 2.0514508928571425e-05 0.0 2.0515066964285712e-05 1.5 2.052064732142857e-05 1.5 2.0521205357142856e-05 0.0 2.053236607142857e-05 0.0 2.0532924107142854e-05 1.5 2.0538504464285712e-05 1.5 2.05390625e-05 0.0 2.0550223214285713e-05 0.0 2.055078125e-05 1.5 2.0556361607142854e-05 1.5 2.055691964285714e-05 0.0 2.0568080357142856e-05 0.0 2.0568638392857143e-05 1.5 2.057421875e-05 1.5 2.0574776785714283e-05 0.0 2.0585937499999998e-05 0.0 2.0586495535714285e-05 1.5 2.0592075892857142e-05 1.5 2.0592633928571426e-05 0.0 2.060379464285714e-05 0.0 2.0604352678571427e-05 1.5 2.0609933035714285e-05 1.5 2.061049107142857e-05 0.0 2.0621651785714283e-05 0.0 2.062220982142857e-05 1.5 2.0627790178571427e-05 1.5 2.0628348214285714e-05 0.0 2.063950892857143e-05 0.0 2.0640066964285712e-05 1.5 2.064564732142857e-05 1.5 2.0646205357142856e-05 0.0 2.065736607142857e-05 0.0 2.0657924107142854e-05 1.5 2.066350446428571e-05 1.5 2.0664062499999998e-05 0.0 2.0675223214285713e-05 0.0 2.067578125e-05 1.5 2.0681361607142857e-05 1.5 2.068191964285714e-05 0.0 2.0693080357142855e-05 0.0 2.0693638392857142e-05 1.5 2.069921875e-05 1.5 2.0699776785714283e-05 0.0 2.0710937499999998e-05 0.0 2.0711495535714284e-05 1.5 2.0717075892857142e-05 1.5 2.071763392857143e-05 0.0 2.072879464285714e-05 0.0 2.0729352678571427e-05 1.5 2.0734374999999997e-05 1.5 2.0734933035714284e-05 0.0 2.074720982142857e-05 0.0 2.0747767857142856e-05 1.5 2.075223214285714e-05 1.5 2.0752790178571427e-05 0.0 2.076506696428571e-05 0.0 2.0765624999999998e-05 1.5 2.0770089285714285e-05 1.5 2.077064732142857e-05 0.0 2.0782924107142857e-05 0.0 2.078348214285714e-05 1.5 2.0787946428571428e-05 1.5 2.078850446428571e-05 0.0 2.080078125e-05 0.0 2.0801339285714283e-05 1.5 2.080580357142857e-05 1.5 2.0806361607142857e-05 0.0 2.0818638392857142e-05 0.0 2.081919642857143e-05 1.5 2.0823660714285712e-05 1.5 2.082421875e-05 0.0 2.0836495535714284e-05 0.0 2.083705357142857e-05 1.5 2.0841517857142855e-05 1.5 2.084207589285714e-05 0.0 2.0854352678571426e-05 0.0 2.0854910714285713e-05 1.5 2.0859374999999997e-05 1.5 2.0859933035714284e-05 0.0 2.087220982142857e-05 0.0 2.0872767857142856e-05 1.5 2.0877232142857143e-05 1.5 2.0877790178571426e-05 0.0 2.089006696428571e-05 0.0 2.0890624999999998e-05 1.5 2.0895089285714285e-05 1.5 2.089564732142857e-05 0.0 2.0907924107142857e-05 0.0 2.090848214285714e-05 1.5 2.0912946428571427e-05 1.5 2.0913504464285714e-05 0.0 2.092578125e-05 0.0 2.0926339285714283e-05 1.5 2.093080357142857e-05 1.5 2.0931361607142857e-05 0.0 2.094363839285714e-05 0.0 2.0944196428571428e-05 1.5 2.0948660714285712e-05 1.5 2.094921875e-05 0.0 2.0961495535714284e-05 0.0 2.096205357142857e-05 1.5 2.0966517857142854e-05 1.5 2.096707589285714e-05 0.0 2.0979352678571426e-05 0.0 2.0979910714285713e-05 1.5 2.0984375e-05 1.5 2.0984933035714284e-05 0.0 2.0997767857142855e-05 0.0 2.0998325892857142e-05 1.5 2.1001674107142856e-05 1.5 2.1002232142857142e-05 0.0 2.1015624999999998e-05 0.0 2.1016183035714284e-05 1.5 2.1019531249999998e-05 1.5 2.1020089285714285e-05 0.0 2.103348214285714e-05 0.0 2.1034040178571427e-05 1.5 2.103738839285714e-05 1.5 2.1037946428571427e-05 0.0 2.1051339285714286e-05 0.0 2.105189732142857e-05 1.5 2.1055245535714283e-05 1.5 2.105580357142857e-05 0.0 2.1069196428571428e-05 0.0 2.106975446428571e-05 1.5 2.107310267857143e-05 1.5 2.1073660714285712e-05 0.0 2.108705357142857e-05 0.0 2.1087611607142857e-05 1.5 2.109095982142857e-05 1.5 2.1091517857142854e-05 0.0 2.1104910714285713e-05 0.0 2.110546875e-05 1.5 2.1108816964285713e-05 1.5 2.1109375e-05 0.0 2.1122767857142855e-05 0.0 2.112332589285714e-05 1.5 2.1126674107142855e-05 1.5 2.1127232142857142e-05 0.0 2.1140624999999997e-05 0.0 2.1141183035714284e-05 1.5 2.1144531249999998e-05 1.5 2.1145089285714284e-05 0.0 2.1158482142857143e-05 0.0 2.1159040178571426e-05 1.5 2.116238839285714e-05 1.5 2.1162946428571427e-05 0.0 2.1176339285714285e-05 0.0 2.117689732142857e-05 1.5 2.1180245535714286e-05 1.5 2.118080357142857e-05 0.0 2.1194196428571428e-05 0.0 2.1194754464285714e-05 1.5 2.1198102678571428e-05 1.5 2.119866071428571e-05 0.0 2.121205357142857e-05 0.0 2.1212611607142857e-05 1.5 2.121595982142857e-05 1.5 2.1216517857142857e-05 0.0 2.1229910714285712e-05 0.0 2.123046875e-05 1.5 2.1233816964285713e-05 1.5 2.1234375e-05 0.0 2.1247767857142855e-05 0.0 2.124832589285714e-05 1.5 2.1251674107142855e-05 1.5 2.1252232142857142e-05 0.0 2.1265624999999997e-05 0.0 2.1266183035714284e-05 1.5 2.1269531249999997e-05 1.5 2.1270089285714284e-05 0.0 2.1283482142857143e-05 0.0 2.1284040178571426e-05 1.5 2.128738839285714e-05 1.5 2.1287946428571426e-05 0.0 2.1301339285714285e-05 0.0 2.1301897321428568e-05 1.5 2.1305245535714285e-05 1.5 2.130580357142857e-05 0.0 2.1319196428571427e-05 0.0 2.1319754464285714e-05 1.5 2.132254464285714e-05 1.5 2.1323102678571428e-05 0.0 2.1337611607142856e-05 0.0 2.1338169642857143e-05 1.5 2.1340401785714283e-05 1.5 2.134095982142857e-05 0.0 2.135546875e-05 0.0 2.1356026785714285e-05 1.5 2.1358258928571426e-05 1.5 2.1358816964285712e-05 0.0 2.137332589285714e-05 0.0 2.1373883928571428e-05 1.5 2.137611607142857e-05 1.5 2.1376674107142855e-05 0.0 2.1391183035714283e-05 0.0 2.139174107142857e-05 1.5 2.1393973214285714e-05 1.5 2.1394531249999997e-05 0.0 2.1409040178571426e-05 0.0 2.1409598214285712e-05 1.5 2.1411830357142856e-05 1.5 2.1412388392857143e-05 0.0 2.142689732142857e-05 0.0 2.1427455357142855e-05 1.5 2.1429687499999998e-05 1.5 2.1430245535714285e-05 0.0 2.1444754464285714e-05 0.0 2.1445312499999997e-05 1.5 2.144754464285714e-05 1.5 2.1448102678571427e-05 0.0 2.1462611607142856e-05 0.0 2.1463169642857143e-05 1.5 2.1465401785714283e-05 1.5 2.146595982142857e-05 0.0 2.1480468749999998e-05 0.0 2.1481026785714285e-05 1.5 2.148325892857143e-05 1.5 2.1483816964285712e-05 0.0 2.149832589285714e-05 0.0 2.1498883928571427e-05 1.5 2.150111607142857e-05 1.5 2.1501674107142854e-05 0.0 2.1516183035714283e-05 0.0 2.151674107142857e-05 1.5 2.1518973214285713e-05 1.5 2.151953125e-05 0.0 2.153404017857143e-05 0.0 2.1534598214285712e-05 1.5 2.1536830357142856e-05 1.5 2.1537388392857142e-05 0.0 2.155189732142857e-05 0.0 2.1552455357142854e-05 1.5 2.1554687499999998e-05 1.5 2.1555245535714285e-05 0.0 2.1569754464285713e-05 0.0 2.15703125e-05 1.5 2.157254464285714e-05 1.5 2.1573102678571427e-05 0.0 2.1587611607142856e-05 0.0 2.1588169642857142e-05 1.5 2.1590401785714283e-05 1.5 2.159095982142857e-05 0.0 2.1605468749999998e-05 0.0 2.1606026785714285e-05 1.5 2.1608258928571428e-05 1.5 2.160881696428571e-05 0.0 2.162332589285714e-05 0.0 2.1623883928571427e-05 1.5 2.162611607142857e-05 1.5 2.1626674107142854e-05 0.0 2.1641183035714283e-05 0.0 2.164174107142857e-05 1.5 2.1643973214285713e-05 1.5 2.164453125e-05 0.0 2.1659040178571428e-05 0.0 2.165959821428571e-05 1.5 2.1661830357142855e-05 1.5 2.1662388392857142e-05 0.0 2.167689732142857e-05 0.0 2.1677455357142854e-05 1.5 2.1679687499999998e-05 1.5 2.1680245535714284e-05 0.0 2.1694754464285713e-05 0.0 2.16953125e-05 1.5 2.169754464285714e-05 1.5 2.1698102678571427e-05 0.0 2.1712611607142855e-05 0.0 2.1713169642857142e-05 1.5 2.1715401785714286e-05 1.5 2.171595982142857e-05 0.0 2.1730468749999998e-05 0.0 2.1731026785714284e-05 1.5 2.1733258928571428e-05 1.5 2.173381696428571e-05 0.0 2.174832589285714e-05 0.0 2.1748883928571427e-05 1.5 2.175111607142857e-05 1.5 2.1751674107142857e-05 0.0 2.1766183035714286e-05 0.0 2.176674107142857e-05 1.5 2.1768973214285713e-05 1.5 2.176953125e-05 0.0 2.1784040178571428e-05 0.0 2.178459821428571e-05 1.5 2.1786830357142855e-05 1.5 2.178738839285714e-05 0.0 2.180189732142857e-05 0.0 2.1802455357142857e-05 1.5 2.1804687499999997e-05 1.5 2.1805245535714284e-05 0.0 2.1819754464285713e-05 0.0 2.18203125e-05 1.5 2.1822544642857143e-05 1.5 2.1823102678571426e-05 0.0 2.1837611607142855e-05 0.0 2.183816964285714e-05 1.5 2.1840401785714285e-05 1.5 2.184095982142857e-05 0.0 2.1855468749999997e-05 0.0 2.1856026785714284e-05 1.5 2.1858258928571428e-05 1.5 2.1858816964285714e-05 0.0 2.1873325892857143e-05 0.0 2.1873883928571426e-05 1.5 2.187611607142857e-05 1.5 2.1876674107142857e-05 0.0 2.1891183035714285e-05 0.0 2.189174107142857e-05 1.5 2.1893973214285712e-05 1.5 2.189453125e-05 0.0 2.1909040178571428e-05 0.0 2.1909598214285714e-05 1.5 2.1911830357142855e-05 1.5 2.191238839285714e-05 0.0 2.192689732142857e-05 0.0 2.1927455357142857e-05 1.5 2.1929687499999997e-05 1.5 2.1930245535714284e-05 0.0 2.1944754464285712e-05 0.0 2.19453125e-05 1.5 2.1947544642857143e-05 1.5 2.1948102678571426e-05 0.0 2.1962611607142855e-05 0.0 2.196316964285714e-05 1.5 2.1965401785714285e-05 1.5 2.1965959821428568e-05 0.0 2.1980468749999997e-05 0.0 2.1981026785714284e-05 1.5 2.1983258928571427e-05 1.5 2.1983816964285714e-05 0.0 2.1998325892857143e-05 0.0 2.1998883928571426e-05 1.5 2.200111607142857e-05 1.5 2.2001674107142856e-05 0.0 2.2016183035714285e-05 0.0 2.2016741071428568e-05 1.5 2.2018973214285712e-05 1.5 2.201953125e-05 0.0 2.2034040178571427e-05 0.0 2.2034598214285714e-05 1.5 2.2036830357142854e-05 1.5 2.203738839285714e-05 0.0 2.205189732142857e-05 0.0 2.2052455357142856e-05 1.5 2.20546875e-05 1.5 2.2055245535714283e-05 0.0 2.2069754464285712e-05 0.0 2.20703125e-05 1.5 2.2072544642857142e-05 1.5 2.2073102678571426e-05 0.0 2.2087611607142854e-05 0.0 2.208816964285714e-05 1.5 2.2090401785714285e-05 1.5 2.209095982142857e-05 0.0 2.210546875e-05 0.0 2.2106026785714283e-05 1.5 2.2108258928571427e-05 1.5 2.2108816964285714e-05 0.0 2.2123325892857142e-05 0.0 2.2123883928571426e-05 1.5 2.212611607142857e-05 1.5 2.2126674107142856e-05 0.0 2.2141183035714285e-05 0.0 2.214174107142857e-05 1.5 2.214397321428571e-05 1.5 2.2144531249999998e-05 0.0 2.2159040178571427e-05 0.0 2.2159598214285714e-05 1.5 2.2161830357142857e-05 1.5 2.216238839285714e-05 0.0 2.217689732142857e-05 0.0 2.2177455357142856e-05 1.5 2.21796875e-05 1.5 2.2180245535714283e-05 0.0 2.219475446428571e-05 0.0 2.2195312499999998e-05 1.5 2.2197544642857142e-05 1.5 2.219810267857143e-05 0.0 2.2212611607142857e-05 0.0 2.221316964285714e-05 1.5 2.2215401785714284e-05 1.5 2.221595982142857e-05 0.0 2.223046875e-05 0.0 2.2231026785714283e-05 1.5 2.2233258928571427e-05 1.5 2.2233816964285713e-05 0.0 2.2248325892857142e-05 0.0 2.224888392857143e-05 1.5 2.225111607142857e-05 1.5 2.2251674107142856e-05 0.0 2.2266183035714284e-05 0.0 2.226674107142857e-05 1.5 2.226897321428571e-05 1.5 2.2269531249999998e-05 0.0 2.2284040178571426e-05 0.0 2.2284598214285713e-05 1.5 2.2286830357142857e-05 1.5 2.228738839285714e-05 0.0 2.230189732142857e-05 0.0 2.2302455357142856e-05 1.5 2.23046875e-05 1.5 2.2305245535714283e-05 0.0 2.231975446428571e-05 0.0 2.2320312499999998e-05 1.5 2.232254464285714e-05 1.5 2.2323102678571428e-05 0.0 2.2337611607142857e-05 0.0 2.233816964285714e-05 1.5 2.2340401785714284e-05 1.5 2.234095982142857e-05 0.0 2.235546875e-05 0.0 2.2356026785714283e-05 1.5 2.2358258928571426e-05 1.5 2.2358816964285713e-05 0.0 2.237332589285714e-05 0.0 2.2373883928571428e-05 1.5 2.237611607142857e-05 1.5 2.2376674107142855e-05 0.0 2.2391183035714284e-05 0.0 2.239174107142857e-05 1.5 2.2393973214285714e-05 1.5 2.2394531249999998e-05 0.0 2.2409040178571426e-05 0.0 2.2409598214285713e-05 1.5 2.2411830357142857e-05 1.5 2.241238839285714e-05 0.0 2.242689732142857e-05 0.0 2.2427455357142855e-05 1.5 2.24296875e-05 1.5 2.2430245535714286e-05 0.0 2.2444754464285714e-05 0.0 2.2445312499999998e-05 1.5 2.244754464285714e-05 1.5 2.2448102678571428e-05 0.0 2.2462611607142857e-05 0.0 2.246316964285714e-05 1.5 2.2465401785714284e-05 1.5 2.246595982142857e-05 0.0 2.248046875e-05 0.0 2.2481026785714286e-05 1.5 2.2483258928571426e-05 1.5 2.2483816964285713e-05 0.0 2.249832589285714e-05 0.0 2.2498883928571428e-05 1.5 2.2501116071428568e-05 1.5 2.2501674107142855e-05 0.0 2.2516183035714283e-05 0.0 2.251674107142857e-05 1.5 2.2518973214285714e-05 1.5 2.2519531249999997e-05 0.0 2.2534040178571426e-05 0.0 2.2534598214285713e-05 1.5 2.2536830357142856e-05 1.5 2.253738839285714e-05 0.0 2.2551897321428568e-05 0.0 2.2552455357142855e-05 1.5 2.25546875e-05 1.5 2.2555245535714285e-05 0.0 2.2569754464285714e-05 0.0 2.2570312499999997e-05 1.5 2.257254464285714e-05 1.5 2.2573102678571428e-05 0.0 2.2587611607142856e-05 0.0 2.2588169642857143e-05 1.5 2.2590401785714283e-05 1.5 2.259095982142857e-05 0.0 2.260546875e-05 0.0 2.2606026785714285e-05 1.5 2.2608258928571425e-05 1.5 2.2608816964285712e-05 0.0 2.262332589285714e-05 0.0 2.2623883928571428e-05 1.5 2.262611607142857e-05 1.5 2.2626674107142855e-05 0.0 2.2641183035714283e-05 0.0 2.264174107142857e-05 1.5 2.2643973214285714e-05 1.5 2.2644531249999997e-05 0.0 2.2659040178571425e-05 0.0 2.2659598214285712e-05 1.5 2.2661830357142856e-05 1.5 2.2662388392857143e-05 0.0 2.267689732142857e-05 0.0 2.2677455357142855e-05 1.5 2.2679687499999998e-05 1.5 2.2680245535714285e-05 0.0 2.2694754464285713e-05 0.0 2.2695312499999997e-05 1.5 2.269754464285714e-05 1.5 2.2698102678571427e-05 0.0 2.2712611607142856e-05 0.0 2.2713169642857143e-05 1.5 2.2715401785714283e-05 1.5 2.271595982142857e-05 0.0 2.2730468749999998e-05 0.0 2.2731026785714285e-05 1.5 2.273325892857143e-05 1.5 2.2733816964285712e-05 0.0 2.274832589285714e-05 0.0 2.2748883928571427e-05 1.5 2.275111607142857e-05 1.5 2.2751674107142854e-05 0.0 2.2766183035714283e-05 0.0 2.276674107142857e-05 1.5 2.2768973214285713e-05 1.5 2.276953125e-05 0.0 2.278404017857143e-05 0.0 2.2784598214285712e-05 1.5 2.2786830357142855e-05 1.5 2.2787388392857142e-05 0.0 2.280189732142857e-05 0.0 2.2802455357142854e-05 1.5 2.2804687499999998e-05 1.5 2.2805245535714285e-05 0.0 2.2819196428571426e-05 0.0 2.2819754464285713e-05 1.5 2.2823102678571427e-05 1.5 2.2823660714285714e-05 0.0 2.283705357142857e-05 0.0 2.2837611607142855e-05 1.5 2.284095982142857e-05 1.5 2.2841517857142856e-05 0.0 2.285491071428571e-05 0.0 2.2855468749999998e-05 1.5 2.285881696428571e-05 1.5 2.2859374999999998e-05 0.0 2.2872767857142857e-05 0.0 2.287332589285714e-05 1.5 2.2876674107142854e-05 1.5 2.287723214285714e-05 0.0 2.2890625e-05 0.0 2.2891183035714282e-05 1.5 2.289453125e-05 1.5 2.2895089285714283e-05 0.0 2.290848214285714e-05 0.0 2.2909040178571428e-05 1.5 2.2912388392857142e-05 1.5 2.2912946428571425e-05 0.0 2.2926339285714284e-05 0.0 2.292689732142857e-05 1.5 2.2930245535714284e-05 1.5 2.293080357142857e-05 0.0 2.2944196428571426e-05 0.0 2.2944754464285713e-05 1.5 2.2948102678571427e-05 1.5 2.2948660714285713e-05 0.0 2.296205357142857e-05 0.0 2.2962611607142855e-05 1.5 2.296595982142857e-05 1.5 2.2966517857142856e-05 0.0 2.2979910714285714e-05 0.0 2.2980468749999997e-05 1.5 2.298381696428571e-05 1.5 2.2984374999999998e-05 0.0 2.2997767857142856e-05 0.0 2.299832589285714e-05 1.5 2.3001674107142857e-05 1.5 2.300223214285714e-05 0.0 2.3015625e-05 0.0 2.3016183035714285e-05 1.5 2.301953125e-05 1.5 2.3020089285714283e-05 0.0 2.303348214285714e-05 0.0 2.3034040178571428e-05 1.5 2.303738839285714e-05 1.5 2.3037946428571428e-05 0.0 2.3051339285714283e-05 0.0 2.305189732142857e-05 1.5 2.3055245535714284e-05 1.5 2.305580357142857e-05 0.0 2.3069196428571426e-05 0.0 2.3069754464285712e-05 1.5 2.3073102678571426e-05 1.5 2.3073660714285713e-05 0.0 2.308705357142857e-05 0.0 2.3087611607142855e-05 1.5 2.309095982142857e-05 1.5 2.3091517857142855e-05 0.0 2.3104910714285714e-05 0.0 2.3105468749999997e-05 1.5 2.3108816964285714e-05 1.5 2.3109374999999998e-05 0.0 2.3122767857142856e-05 0.0 2.3123325892857143e-05 1.5 2.3126674107142857e-05 1.5 2.312723214285714e-05 0.0 2.3140625e-05 0.0 2.3141183035714285e-05 1.5 2.3145089285714286e-05 1.5 2.314564732142857e-05 0.0 2.3157924107142854e-05 0.0 2.315848214285714e-05 1.5 2.3162946428571428e-05 1.5 2.316350446428571e-05 0.0 2.317578125e-05 0.0 2.3176339285714283e-05 1.5 2.318080357142857e-05 1.5 2.3181361607142857e-05 0.0 2.3193638392857142e-05 0.0 2.3194196428571425e-05 1.5 2.3198660714285713e-05 1.5 2.319921875e-05 0.0 2.3211495535714284e-05 0.0 2.321205357142857e-05 1.5 2.3216517857142855e-05 1.5 2.321707589285714e-05 0.0 2.3229352678571427e-05 0.0 2.3229910714285713e-05 1.5 2.3234374999999997e-05 1.5 2.3234933035714284e-05 0.0 2.324720982142857e-05 0.0 2.3247767857142856e-05 1.5 2.325223214285714e-05 1.5 2.3252790178571426e-05 0.0 2.326506696428571e-05 0.0 2.3265624999999998e-05 1.5 2.3270089285714285e-05 1.5 2.327064732142857e-05 0.0 2.3282924107142857e-05 0.0 2.328348214285714e-05 1.5 2.3287946428571428e-05 1.5 2.328850446428571e-05 0.0 2.330078125e-05 0.0 2.3301339285714283e-05 1.5 2.330580357142857e-05 1.5 2.3306361607142857e-05 0.0 2.331863839285714e-05 0.0 2.331919642857143e-05 1.5 2.3323660714285712e-05 1.5 2.332421875e-05 0.0 2.3336495535714284e-05 0.0 2.333705357142857e-05 1.5 2.3341517857142855e-05 1.5 2.334207589285714e-05 0.0 2.3354352678571426e-05 0.0 2.3354910714285713e-05 1.5 2.3359374999999997e-05 1.5 2.3359933035714284e-05 0.0 2.337220982142857e-05 0.0 2.3372767857142855e-05 1.5 2.3377232142857143e-05 1.5 2.3377790178571426e-05 0.0 2.3390066964285714e-05 0.0 2.3390624999999998e-05 1.5 2.3395089285714285e-05 1.5 2.3395647321428568e-05 0.0 2.3407924107142857e-05 0.0 2.340848214285714e-05 1.5 2.3413504464285714e-05 1.5 2.3414062499999997e-05 0.0 2.3425223214285712e-05 0.0 2.342578125e-05 1.5 2.3431361607142856e-05 1.5 2.343191964285714e-05 0.0 2.3443080357142854e-05 0.0 2.344363839285714e-05 1.5 2.344921875e-05 1.5 2.3449776785714285e-05 0.0 2.3460937499999997e-05 0.0 2.3461495535714284e-05 1.5 2.346707589285714e-05 1.5 2.3467633928571428e-05 0.0 2.3478794642857143e-05 0.0 2.3479352678571426e-05 1.5 2.3484933035714283e-05 1.5 2.348549107142857e-05 0.0 2.3496651785714285e-05 0.0 2.3497209821428568e-05 1.5 2.3502790178571426e-05 1.5 2.3503348214285712e-05 0.0 2.3514508928571427e-05 0.0 2.3515066964285714e-05 1.5 2.352064732142857e-05 1.5 2.3521205357142855e-05 0.0 2.353236607142857e-05 0.0 2.3532924107142856e-05 1.5 2.3538504464285714e-05 1.5 2.3539062499999997e-05 0.0 2.3550223214285712e-05 0.0 2.355078125e-05 1.5 2.3556361607142856e-05 1.5 2.3556919642857143e-05 0.0 2.3568080357142854e-05 0.0 2.356863839285714e-05 1.5 2.3574218749999998e-05 1.5 2.3574776785714285e-05 0.0 2.35859375e-05 0.0 2.3586495535714283e-05 1.5 2.359207589285714e-05 1.5 2.3592633928571427e-05 0.0 2.3603794642857142e-05 0.0 2.3604352678571426e-05 1.5 2.3609933035714283e-05 1.5 2.361049107142857e-05 0.0 2.3621651785714285e-05 0.0 2.362220982142857e-05 1.5 2.3627790178571425e-05 1.5 2.3628348214285712e-05 0.0 2.3639508928571427e-05 0.0 2.3640066964285714e-05 1.5 2.3646205357142854e-05 1.5 2.364676339285714e-05 0.0 2.3656808035714282e-05 0.0 2.365736607142857e-05 1.5 2.3664062499999997e-05 1.5 2.3664620535714283e-05 0.0 2.3674665178571428e-05 0.0 2.367522321428571e-05 1.5 2.3681919642857142e-05 1.5 2.3682477678571426e-05 0.0 2.369252232142857e-05 0.0 2.3693080357142854e-05 1.5 2.3699776785714285e-05 1.5 2.3700334821428568e-05 0.0 2.3710379464285713e-05 0.0 2.37109375e-05 1.5 2.3717633928571427e-05 1.5 2.3718191964285714e-05 0.0 2.3728236607142855e-05 0.0 2.3728794642857142e-05 1.5 2.373549107142857e-05 1.5 2.3736049107142856e-05 0.0 2.3746093749999997e-05 0.0 2.3746651785714284e-05 1.5 2.375334821428571e-05 1.5 2.375390625e-05 0.0 2.376395089285714e-05 0.0 2.3764508928571426e-05 1.5 2.3771205357142854e-05 1.5 2.377176339285714e-05 0.0 2.3781808035714285e-05 0.0 2.378236607142857e-05 1.5 2.37890625e-05 1.5 2.3789620535714283e-05 0.0 2.3799665178571428e-05 0.0 2.380022321428571e-05 1.5 2.3806919642857142e-05 1.5 2.3807477678571425e-05 0.0 2.381752232142857e-05 0.0 2.3818080357142857e-05 1.5 2.3824776785714284e-05 1.5 2.382533482142857e-05 0.0 2.3835379464285712e-05 0.0 2.38359375e-05 1.5 2.3842633928571427e-05 1.5 2.3843191964285713e-05 0.0 2.3853236607142855e-05 0.0 2.385379464285714e-05 1.5 2.386049107142857e-05 1.5 2.3861049107142856e-05 0.0 2.3870535714285714e-05 0.0 2.3871093749999997e-05 1.5 2.3878906249999998e-05 1.5 2.3879464285714285e-05 0.0 2.3888392857142856e-05 0.0 2.3888950892857143e-05 1.5 2.389676339285714e-05 1.5 2.3897321428571427e-05 0.0 2.390625e-05 0.0 2.3906808035714285e-05 1.5 2.3914620535714283e-05 1.5 2.391517857142857e-05 0.0 2.392410714285714e-05 0.0 2.3924665178571427e-05 1.5 2.393247767857143e-05 1.5 2.3933035714285712e-05 0.0 2.3941964285714283e-05 0.0 2.394252232142857e-05 1.5 2.395033482142857e-05 1.5 2.3950892857142854e-05 0.0 2.3959821428571425e-05 0.0 2.3960379464285712e-05 1.5 2.3968191964285713e-05 1.5 2.396875e-05 0.0 2.397767857142857e-05 0.0 2.3978236607142854e-05 1.5 2.3986049107142855e-05 1.5 2.3986607142857142e-05 0.0 2.3995535714285713e-05 0.0 2.3996093749999997e-05 1.5 2.4003906249999998e-05 1.5 2.4004464285714284e-05 0.0 2.4013392857142856e-05 0.0 2.4013950892857142e-05 1.5 2.402176339285714e-05 1.5 2.4022321428571427e-05 0.0 2.4031249999999998e-05 0.0 2.4031808035714285e-05 1.5 2.4039620535714282e-05 1.5 2.404017857142857e-05 0.0 2.404910714285714e-05 0.0 2.4049665178571427e-05 1.5 2.4057477678571428e-05 1.5 2.405803571428571e-05 0.0 2.4066964285714283e-05 0.0 2.406752232142857e-05 1.5 2.407533482142857e-05 1.5 2.4075892857142854e-05 0.0 2.408426339285714e-05 0.0 2.408482142857143e-05 1.5 2.409375e-05 1.5 2.4094308035714283e-05 0.0 2.4102120535714284e-05 0.0 2.410267857142857e-05 1.5 2.4111607142857142e-05 1.5 2.4112165178571425e-05 0.0 2.4119977678571426e-05 0.0 2.4120535714285713e-05 1.5 2.4129464285714284e-05 1.5 2.413002232142857e-05 0.0 2.413783482142857e-05 0.0 2.4138392857142855e-05 1.5 2.4147321428571426e-05 1.5 2.4147879464285713e-05 0.0 2.415569196428571e-05 0.0 2.4156249999999998e-05 1.5 2.416517857142857e-05 1.5 2.4165736607142856e-05 0.0 2.4173549107142857e-05 0.0 2.417410714285714e-05 1.5 2.418303571428571e-05 1.5 2.4183593749999998e-05 0.0 2.419140625e-05 0.0 2.4191964285714286e-05 1.5 2.4200892857142857e-05 1.5 2.420145089285714e-05 0.0 2.420926339285714e-05 0.0 2.4209821428571428e-05 1.5 2.421875e-05 1.5 2.4219308035714283e-05 0.0 2.4227120535714284e-05 0.0 2.422767857142857e-05 1.5 2.423660714285714e-05 1.5 2.4237165178571428e-05 0.0 2.4244977678571426e-05 0.0 2.4245535714285713e-05 1.5 2.4254464285714284e-05 1.5 2.425502232142857e-05 0.0 2.4262834821428568e-05 0.0 2.4263392857142855e-05 1.5 2.4272321428571426e-05 1.5 2.4272879464285713e-05 0.0 2.4280691964285714e-05 0.0 2.4281249999999997e-05 1.5 2.429017857142857e-05 1.5 2.4290736607142855e-05 0.0 2.429799107142857e-05 0.0 2.4298549107142856e-05 1.5 2.4308593749999998e-05 1.5 2.4309151785714284e-05 0.0 2.4315848214285712e-05 0.0 2.431640625e-05 1.5 2.432645089285714e-05 1.5 2.4327008928571427e-05 0.0 2.4333705357142854e-05 0.0 2.433426339285714e-05 1.5 2.4344308035714286e-05 1.5 2.434486607142857e-05 0.0 2.43515625e-05 0.0 2.4352120535714283e-05 1.5 2.4362165178571428e-05 1.5 2.436272321428571e-05 0.0 2.4369419642857142e-05 0.0 2.4369977678571426e-05 1.5 2.438002232142857e-05 1.5 2.4380580357142857e-05 0.0 2.4387276785714284e-05 0.0 2.438783482142857e-05 1.5 2.4397879464285713e-05 1.5 2.43984375e-05 0.0 2.4405133928571427e-05 0.0 2.4405691964285714e-05 1.5 2.4415736607142855e-05 1.5 2.441629464285714e-05 0.0 2.442299107142857e-05 0.0 2.4423549107142856e-05 1.5 2.4433593749999997e-05 1.5 2.4434151785714284e-05 0.0 2.444084821428571e-05 0.0 2.4441406249999998e-05 1.5 2.445145089285714e-05 1.5 2.4452008928571426e-05 0.0 2.4458705357142854e-05 0.0 2.445926339285714e-05 1.5 2.4469308035714285e-05 1.5 2.446986607142857e-05 0.0 2.44765625e-05 0.0 2.4477120535714283e-05 1.5 2.4487165178571428e-05 1.5 2.448772321428571e-05 0.0 2.4494419642857142e-05 0.0 2.4494977678571425e-05 1.5 2.450502232142857e-05 1.5 2.4505580357142857e-05 0.0 2.4511718749999997e-05 0.0 2.4512276785714284e-05 1.5 2.45234375e-05 1.5 2.4523995535714282e-05 0.0 2.452957589285714e-05 0.0 2.4530133928571426e-05 1.5 2.454129464285714e-05 1.5 2.4541852678571428e-05 0.0 2.4547433035714285e-05 0.0 2.454799107142857e-05 1.5 2.4559151785714284e-05 1.5 2.455970982142857e-05 0.0 2.4565290178571428e-05 0.0 2.456584821428571e-05 1.5 2.4577008928571426e-05 1.5 2.4577566964285713e-05 0.0 2.458314732142857e-05 0.0 2.4583705357142857e-05 1.5 2.4594866071428568e-05 1.5 2.4595424107142855e-05 0.0 2.4601004464285712e-05 0.0 2.46015625e-05 1.5 2.4612723214285714e-05 1.5 2.4613281249999997e-05 0.0 2.4618861607142855e-05 0.0 2.461941964285714e-05 1.5 2.4630580357142856e-05 1.5 2.463113839285714e-05 0.0 2.4636718749999997e-05 0.0 2.4637276785714284e-05 1.5 2.46484375e-05 1.5 2.4648995535714285e-05 0.0 2.4654575892857143e-05 0.0 2.4655133928571426e-05 1.5 2.466629464285714e-05 1.5 2.4666852678571428e-05 0.0 2.4672433035714285e-05 0.0 2.467299107142857e-05 1.5 2.4684151785714283e-05 1.5 2.468470982142857e-05 0.0 2.4690290178571427e-05 0.0 2.4690848214285714e-05 1.5 2.4702008928571426e-05 1.5 2.4702566964285712e-05 0.0 2.470814732142857e-05 0.0 2.4708705357142856e-05 1.5 2.471986607142857e-05 1.5 2.4720424107142855e-05 0.0 2.4726004464285712e-05 0.0 2.47265625e-05 1.5 2.4737723214285714e-05 1.5 2.4738281249999997e-05 0.0 2.4743861607142854e-05 0.0 2.474441964285714e-05 1.5 2.4756138392857143e-05 1.5 2.4756696428571426e-05 0.0 2.4761160714285713e-05 0.0 2.4761718749999997e-05 1.5 2.4773995535714285e-05 1.5 2.477455357142857e-05 0.0 2.4779017857142856e-05 0.0 2.4779575892857142e-05 1.5 2.4791852678571427e-05 1.5 2.4792410714285714e-05 0.0 2.4796874999999998e-05 0.0 2.4797433035714285e-05 1.5 2.480970982142857e-05 1.5 2.4810267857142856e-05 0.0 2.481473214285714e-05 0.0 2.4815290178571427e-05 1.5 2.4827566964285712e-05 1.5 2.4828125e-05 0.0 2.4832589285714283e-05 0.0 2.483314732142857e-05 1.5 2.4845424107142854e-05 1.5 2.484598214285714e-05 0.0 2.485044642857143e-05 0.0 2.485100446428571e-05 1.5 2.4863281249999997e-05 1.5 2.4863839285714283e-05 0.0 2.486830357142857e-05 0.0 2.4868861607142854e-05 1.5 2.4881138392857142e-05 1.5 2.4881696428571426e-05 0.0 2.4886160714285713e-05 0.0 2.488671875e-05 1.5 2.4898995535714285e-05 1.5 2.4899553571428568e-05 0.0 2.4904017857142855e-05 0.0 2.4904575892857142e-05 1.5 2.4916852678571427e-05 1.5 2.4917410714285714e-05 0.0 2.4921874999999998e-05 0.0 2.4922433035714284e-05 1.5 2.493470982142857e-05 1.5 2.4935267857142856e-05 0.0 2.493973214285714e-05 0.0 2.4940290178571427e-05 1.5 2.495256696428571e-05 1.5 2.4953125e-05 0.0 2.4957589285714282e-05 0.0 2.495814732142857e-05 1.5 2.4970424107142854e-05 1.5 2.497098214285714e-05 0.0 2.4975446428571428e-05 0.0 2.497600446428571e-05 1.5 2.498828125e-05 1.5 2.4988839285714283e-05 0.0 2.499330357142857e-05 0.0 2.4993861607142857e-05 1.5 2.5006138392857142e-05 1.5 2.5006696428571425e-05 0.0 2.5010602678571426e-05 0.0 2.5011160714285713e-05 1.5 2.502455357142857e-05 1.5 2.5025111607142854e-05 0.0 2.5028459821428568e-05 0.0 2.5029017857142855e-05 1.5 2.5042410714285713e-05 1.5 2.5042968749999997e-05 0.0 2.5046316964285714e-05 0.0 2.5046874999999997e-05 1.5 2.5060267857142856e-05 1.5 2.5060825892857142e-05 0.0 2.5064174107142856e-05 0.0 2.506473214285714e-05 1.5 2.5078124999999998e-05 1.5 2.5078683035714285e-05 0.0 2.508203125e-05 0.0 2.5082589285714285e-05 1.5 2.509598214285714e-05 1.5 2.5096540178571427e-05 0.0 2.509988839285714e-05 0.0 2.5100446428571428e-05 1.5 2.5113839285714283e-05 1.5 2.511439732142857e-05 0.0 2.5117745535714283e-05 0.0 2.511830357142857e-05 1.5 2.513169642857143e-05 1.5 2.5132254464285712e-05 0.0 2.5135602678571426e-05 0.0 2.5136160714285712e-05 1.5 2.514955357142857e-05 1.5 2.5150111607142854e-05 0.0 2.515345982142857e-05 0.0 2.5154017857142855e-05 1.5 2.5167410714285713e-05 1.5 2.516796875e-05 0.0 2.5171316964285714e-05 0.0 2.5171874999999997e-05 1.5 2.5185267857142855e-05 1.5 2.5185825892857142e-05 0.0 2.5189174107142856e-05 0.0 2.5189732142857143e-05 1.5 2.5203124999999998e-05 1.5 2.5203683035714284e-05 0.0 2.5207031249999998e-05 0.0 2.5207589285714285e-05 1.5 2.522098214285714e-05 1.5 2.5221540178571427e-05 0.0 2.522488839285714e-05 0.0 2.5225446428571427e-05 1.5 2.5238839285714282e-05 1.5 2.523939732142857e-05 0.0 2.5242745535714283e-05 0.0 2.524330357142857e-05 1.5 2.5256696428571428e-05 1.5 2.525725446428571e-05 0.0 2.5260602678571425e-05 0.0 2.5261160714285712e-05 1.5 2.527455357142857e-05 1.5 2.5275111607142854e-05 0.0 2.527845982142857e-05 0.0 2.5279017857142854e-05 1.5 2.5292410714285713e-05 1.5 2.529296875e-05 0.0 2.5296316964285713e-05 0.0 2.5296874999999997e-05 1.5 2.5310267857142855e-05 1.5 2.5310825892857142e-05 0.0 2.5314174107142856e-05 0.0 2.5314732142857142e-05 1.5 2.5328124999999997e-05 1.5 2.5328683035714284e-05 0.0 2.5332031249999998e-05 0.0 2.5332589285714285e-05 1.5 2.5346540178571426e-05 1.5 2.5347098214285713e-05 0.0 2.5349330357142857e-05 0.0 2.534988839285714e-05 1.5 2.536439732142857e-05 1.5 2.5364955357142855e-05 0.0 2.53671875e-05 0.0 2.5367745535714282e-05 1.5 2.538225446428571e-05 1.5 2.5382812499999998e-05 0.0 2.538504464285714e-05 0.0 2.5385602678571428e-05 1.5 2.5400111607142857e-05 1.5 2.540066964285714e-05 0.0 2.5402901785714284e-05 0.0 2.540345982142857e-05 1.5 2.541796875e-05 1.5 2.5418526785714282e-05 0.0 2.5420758928571426e-05 0.0 2.5421316964285713e-05 1.5 2.543582589285714e-05 1.5 2.5436383928571428e-05 0.0 2.543861607142857e-05 0.0 2.5439174107142855e-05 1.5 2.5453683035714284e-05 1.5 2.545424107142857e-05 0.0 2.5456473214285714e-05 0.0 2.5457031249999997e-05 1.5 2.5471540178571426e-05 1.5 2.5472098214285713e-05 0.0 2.5474330357142856e-05 0.0 2.547488839285714e-05 1.5 2.548939732142857e-05 1.5 2.5489955357142855e-05 0.0 2.54921875e-05 0.0 2.5492745535714286e-05 1.5 2.5507254464285714e-05 1.5 2.5507812499999997e-05 0.0 2.551004464285714e-05 0.0 2.5510602678571428e-05 1.5 2.5525111607142856e-05 1.5 2.552566964285714e-05 0.0 2.5527901785714283e-05 0.0 2.552845982142857e-05 1.5 2.554296875e-05 1.5 2.5543526785714285e-05 0.0 2.5545758928571426e-05 0.0 2.5546316964285712e-05 1.5 2.556082589285714e-05 1.5 2.5561383928571428e-05 0.0 2.5563616071428568e-05 0.0 2.5564174107142855e-05 1.5 2.5578683035714283e-05 1.5 2.557924107142857e-05 0.0 2.5581473214285714e-05 0.0 2.5582031249999997e-05 1.5 2.5596540178571426e-05 1.5 2.5597098214285712e-05 0.0 2.5599330357142856e-05 0.0 2.559988839285714e-05 1.5 2.5614397321428568e-05 1.5 2.5614955357142855e-05 0.0 2.56171875e-05 0.0 2.5617745535714285e-05 1.5 2.5632254464285714e-05 1.5 2.5632812499999997e-05 0.0 2.563504464285714e-05 0.0 2.5635602678571427e-05 1.5 2.5650111607142856e-05 1.5 2.565066964285714e-05 0.0 2.5652901785714283e-05 0.0 2.565345982142857e-05 1.5 2.566796875e-05 1.5 2.5668526785714285e-05 0.0 2.5670758928571425e-05 0.0 2.5671316964285712e-05 1.5 2.568582589285714e-05 1.5 2.5686383928571427e-05 0.0 2.568861607142857e-05 0.0 2.5689174107142854e-05 1.5 2.5703683035714283e-05 1.5 2.570424107142857e-05 0.0 2.5706473214285713e-05 0.0 2.5707031249999997e-05 1.5 2.5721540178571425e-05 1.5 2.5722098214285712e-05 0.0 2.5724330357142856e-05 0.0 2.5724888392857142e-05 1.5 2.573939732142857e-05 1.5 2.5739955357142854e-05 0.0 2.5742187499999998e-05 0.0 2.5742745535714285e-05 1.5 2.5757254464285713e-05 1.5 2.5757812499999997e-05 0.0 2.576004464285714e-05 0.0 2.5760602678571427e-05 1.5 2.5775111607142856e-05 1.5 2.5775669642857142e-05 0.0 2.5777901785714283e-05 0.0 2.577845982142857e-05 1.5 2.5792968749999998e-05 1.5 2.5793526785714285e-05 0.0 2.5795758928571425e-05 0.0 2.5796316964285712e-05 1.5 2.581082589285714e-05 1.5 2.5811383928571427e-05 0.0 2.581361607142857e-05 0.0 2.5814174107142854e-05 1.5 2.5828683035714283e-05 1.5 2.582924107142857e-05 0.0 2.5831473214285713e-05 0.0 2.583203125e-05 1.5 2.584654017857143e-05 1.5 2.5847098214285712e-05 0.0 2.5849330357142855e-05 0.0 2.5849888392857142e-05 1.5 2.586439732142857e-05 1.5 2.5864955357142854e-05 0.0 2.5867187499999998e-05 0.0 2.5867745535714284e-05 1.5 2.5882254464285713e-05 1.5 2.58828125e-05 0.0 2.588504464285714e-05 0.0 2.5885602678571427e-05 1.5 2.5900111607142855e-05 1.5 2.5900669642857142e-05 0.0 2.5902901785714282e-05 0.0 2.590345982142857e-05 1.5 2.5917968749999998e-05 1.5 2.5918526785714284e-05 0.0 2.5920758928571428e-05 0.0 2.592131696428571e-05 1.5 2.593582589285714e-05 1.5 2.5936383928571427e-05 0.0 2.593861607142857e-05 0.0 2.5939174107142854e-05 1.5 2.5953683035714282e-05 1.5 2.595424107142857e-05 0.0 2.5956473214285713e-05 0.0 2.595703125e-05 1.5 2.5971540178571428e-05 1.5 2.597209821428571e-05 0.0 2.5974330357142855e-05 0.0 2.5974888392857142e-05 1.5 2.598939732142857e-05 1.5 2.5989955357142854e-05 0.0 2.5992187499999997e-05 0.0 2.5992745535714284e-05 1.5 2.6007254464285713e-05 1.5 2.60078125e-05 0.0 2.601004464285714e-05 0.0 2.6010602678571426e-05 1.5 2.6025111607142855e-05 1.5 2.6025669642857142e-05 0.0 2.6027901785714285e-05 0.0 2.602845982142857e-05 1.5 2.6042968749999997e-05 1.5 2.6043526785714284e-05 0.0 2.6045758928571428e-05 0.0 2.604631696428571e-05 1.5 2.606082589285714e-05 1.5 2.6061383928571426e-05 0.0 2.606361607142857e-05 0.0 2.6064174107142857e-05 1.5 2.6078683035714285e-05 1.5 2.607924107142857e-05 0.0 2.6081473214285712e-05 0.0 2.608203125e-05 1.5 2.6096540178571428e-05 1.5 2.609709821428571e-05 0.0 2.6099330357142855e-05 0.0 2.609988839285714e-05 1.5 2.611439732142857e-05 1.5 2.6114955357142857e-05 0.0 2.6117187499999997e-05 0.0 2.6117745535714284e-05 1.5 2.6132254464285712e-05 1.5 2.61328125e-05 0.0 2.613504464285714e-05 0.0 2.6135602678571426e-05 1.5 2.6150111607142855e-05 1.5 2.615066964285714e-05 0.0 2.6152901785714285e-05 0.0 2.615345982142857e-05 1.5 2.6167968749999997e-05 1.5 2.6168526785714284e-05 0.0 2.6170758928571427e-05 0.0 2.617131696428571e-05 1.5 2.618582589285714e-05 1.5 2.6186383928571426e-05 0.0 2.618861607142857e-05 0.0 2.6189174107142856e-05 1.5 2.6203683035714285e-05 1.5 2.620424107142857e-05 0.0 2.6206473214285712e-05 0.0 2.620703125e-05 1.5 2.6221540178571427e-05 1.5 2.6222098214285714e-05 0.0 2.6224330357142854e-05 0.0 2.622488839285714e-05 1.5 2.623939732142857e-05 1.5 2.6239955357142856e-05 0.0 2.6242187499999997e-05 0.0 2.6242745535714283e-05 1.5 2.6257254464285712e-05 1.5 2.62578125e-05 0.0 2.6260044642857142e-05 0.0 2.6260602678571426e-05 1.5 2.6275111607142854e-05 1.5 2.627566964285714e-05 0.0 2.6277901785714285e-05 0.0 2.6278459821428568e-05 1.5 2.6292968749999997e-05 1.5 2.6293526785714283e-05 0.0 2.6295758928571427e-05 0.0 2.6296316964285714e-05 1.5 2.6310825892857142e-05 1.5 2.6311383928571426e-05 0.0 2.631361607142857e-05 0.0 2.6314174107142856e-05 1.5 2.6328683035714285e-05 1.5 2.6329241071428568e-05 0.0 2.633147321428571e-05 0.0 2.633203125e-05 1.5 2.6346540178571427e-05 1.5 2.6347098214285714e-05 0.0 2.6349330357142854e-05 0.0 2.634988839285714e-05 1.5 2.636439732142857e-05 1.5 2.6364955357142856e-05 0.0 2.63671875e-05 0.0 2.6367745535714283e-05 1.5 2.638225446428571e-05 1.5 2.63828125e-05 0.0 2.6385044642857142e-05 0.0 2.6385602678571425e-05 1.5 2.6400111607142854e-05 1.5 2.640066964285714e-05 0.0 2.6402901785714284e-05 0.0 2.640345982142857e-05 1.5 2.641796875e-05 1.5 2.6418526785714283e-05 0.0 2.6420758928571427e-05 0.0 2.6421316964285713e-05 1.5 2.6435825892857142e-05 1.5 2.6436383928571425e-05 0.0 2.643861607142857e-05 0.0 2.6439174107142856e-05 1.5 2.6453683035714284e-05 1.5 2.645424107142857e-05 0.0 2.645647321428571e-05 0.0 2.6457031249999998e-05 1.5 2.6471540178571427e-05 1.5 2.6472098214285713e-05 0.0 2.6474330357142854e-05 0.0 2.647488839285714e-05 1.5 2.648939732142857e-05 1.5 2.6489955357142856e-05 0.0 2.64921875e-05 0.0 2.6492745535714283e-05 1.5 2.650725446428571e-05 1.5 2.6507812499999998e-05 0.0 2.651004464285714e-05 0.0 2.6510602678571425e-05 1.5 2.6525111607142854e-05 1.5 2.652566964285714e-05 0.0 2.6527901785714284e-05 0.0 2.652845982142857e-05 1.5 2.654296875e-05 1.5 2.6543526785714283e-05 0.0 2.6545758928571426e-05 0.0 2.6546316964285713e-05 1.5 2.656082589285714e-05 1.5 2.6561383928571425e-05 0.0 2.656361607142857e-05 0.0 2.6564174107142855e-05 1.5 2.6578683035714284e-05 1.5 2.657924107142857e-05 0.0 2.658147321428571e-05 0.0 2.6582031249999998e-05 1.5 2.6596540178571426e-05 1.5 2.6597098214285713e-05 0.0 2.6599330357142857e-05 0.0 2.659988839285714e-05 1.5 2.661439732142857e-05 1.5 2.6614955357142855e-05 0.0 2.66171875e-05 0.0 2.6617745535714282e-05 1.5 2.663225446428571e-05 1.5 2.6632812499999998e-05 0.0 2.663504464285714e-05 0.0 2.6635602678571428e-05 1.5 2.6650111607142857e-05 1.5 2.665066964285714e-05 0.0 2.6652901785714284e-05 0.0 2.665345982142857e-05 1.5 2.666796875e-05 1.5 2.6668526785714282e-05 0.0 2.6670758928571426e-05 0.0 2.6671316964285713e-05 1.5 2.668582589285714e-05 1.5 2.6686383928571428e-05 0.0 2.6688616071428568e-05 0.0 2.6689174107142855e-05 1.5 2.6703683035714284e-05 1.5 2.670424107142857e-05 0.0 2.6706473214285714e-05 0.0 2.6707031249999997e-05 1.5 2.6721540178571426e-05 1.5 2.6722098214285713e-05 0.0 2.6724330357142856e-05 0.0 2.672488839285714e-05 1.5 2.6739397321428568e-05 1.5 2.6739955357142855e-05 0.0 2.67421875e-05 0.0 2.6742745535714285e-05 1.5 2.6757254464285714e-05 1.5 2.6757812499999997e-05 0.0 2.676004464285714e-05 0.0 2.6760602678571428e-05 1.5 2.6775111607142856e-05 1.5 2.677566964285714e-05 0.0 2.6777901785714283e-05 0.0 2.677845982142857e-05 1.5 2.679296875e-05 1.5 2.6793526785714285e-05 0.0 2.6795758928571426e-05 0.0 2.6796316964285712e-05 1.5 2.681082589285714e-05 1.5 2.6811383928571428e-05 0.0 2.6813616071428568e-05 0.0 2.6814174107142855e-05 1.5 2.6828683035714283e-05 1.5 2.682924107142857e-05 0.0 2.6832031249999997e-05 0.0 2.6832589285714284e-05 1.5 2.6845982142857142e-05 1.5 2.6846540178571426e-05 0.0 2.684988839285714e-05 0.0 2.6850446428571426e-05 1.5 2.6863839285714285e-05 1.5 2.6864397321428568e-05 0.0 2.6867745535714285e-05 0.0 2.686830357142857e-05 1.5 2.6881696428571427e-05 1.5 2.6882254464285714e-05 0.0 2.6885602678571427e-05 0.0 2.688616071428571e-05 1.5 2.689955357142857e-05 1.5 2.6900111607142856e-05 0.0 2.690345982142857e-05 0.0 2.6904017857142856e-05 1.5 2.691741071428571e-05 1.5 2.6917968749999998e-05 0.0 2.6921316964285712e-05 0.0 2.6921875e-05 1.5 2.6935267857142854e-05 1.5 2.693582589285714e-05 0.0 2.6939174107142854e-05 0.0 2.693973214285714e-05 1.5 2.6953125e-05 1.5 2.6953683035714283e-05 0.0 2.6957031249999997e-05 0.0 2.6957589285714283e-05 1.5 2.6970982142857142e-05 1.5 2.6971540178571425e-05 0.0 2.6974888392857142e-05 0.0 2.6975446428571426e-05 1.5 2.6988839285714284e-05 1.5 2.698939732142857e-05 0.0 2.6992745535714285e-05 0.0 2.6993303571428568e-05 1.5 2.7006696428571427e-05 1.5 2.7007254464285713e-05 0.0 2.7010602678571427e-05 0.0 2.7011160714285714e-05 1.5 2.702455357142857e-05 1.5 2.7025111607142856e-05 0.0 2.702845982142857e-05 0.0 2.7029017857142856e-05 1.5 2.704241071428571e-05 1.5 2.7042968749999998e-05 0.0 2.704631696428571e-05 0.0 2.7046875e-05 1.5 2.7060267857142857e-05 1.5 2.706082589285714e-05 0.0 2.7064174107142854e-05 0.0 2.706473214285714e-05 1.5 2.7078125e-05 1.5 2.7078683035714283e-05 0.0 2.708203125e-05 0.0 2.7082589285714283e-05 1.5 2.709598214285714e-05 1.5 2.7096540178571428e-05 0.0 2.7099888392857142e-05 0.0 2.7100446428571425e-05 1.5 2.7113839285714284e-05 1.5 2.711439732142857e-05 0.0 2.7117745535714284e-05 0.0 2.711830357142857e-05 1.5 2.7131696428571426e-05 1.5 2.7132254464285713e-05 0.0 2.7135602678571427e-05 0.0 2.7136160714285713e-05 1.5 2.714955357142857e-05 1.5 2.7150111607142855e-05 0.0 2.715345982142857e-05 0.0 2.7154017857142856e-05 1.5 2.7166852678571427e-05 1.5 2.716741071428571e-05 0.0 2.7171874999999998e-05 0.0 2.7172433035714285e-05 1.5 2.718470982142857e-05 1.5 2.7185267857142857e-05 0.0 2.718973214285714e-05 0.0 2.7190290178571427e-05 1.5 2.7202566964285712e-05 1.5 2.7203125e-05 0.0 2.7207589285714283e-05 0.0 2.720814732142857e-05 1.5 2.7220424107142854e-05 1.5 2.722098214285714e-05 0.0 2.7225446428571425e-05 0.0 2.7226004464285712e-05 1.5 2.7238281249999997e-05 1.5 2.7238839285714283e-05 0.0 2.724330357142857e-05 0.0 2.7243861607142854e-05 1.5 2.7256138392857142e-05 1.5 2.7256696428571426e-05 0.0 2.7261160714285713e-05 0.0 2.7261718749999996e-05 1.5 2.7273995535714285e-05 1.5 2.7274553571428568e-05 0.0 2.7279017857142855e-05 0.0 2.7279575892857142e-05 1.5 2.7291852678571427e-05 1.5 2.7292410714285714e-05 0.0 2.7296874999999998e-05 0.0 2.7297433035714284e-05 1.5 2.730970982142857e-05 1.5 2.7310267857142856e-05 0.0 2.731473214285714e-05 0.0 2.7315290178571427e-05 1.5 2.7327566964285712e-05 1.5 2.7328125e-05 0.0 2.7332589285714282e-05 0.0 2.733314732142857e-05 1.5 2.7345424107142854e-05 1.5 2.734598214285714e-05 0.0 2.7350446428571428e-05 0.0 2.735100446428571e-05 1.5 2.7363281249999996e-05 1.5 2.7363839285714283e-05 0.0 2.736830357142857e-05 0.0 2.7368861607142854e-05 1.5 2.7381138392857142e-05 1.5 2.7381696428571425e-05 0.0 2.7386160714285713e-05 0.0 2.738671875e-05 1.5 2.7398995535714284e-05 1.5 2.7399553571428568e-05 0.0 2.7404017857142855e-05 0.0 2.7404575892857142e-05 1.5 2.7416852678571427e-05 1.5 2.7417410714285713e-05 0.0 2.7422433035714284e-05 0.0 2.742299107142857e-05 1.5 2.7434151785714282e-05 1.5 2.743470982142857e-05 0.0 2.7440290178571426e-05 0.0 2.7440848214285713e-05 1.5 2.7452008928571428e-05 1.5 2.745256696428571e-05 0.0 2.745814732142857e-05 0.0 2.7458705357142856e-05 1.5 2.746986607142857e-05 1.5 2.7470424107142854e-05 0.0 2.747600446428571e-05 0.0 2.7476562499999998e-05 1.5 2.7487723214285713e-05 1.5 2.748828125e-05 0.0 2.7493861607142857e-05 0.0 2.749441964285714e-05 1.5 2.7505580357142855e-05 1.5 2.7506138392857142e-05 0.0 2.751171875e-05 0.0 2.7512276785714283e-05 1.5 2.7523437499999997e-05 1.5 2.7523995535714284e-05 0.0 2.752957589285714e-05 0.0 2.7530133928571428e-05 1.5 2.754129464285714e-05 1.5 2.7541852678571426e-05 0.0 2.7547433035714284e-05 0.0 2.754799107142857e-05 1.5 2.7559151785714285e-05 1.5 2.755970982142857e-05 0.0 2.7565290178571426e-05 0.0 2.7565848214285713e-05 1.5 2.7577008928571428e-05 1.5 2.757756696428571e-05 0.0 2.758314732142857e-05 0.0 2.7583705357142855e-05 1.5 2.759486607142857e-05 1.5 2.7595424107142857e-05 0.0 2.760100446428571e-05 0.0 2.7601562499999998e-05 1.5 2.7612723214285712e-05 1.5 2.761328125e-05 0.0 2.7618861607142856e-05 0.0 2.761941964285714e-05 1.5 2.7630580357142855e-05 1.5 2.763113839285714e-05 0.0 2.763671875e-05 0.0 2.7637276785714282e-05 1.5 2.7648437499999997e-05 1.5 2.7648995535714284e-05 0.0 2.765457589285714e-05 0.0 2.7655133928571428e-05 1.5 2.7665736607142856e-05 1.5 2.766629464285714e-05 0.0 2.767299107142857e-05 0.0 2.7673549107142854e-05 1.5 2.7683593749999998e-05 1.5 2.7684151785714285e-05 0.0 2.7690848214285713e-05 0.0 2.769140625e-05 1.5 2.770145089285714e-05 1.5 2.7702008928571427e-05 0.0 2.7708705357142855e-05 0.0 2.770926339285714e-05 1.5 2.7719308035714283e-05 1.5 2.771986607142857e-05 0.0 2.7726562499999997e-05 0.0 2.7727120535714284e-05 1.5 2.7737165178571425e-05 1.5 2.7737723214285712e-05 0.0 2.774441964285714e-05 0.0 2.7744977678571426e-05 1.5 2.775502232142857e-05 1.5 2.7755580357142854e-05 0.0 2.7762276785714285e-05 0.0 2.776283482142857e-05 1.5 2.7772879464285713e-05 1.5 2.7773437499999997e-05 0.0 2.7780133928571428e-05 0.0 2.778069196428571e-05 1.5 2.7790736607142856e-05 1.5 2.7791294642857142e-05 0.0 2.779799107142857e-05 0.0 2.7798549107142857e-05 1.5 2.7808593749999998e-05 1.5 2.7809151785714285e-05 0.0 2.7815848214285712e-05 0.0 2.781640625e-05 1.5 2.782645089285714e-05 1.5 2.7827008928571427e-05 0.0 2.7833705357142854e-05 0.0 2.783426339285714e-05 1.5 2.7844308035714283e-05 1.5 2.784486607142857e-05 0.0 2.7851562499999997e-05 0.0 2.7852120535714284e-05 1.5 2.7862165178571428e-05 1.5 2.786272321428571e-05 0.0 2.7869419642857143e-05 0.0 2.7869977678571426e-05 1.5 2.7879464285714284e-05 1.5 2.788002232142857e-05 0.0 2.7887834821428568e-05 0.0 2.7888392857142855e-05 1.5 2.7897321428571426e-05 1.5 2.7897879464285713e-05 0.0 2.7905691964285714e-05 0.0 2.7906249999999997e-05 1.5 2.791517857142857e-05 1.5 2.7915736607142855e-05 0.0 2.7923549107142856e-05 0.0 2.792410714285714e-05 1.5 2.793303571428571e-05 1.5 2.7933593749999998e-05 0.0 2.794140625e-05 0.0 2.7941964285714285e-05 1.5 2.7950892857142856e-05 1.5 2.795145089285714e-05 0.0 2.795926339285714e-05 0.0 2.7959821428571428e-05 1.5 2.796875e-05 1.5 2.7969308035714282e-05 0.0 2.7977120535714283e-05 0.0 2.797767857142857e-05 1.5 2.798660714285714e-05 1.5 2.7987165178571428e-05 0.0 2.7994977678571426e-05 0.0 2.7995535714285712e-05 1.5 2.8004464285714283e-05 1.5 2.800502232142857e-05 0.0 2.8012834821428568e-05 0.0 2.8013392857142855e-05 1.5 2.8022321428571426e-05 1.5 2.8022879464285713e-05 0.0 2.8030691964285714e-05 0.0 2.8031249999999997e-05 1.5 2.8040178571428568e-05 1.5 2.8040736607142855e-05 0.0 2.8048549107142856e-05 0.0 2.804910714285714e-05 1.5 2.8058035714285714e-05 1.5 2.8058593749999997e-05 0.0 2.8066406249999998e-05 0.0 2.8066964285714285e-05 1.5 2.8075892857142856e-05 1.5 2.807645089285714e-05 0.0 2.808426339285714e-05 0.0 2.8084821428571427e-05 1.5 2.8093191964285712e-05 1.5 2.809375e-05 0.0 2.810267857142857e-05 0.0 2.8103236607142856e-05 1.5 2.8111049107142854e-05 1.5 2.811160714285714e-05 0.0 2.8120535714285712e-05 0.0 2.812109375e-05 1.5 2.8128906249999996e-05 1.5 2.8129464285714283e-05 0.0 2.8138392857142854e-05 0.0 2.813895089285714e-05 1.5 2.8146763392857142e-05 1.5 2.8147321428571425e-05 0.0 2.8156249999999997e-05 0.0 2.8156808035714283e-05 1.5 2.8164620535714284e-05 1.5 2.8165178571428568e-05 0.0 2.8174107142857142e-05 0.0 2.8174665178571426e-05 1.5 2.8182477678571427e-05 1.5 2.8183035714285713e-05 0.0 2.8191964285714285e-05 0.0 2.8192522321428568e-05 1.5 2.820033482142857e-05 1.5 2.8200892857142856e-05 0.0 2.8209821428571427e-05 0.0 2.8210379464285714e-05 1.5 2.821819196428571e-05 1.5 2.8218749999999998e-05 0.0 2.822767857142857e-05 0.0 2.8228236607142856e-05 1.5 2.8236049107142854e-05 1.5 2.823660714285714e-05 0.0 2.824553571428571e-05 0.0 2.824609375e-05 1.5 2.825390625e-05 1.5 2.8254464285714283e-05 0.0 2.8263392857142854e-05 0.0 2.826395089285714e-05 1.5 2.8271763392857142e-05 1.5 2.8272321428571425e-05 0.0 2.828125e-05 0.0 2.8281808035714283e-05 1.5 2.8289620535714284e-05 1.5 2.829017857142857e-05 0.0 2.8299107142857142e-05 0.0 2.8299665178571425e-05 1.5 2.830691964285714e-05 1.5 2.8307477678571426e-05 0.0 2.831752232142857e-05 0.0 2.8318080357142854e-05 1.5 2.8324776785714285e-05 1.5 2.832533482142857e-05 0.0 2.8335379464285713e-05 0.0 2.8335937499999997e-05 1.5 2.8342633928571428e-05 1.5 2.834319196428571e-05 0.0 2.8353236607142856e-05 0.0 2.8353794642857142e-05 1.5 2.836049107142857e-05 1.5 2.8361049107142857e-05 0.0 2.8371093749999998e-05 0.0 2.8371651785714285e-05 1.5 2.8378348214285712e-05 1.5 2.837890625e-05 0.0 2.838895089285714e-05 0.0 2.8389508928571427e-05 1.5 2.8396205357142855e-05 1.5 2.839676339285714e-05 0.0 2.8406808035714283e-05 0.0 2.840736607142857e-05 1.5 2.8414062499999997e-05 1.5 2.8414620535714284e-05 0.0 2.8424665178571425e-05 0.0 2.8425223214285712e-05 1.5 2.843191964285714e-05 1.5 2.8432477678571426e-05 0.0 2.844252232142857e-05 0.0 2.8443080357142854e-05 1.5 2.8449776785714285e-05 1.5 2.845033482142857e-05 0.0 2.8460379464285713e-05 0.0 2.8460937499999996e-05 1.5 2.8467633928571427e-05 1.5 2.846819196428571e-05 0.0 2.8478236607142855e-05 0.0 2.8478794642857142e-05 1.5 2.848549107142857e-05 1.5 2.8486049107142856e-05 0.0 2.8496093749999998e-05 0.0 2.8496651785714284e-05 1.5 2.8503348214285712e-05 1.5 2.850390625e-05 0.0 2.851395089285714e-05 0.0 2.8514508928571427e-05 1.5 2.8521205357142854e-05 1.5 2.852176339285714e-05 0.0 2.853236607142857e-05 0.0 2.8532924107142856e-05 1.5 2.8538504464285713e-05 1.5 2.8539062499999997e-05 0.0 2.855022321428571e-05 0.0 2.8550781249999998e-05 1.5 2.8556361607142856e-05 1.5 2.8556919642857142e-05 0.0 2.8568080357142854e-05 0.0 2.856863839285714e-05 1.5 2.8574218749999998e-05 1.5 2.8574776785714285e-05 0.0 2.85859375e-05 0.0 2.8586495535714283e-05 1.5 2.859207589285714e-05 1.5 2.8592633928571427e-05 0.0 2.8603794642857142e-05 0.0 2.8604352678571425e-05 1.5 2.8609933035714283e-05 1.5 2.861049107142857e-05 0.0 2.8621651785714284e-05 0.0 2.862220982142857e-05 1.5 2.8627790178571425e-05 1.5 2.862834821428571e-05 0.0 2.8639508928571426e-05 0.0 2.8640066964285713e-05 1.5 2.864564732142857e-05 1.5 2.8646205357142854e-05 0.0 2.865736607142857e-05 0.0 2.8657924107142855e-05 1.5 2.8663504464285713e-05 1.5 2.86640625e-05 0.0 2.867522321428571e-05 0.0 2.8675781249999998e-05 1.5 2.8681361607142855e-05 1.5 2.8681919642857142e-05 0.0 2.8693080357142857e-05 0.0 2.869363839285714e-05 1.5 2.8699218749999998e-05 1.5 2.8699776785714284e-05 0.0 2.87109375e-05 0.0 2.8711495535714282e-05 1.5 2.871707589285714e-05 1.5 2.8717633928571427e-05 0.0 2.872879464285714e-05 0.0 2.8729352678571428e-05 1.5 2.8734933035714282e-05 1.5 2.873549107142857e-05 0.0 2.8746651785714284e-05 0.0 2.874720982142857e-05 1.5 2.8752790178571428e-05 1.5 2.875334821428571e-05 0.0 2.8765066964285713e-05 0.0 2.8765625e-05 1.5 2.8770089285714283e-05 1.5 2.877064732142857e-05 0.0 2.8782924107142855e-05 0.0 2.8783482142857142e-05 1.5 2.8787946428571426e-05 1.5 2.8788504464285713e-05 0.0 2.8800781249999997e-05 0.0 2.8801339285714284e-05 1.5 2.8805803571428568e-05 1.5 2.8806361607142855e-05 0.0 2.881863839285714e-05 0.0 2.8819196428571427e-05 1.5 2.8823660714285714e-05 1.5 2.8824218749999997e-05 0.0 2.8836495535714282e-05 0.0 2.883705357142857e-05 1.5 2.8841517857142856e-05 1.5 2.884207589285714e-05 0.0 2.8854352678571428e-05 0.0 2.885491071428571e-05 1.5 2.8859375e-05 1.5 2.8859933035714285e-05 0.0 2.887220982142857e-05 0.0 2.8872767857142853e-05 1.5 2.887723214285714e-05 1.5 2.8877790178571428e-05 0.0 2.8890066964285712e-05 0.0 2.8890625e-05 1.5 2.8895089285714283e-05 1.5 2.889564732142857e-05 0.0 2.8907924107142855e-05 0.0 2.890848214285714e-05 1.5 2.8912946428571425e-05 1.5 2.8913504464285712e-05 0.0 2.8925781249999997e-05 0.0 2.8926339285714284e-05 1.5 2.8930803571428568e-05 1.5 2.8931361607142854e-05 0.0 2.894363839285714e-05 0.0 2.8944196428571426e-05 1.5 2.8948660714285713e-05 1.5 2.8949218749999997e-05 0.0 2.8961495535714285e-05 0.0 2.896205357142857e-05 1.5 2.8966517857142856e-05 1.5 2.896707589285714e-05 0.0 2.8979352678571427e-05 0.0 2.897991071428571e-05 1.5 2.8984374999999998e-05 1.5 2.8984933035714285e-05 0.0 2.899720982142857e-05 0.0 2.8997767857142857e-05 1.5 2.900223214285714e-05 1.5 2.9002790178571427e-05 0.0 2.9015066964285712e-05 0.0 2.9015625e-05 1.5 2.9020089285714283e-05 1.5 2.902064732142857e-05 0.0 2.903348214285714e-05 0.0 2.9034040178571428e-05 1.5 2.9037388392857142e-05 1.5 2.9037946428571425e-05 0.0 2.9051339285714284e-05 0.0 2.905189732142857e-05 1.5 2.9055245535714284e-05 1.5 2.905580357142857e-05 0.0 2.9069196428571426e-05 0.0 2.9069754464285713e-05 1.5 2.9073102678571426e-05 1.5 2.9073660714285713e-05 0.0 2.9087053571428568e-05 0.0 2.9087611607142855e-05 1.5 2.909095982142857e-05 1.5 2.9091517857142855e-05 0.0 2.9104910714285714e-05 0.0 2.9105468749999997e-05 1.5 2.910881696428571e-05 1.5 2.9109374999999998e-05 0.0 2.9122767857142856e-05 0.0 2.912332589285714e-05 1.5 2.9126674107142857e-05 1.5 2.912723214285714e-05 0.0 2.9140625e-05 0.0 2.9141183035714285e-05 1.5 2.914453125e-05 1.5 2.9145089285714282e-05 0.0 2.915848214285714e-05 0.0 2.9159040178571428e-05 1.5 2.916238839285714e-05 1.5 2.9162946428571428e-05 0.0 2.9176339285714283e-05 0.0 2.917689732142857e-05 1.5 2.9180245535714284e-05 1.5 2.918080357142857e-05 0.0 2.9194196428571425e-05 0.0 2.9194754464285712e-05 1.5 2.9198102678571426e-05 1.5 2.9198660714285713e-05 0.0 2.9212053571428568e-05 0.0 2.9212611607142855e-05 1.5 2.921595982142857e-05 1.5 2.9216517857142855e-05 0.0 2.9229910714285714e-05 0.0 2.9230468749999997e-05 1.5 2.923381696428571e-05 1.5 2.9234374999999997e-05 0.0 2.9247767857142856e-05 0.0 2.924832589285714e-05 1.5 2.9251674107142856e-05 1.5 2.925223214285714e-05 0.0 2.9265624999999998e-05 0.0 2.9266183035714285e-05 1.5 2.926953125e-05 1.5 2.9270089285714282e-05 0.0 2.928348214285714e-05 0.0 2.9284040178571427e-05 1.5 2.928738839285714e-05 1.5 2.9287946428571428e-05 0.0 2.9301339285714283e-05 0.0 2.930189732142857e-05 1.5 2.9305245535714283e-05 1.5 2.930580357142857e-05 0.0 2.9319196428571425e-05 0.0 2.9319754464285712e-05 1.5 2.9323102678571426e-05 1.5 2.9323660714285712e-05 0.0 2.933705357142857e-05 0.0 2.9337611607142854e-05 1.5 2.9340959821428568e-05 1.5 2.9341517857142855e-05 0.0 2.9355468749999997e-05 0.0 2.9356026785714283e-05 1.5 2.9358258928571427e-05 1.5 2.9358816964285714e-05 0.0 2.9373325892857142e-05 0.0 2.9373883928571426e-05 1.5 2.937611607142857e-05 1.5 2.9376674107142856e-05 0.0 2.9391183035714285e-05 0.0 2.9391741071428568e-05 1.5 2.939397321428571e-05 1.5 2.939453125e-05 0.0 2.9409040178571427e-05 0.0 2.9409598214285714e-05 1.5 2.9411830357142854e-05 1.5 2.941238839285714e-05 0.0 2.942689732142857e-05 0.0 2.9427455357142856e-05 1.5 2.9429687499999996e-05 1.5 2.9430245535714283e-05 0.0 2.944475446428571e-05 0.0 2.9445312499999998e-05 1.5 2.9447544642857142e-05 1.5 2.9448102678571425e-05 0.0 2.9462611607142854e-05 0.0 2.946316964285714e-05 1.5 2.9465401785714284e-05 1.5 2.946595982142857e-05 0.0 2.948046875e-05 0.0 2.9481026785714283e-05 1.5 2.9483258928571427e-05 1.5 2.9483816964285713e-05 0.0 2.9498325892857142e-05 0.0 2.9498883928571425e-05 1.5 2.950111607142857e-05 1.5 2.9501674107142856e-05 0.0 2.9516183035714284e-05 0.0 2.951674107142857e-05 1.5 2.951897321428571e-05 1.5 2.9519531249999998e-05 0.0 2.9534040178571427e-05 0.0 2.9534598214285713e-05 1.5 2.9536830357142854e-05 1.5 2.953738839285714e-05 0.0 2.955189732142857e-05 0.0 2.9552455357142856e-05 1.5 2.95546875e-05 1.5 2.9555245535714283e-05 0.0 2.956975446428571e-05 0.0 2.9570312499999998e-05 1.5 2.957254464285714e-05 1.5 2.9573102678571425e-05 0.0 2.9587611607142854e-05 0.0 2.958816964285714e-05 1.5 2.9590401785714284e-05 1.5 2.959095982142857e-05 0.0 2.960546875e-05 0.0 2.9606026785714283e-05 1.5 2.9608258928571426e-05 1.5 2.9608816964285713e-05 0.0 2.962332589285714e-05 0.0 2.9623883928571425e-05 1.5 2.962611607142857e-05 1.5 2.9626674107142855e-05 0.0 2.9641183035714284e-05 0.0 2.964174107142857e-05 1.5 2.964397321428571e-05 1.5 2.9644531249999998e-05 0.0 2.9659040178571426e-05 0.0 2.9659598214285713e-05 1.5 2.9661830357142857e-05 1.5 2.966238839285714e-05 0.0 2.967689732142857e-05 0.0 2.9677455357142855e-05 1.5 2.96796875e-05 1.5 2.9680245535714282e-05 0.0 2.969475446428571e-05 0.0 2.9695312499999998e-05 1.5 2.969754464285714e-05 1.5 2.9698102678571428e-05 0.0 2.9712611607142857e-05 0.0 2.971316964285714e-05 1.5 2.9715401785714284e-05 1.5 2.971595982142857e-05 0.0 2.973046875e-05 0.0 2.9731026785714282e-05 1.5 2.9733258928571426e-05 1.5 2.9733816964285713e-05 0.0 2.974832589285714e-05 0.0 2.9748883928571428e-05 1.5 2.9751116071428568e-05 1.5 2.9751674107142855e-05 0.0 2.9766183035714284e-05 0.0 2.976674107142857e-05 1.5 2.976897321428571e-05 1.5 2.9769531249999997e-05 0.0 2.9784040178571426e-05 0.0 2.9784598214285713e-05 1.5 2.9786830357142856e-05 1.5 2.978738839285714e-05 0.0 2.9801897321428568e-05 0.0 2.9802455357142855e-05 1.5 2.98046875e-05 1.5 2.9805245535714282e-05 0.0 2.981975446428571e-05 0.0 2.9820312499999997e-05 1.5 2.982254464285714e-05 1.5 2.9823102678571428e-05 0.0 2.9837611607142856e-05 0.0 2.983816964285714e-05 1.5 2.9840401785714283e-05 1.5 2.984095982142857e-05 0.0 2.985546875e-05 0.0 2.9856026785714282e-05 1.5 2.9858258928571426e-05 1.5 2.9858816964285712e-05 0.0 2.987332589285714e-05 0.0 2.9873883928571428e-05 1.5 2.9876116071428568e-05 1.5 2.9876674107142855e-05 0.0 2.9891183035714283e-05 0.0 2.989174107142857e-05 1.5 2.9893973214285714e-05 1.5 2.9894531249999997e-05 0.0 2.9909040178571425e-05 0.0 2.9909598214285712e-05 1.5 2.9911830357142856e-05 1.5 2.991238839285714e-05 0.0 2.9926897321428568e-05 0.0 2.9927455357142855e-05 1.5 2.9929687499999998e-05 1.5 2.9930245535714285e-05 0.0 2.9944754464285714e-05 0.0 2.9945312499999997e-05 1.5 2.994754464285714e-05 1.5 2.9948102678571427e-05 0.0 2.9962611607142856e-05 0.0 2.996316964285714e-05 1.5 2.9965401785714283e-05 1.5 2.996595982142857e-05 0.0 2.9980468749999998e-05 0.0 2.9981026785714285e-05 1.5 2.9983258928571425e-05 1.5 2.9983816964285712e-05 0.0 2.999832589285714e-05 0.0 2.9998883928571427e-05 1.5 3.000111607142857e-05 1.5 3.0001674107142854e-05 0.0 3.0016183035714283e-05 0.0 3.001674107142857e-05 1.5 3.0018973214285713e-05 1.5 3.0019531249999997e-05 0.0 3.0034040178571425e-05 0.0 3.0034598214285712e-05 1.5 3.0036830357142856e-05 1.5 3.0037388392857142e-05 0.0 3.005189732142857e-05 0.0 3.0052455357142854e-05 1.5 3.0054687499999998e-05 1.5 3.0055245535714285e-05 0.0 3.0069754464285713e-05 0.0 3.0070312499999997e-05 1.5 3.007254464285714e-05 1.5 3.0073102678571427e-05 0.0 3.0087611607142855e-05 0.0 3.0088169642857142e-05 1.5 3.0090401785714283e-05 1.5 3.009095982142857e-05 0.0 3.0105468749999998e-05 0.0 3.0106026785714285e-05 1.5 3.0108258928571425e-05 1.5 3.010881696428571e-05 0.0 3.012332589285714e-05 0.0 3.0123883928571427e-05 1.5 3.012611607142857e-05 1.5 3.0126674107142854e-05 0.0 3.0141183035714282e-05 0.0 3.014174107142857e-05 1.5 3.0143973214285713e-05 1.5 3.0144531249999996e-05 0.0 3.0159040178571425e-05 0.0 3.015959821428571e-05 1.5 3.0161830357142855e-05 1.5 3.0162388392857142e-05 0.0 3.017689732142857e-05 0.0 3.0177455357142854e-05 1.5 3.0179687499999998e-05 1.5 3.0180245535714284e-05 0.0 3.0194754464285713e-05 0.0 3.0195312499999996e-05 1.5 3.019754464285714e-05 1.5 3.0198102678571427e-05 0.0 3.0212611607142855e-05 0.0 3.0213169642857142e-05 1.5 3.0215401785714282e-05 1.5 3.021595982142857e-05 0.0 3.0230468749999997e-05 0.0 3.0231026785714284e-05 1.5 3.0233258928571428e-05 1.5 3.023381696428571e-05 0.0 3.024832589285714e-05 0.0 3.0248883928571427e-05 1.5 3.025111607142857e-05 1.5 3.0251674107142854e-05 0.0 3.0266183035714282e-05 0.0 3.026674107142857e-05 1.5 3.0268973214285713e-05 1.5 3.026953125e-05 0.0 3.0284040178571428e-05 0.0 3.028459821428571e-05 1.5 3.0286830357142855e-05 1.5 3.028738839285714e-05 0.0 3.030189732142857e-05 0.0 3.0302455357142854e-05 1.5 3.0304687499999997e-05 1.5 3.0305245535714284e-05 0.0 3.0319754464285712e-05 0.0 3.03203125e-05 1.5 3.032254464285714e-05 1.5 3.0323102678571426e-05 0.0 3.0337611607142855e-05 0.0 3.033816964285714e-05 1.5 3.0340401785714285e-05 1.5 3.034095982142857e-05 0.0 3.0355468749999997e-05 0.0 3.0356026785714284e-05 1.5 3.0358258928571428e-05 1.5 3.035881696428571e-05 0.0 3.037332589285714e-05 0.0 3.0373883928571426e-05 1.5 3.037611607142857e-05 1.5 3.0376674107142857e-05 0.0 3.0391183035714285e-05 0.0 3.039174107142857e-05 1.5 3.0393973214285712e-05 1.5 3.039453125e-05 0.0 3.0409040178571427e-05 0.0 3.040959821428571e-05 1.5 3.0411830357142854e-05 1.5 3.041238839285714e-05 0.0 3.042689732142857e-05 0.0 3.0427455357142857e-05 1.5 3.0429687499999997e-05 1.5 3.0430245535714284e-05 0.0 3.0444754464285712e-05 0.0 3.04453125e-05 1.5 3.044754464285714e-05 1.5 3.0448102678571426e-05 0.0 3.0462611607142854e-05 0.0 3.046316964285714e-05 1.5 3.0465401785714285e-05 1.5 3.0465959821428568e-05 0.0 3.0480468749999997e-05 0.0 3.0481026785714284e-05 1.5 3.0483258928571427e-05 1.5 3.048381696428571e-05 0.0 3.049832589285714e-05 0.0 3.0498883928571426e-05 1.5 3.050111607142857e-05 1.5 3.0501674107142856e-05 0.0 3.0516183035714285e-05 0.0 3.0516741071428568e-05 1.5 3.051897321428571e-05 1.5 3.0519531249999995e-05 0.0 3.0534040178571424e-05 0.0 3.0534598214285714e-05 1.5 3.0536830357142854e-05 1.5 3.053738839285714e-05 0.0 3.0551897321428566e-05 0.0 3.0552455357142856e-05 1.5 3.0554687499999996e-05 1.5 3.0555245535714287e-05 0.0 3.0569754464285715e-05 0.0 3.05703125e-05 1.5 3.057254464285714e-05 1.5 3.057310267857143e-05 0.0 3.058761160714286e-05 0.0 3.058816964285714e-05 1.5 3.059040178571428e-05 1.5 3.059095982142857e-05 0.0 3.060546875e-05 0.0 3.060602678571428e-05 1.5 3.0608258928571423e-05 1.5 3.0608816964285714e-05 0.0 3.062332589285714e-05 0.0 3.0623883928571425e-05 1.5 3.062611607142857e-05 1.5 3.0626674107142856e-05 0.0 3.0641183035714284e-05 0.0 3.064174107142857e-05 1.5 3.0643973214285715e-05 1.5 3.064453125e-05 0.0 3.065904017857143e-05 0.0 3.065959821428571e-05 1.5 3.066183035714286e-05 1.5 3.066238839285714e-05 0.0 3.067689732142857e-05 0.0 3.067745535714285e-05 1.5 3.06796875e-05 1.5 3.068024553571428e-05 0.0 3.069475446428571e-05 0.0 3.0695312499999995e-05 1.5 3.069754464285714e-05 1.5 3.0698102678571425e-05 0.0 3.0712611607142854e-05 0.0 3.0713169642857144e-05 1.5 3.0715401785714284e-05 1.5 3.071595982142857e-05 0.0 3.0730468749999996e-05 0.0 3.0731026785714286e-05 1.5 3.0733258928571426e-05 1.5 3.073381696428571e-05 0.0 3.074832589285714e-05 0.0 3.074888392857143e-05 1.5 3.075111607142857e-05 1.5 3.075167410714285e-05 0.0 3.076618303571428e-05 0.0 3.076674107142857e-05 1.5 3.076897321428571e-05 1.5 3.0769531249999994e-05 0.0 3.078404017857142e-05 0.0 3.078459821428571e-05 1.5 3.0786830357142853e-05 1.5 3.0787388392857144e-05 0.0 3.080189732142857e-05 0.0 3.0802455357142856e-05 1.5 3.0804687499999996e-05 1.5 3.0805245535714286e-05 0.0 3.0819754464285714e-05 0.0 3.08203125e-05 1.5 3.082254464285714e-05 1.5 3.082310267857143e-05 0.0 3.083761160714286e-05 0.0 3.083816964285714e-05 1.5 3.084040178571428e-05 1.5 3.084095982142857e-05 0.0 3.085491071428571e-05 0.0 3.085546875e-05 1.5 3.085881696428571e-05 1.5 3.0859374999999996e-05 0.0 3.087276785714286e-05 0.0 3.087332589285714e-05 1.5 3.0876674107142855e-05 1.5 3.087723214285714e-05 0.0 3.0890625e-05 0.0 3.0891183035714284e-05 1.5 3.089453125e-05 1.5 3.089508928571428e-05 0.0 3.090848214285714e-05 0.0 3.0909040178571426e-05 1.5 3.091238839285714e-05 1.5 3.091294642857142e-05 0.0 3.0926339285714285e-05 0.0 3.092689732142857e-05 1.5 3.093024553571428e-05 1.5 3.093080357142857e-05 0.0 3.094419642857143e-05 0.0 3.094475446428571e-05 1.5 3.0948102678571424e-05 1.5 3.0948660714285715e-05 0.0 3.096205357142857e-05 0.0 3.096261160714285e-05 1.5 3.096595982142857e-05 1.5 3.096651785714286e-05 0.0 3.097991071428571e-05 0.0 3.0980468749999995e-05 1.5 3.098381696428571e-05 1.5 3.0984375e-05 0.0 3.0997767857142854e-05 0.0 3.099832589285714e-05 1.5 3.100167410714286e-05 1.5 3.100223214285714e-05 0.0 3.1015625e-05 0.0 3.101618303571429e-05 1.5 3.101953125e-05 1.5 3.1020089285714284e-05 0.0 3.103348214285714e-05 0.0 3.103404017857143e-05 1.5 3.103738839285714e-05 1.5 3.1037946428571426e-05 0.0 3.105133928571428e-05 0.0 3.105189732142857e-05 1.5 3.1055245535714285e-05 1.5 3.105580357142857e-05 0.0 3.1069196428571424e-05 0.0 3.1069754464285714e-05 1.5 3.107310267857143e-05 1.5 3.107366071428571e-05 0.0 3.1087053571428566e-05 0.0 3.1087611607142856e-05 1.5 3.109095982142857e-05 1.5 3.109151785714285e-05 0.0 3.1104910714285715e-05 0.0 3.110546875e-05 1.5 3.110881696428571e-05 1.5 3.1109374999999996e-05 0.0 3.112276785714286e-05 0.0 3.112332589285714e-05 1.5 3.1126674107142854e-05 1.5 3.112723214285714e-05 0.0 3.1140625e-05 0.0 3.114118303571428e-05 1.5 3.114453125e-05 1.5 3.114508928571428e-05 0.0 3.115848214285714e-05 0.0 3.1159040178571425e-05 1.5 3.116238839285714e-05 1.5 3.116294642857143e-05 0.0 3.117578125e-05 0.0 3.1176339285714284e-05 1.5 3.118080357142857e-05 1.5 3.1181361607142855e-05 0.0 3.119363839285714e-05 0.0 3.119419642857143e-05 1.5 3.1198660714285714e-05 1.5 3.119921875e-05 0.0 3.1211495535714286e-05 0.0 3.121205357142857e-05 1.5 3.1216517857142856e-05 1.5 3.121707589285714e-05 0.0 3.122935267857143e-05 0.0 3.122991071428571e-05 1.5 3.1234375e-05 1.5 3.123493303571428e-05 0.0 3.124720982142857e-05 0.0 3.1247767857142854e-05 1.5 3.125223214285714e-05 1.5 3.1252790178571424e-05 0.0 3.126506696428571e-05 0.0 3.1265624999999996e-05 1.5 3.127008928571428e-05 1.5 3.1270647321428567e-05 0.0 3.1282924107142855e-05 0.0 3.128348214285714e-05 1.5 3.1287946428571426e-05 1.5 3.128850446428571e-05 0.0 3.130078125e-05 0.0 3.130133928571428e-05 1.5 3.130580357142857e-05 1.5 3.130636160714286e-05 0.0 3.131863839285714e-05 0.0 3.131919642857143e-05 1.5 3.132366071428571e-05 1.5 3.132421875e-05 0.0 3.133649553571428e-05 0.0 3.133705357142857e-05 1.5 3.134151785714285e-05 1.5 3.134207589285714e-05 0.0 3.1354352678571424e-05 0.0 3.1354910714285714e-05 1.5 3.1359374999999995e-05 1.5 3.1359933035714285e-05 0.0 3.1372209821428567e-05 0.0 3.137276785714286e-05 1.5 3.1377232142857144e-05 1.5 3.137779017857143e-05 0.0 3.139006696428571e-05 0.0 3.1390625e-05 1.5 3.1395089285714286e-05 1.5 3.139564732142857e-05 0.0 3.140792410714286e-05 0.0 3.140848214285714e-05 1.5 3.141294642857143e-05 1.5 3.141350446428571e-05 0.0 3.142578125e-05 0.0 3.1426339285714284e-05 1.5 3.143080357142857e-05 1.5 3.1431361607142854e-05 0.0 3.144308035714285e-05 0.0 3.144363839285714e-05 1.5 3.1449218749999997e-05 1.5 3.144977678571429e-05 0.0 3.1460937499999995e-05 0.0 3.1461495535714285e-05 1.5 3.146707589285714e-05 1.5 3.146763392857143e-05 0.0 3.1478794642857144e-05 0.0 3.147935267857143e-05 1.5 3.148493303571428e-05 1.5 3.148549107142857e-05 0.0 3.1496651785714286e-05 0.0 3.149720982142857e-05 1.5 3.1502790178571424e-05 1.5 3.1503348214285714e-05 0.0 3.151450892857143e-05 0.0 3.151506696428571e-05 1.5 3.1520647321428566e-05 1.5 3.1521205357142856e-05 0.0 3.153236607142857e-05 0.0 3.1532924107142854e-05 1.5 3.1538504464285715e-05 1.5 3.15390625e-05 0.0 3.155022321428571e-05 0.0 3.1550781249999997e-05 1.5 3.155636160714286e-05 1.5 3.155691964285714e-05 0.0 3.1568080357142855e-05 0.0 3.156863839285714e-05 1.5 3.157421875e-05 1.5 3.157477678571428e-05 0.0 3.15859375e-05 0.0 3.158649553571428e-05 1.5 3.159207589285714e-05 1.5 3.1592633928571425e-05 0.0 3.160379464285714e-05 0.0 3.1604352678571423e-05 1.5 3.1609933035714284e-05 1.5 3.161049107142857e-05 0.0 3.162165178571428e-05 0.0 3.1622209821428566e-05 1.5 3.1627790178571427e-05 1.5 3.162834821428571e-05 0.0 3.1639508928571425e-05 0.0 3.1640066964285715e-05 1.5 3.164564732142857e-05 1.5 3.164620535714285e-05 0.0 3.165736607142857e-05 0.0 3.165792410714286e-05 1.5 3.166350446428571e-05 1.5 3.1664062499999995e-05 0.0 3.1674665178571426e-05 0.0 3.167522321428571e-05 1.5 3.1681919642857144e-05 1.5 3.168247767857143e-05 0.0 3.169252232142857e-05 0.0 3.169308035714285e-05 1.5 3.1699776785714286e-05 1.5 3.170033482142857e-05 0.0 3.171037946428571e-05 0.0 3.17109375e-05 1.5 3.171763392857143e-05 1.5 3.171819196428571e-05 0.0 3.172823660714285e-05 0.0 3.172879464285714e-05 1.5 3.173549107142857e-05 1.5 3.1736049107142854e-05 0.0 3.1746093749999995e-05 0.0 3.1746651785714285e-05 1.5 3.175334821428571e-05 1.5 3.1753906249999996e-05 0.0 3.176395089285714e-05 0.0 3.176450892857143e-05 1.5 3.1771205357142855e-05 1.5 3.177176339285714e-05 0.0 3.178180803571429e-05 0.0 3.178236607142857e-05 1.5 3.17890625e-05 1.5 3.178962053571428e-05 0.0 3.179966517857143e-05 0.0 3.180022321428571e-05 1.5 3.180691964285714e-05 1.5 3.180747767857142e-05 0.0 3.181752232142857e-05 0.0 3.1818080357142855e-05 1.5 3.182477678571428e-05 1.5 3.182533482142857e-05 0.0 3.1835379464285714e-05 0.0 3.18359375e-05 1.5 3.1842633928571425e-05 1.5 3.1843191964285715e-05 0.0 3.1853236607142856e-05 0.0 3.185379464285714e-05 1.5 3.186049107142857e-05 1.5 3.186104910714286e-05 0.0 3.187109375e-05 0.0 3.187165178571428e-05 1.5 3.187834821428571e-05 1.5 3.187890625e-05 0.0 3.188839285714286e-05 0.0 3.188895089285714e-05 1.5 3.189676339285714e-05 1.5 3.1897321428571425e-05 0.0 3.190625e-05 0.0 3.190680803571428e-05 1.5 3.1914620535714284e-05 1.5 3.191517857142857e-05 0.0 3.192410714285714e-05 0.0 3.1924665178571425e-05 1.5 3.1932477678571426e-05 1.5 3.193303571428571e-05 0.0 3.1941964285714284e-05 0.0 3.194252232142857e-05 1.5 3.195033482142857e-05 1.5 3.195089285714285e-05 0.0 3.195982142857143e-05 0.0 3.196037946428571e-05 1.5 3.196819196428571e-05 1.5 3.1968749999999994e-05 0.0 3.197767857142857e-05 0.0 3.197823660714285e-05 1.5 3.198604910714285e-05 1.5 3.1986607142857144e-05 0.0 3.199553571428571e-05 0.0 3.1996093749999995e-05 1.5 3.2003906249999996e-05 1.5 3.2004464285714286e-05 0.0 3.2013392857142854e-05 0.0 3.2013950892857144e-05 1.5 3.202176339285714e-05 1.5 3.202232142857143e-05 0.0 3.2031249999999996e-05 0.0 3.2031808035714286e-05 1.5 3.203962053571428e-05 1.5 3.204017857142857e-05 0.0 3.204910714285714e-05 0.0 3.204966517857143e-05 1.5 3.205747767857143e-05 1.5 3.205803571428571e-05 0.0 3.206696428571428e-05 0.0 3.206752232142857e-05 1.5 3.207533482142857e-05 1.5 3.2075892857142855e-05 0.0 3.208482142857142e-05 0.0 3.208537946428571e-05 1.5 3.2093191964285714e-05 1.5 3.209375e-05 0.0 )"
spice_ignore=true}
C {devices/gnd.sym} 1400 -1540 0 0 {name=l5 lab=GND}
C {devices/gnd.sym} 1320 -1540 0 0 {name=l13 lab=GND}
C {devices/gnd.sym} 1680 -1540 0 0 {name=l20 lab=GND}
C {devices/vsource.sym} 1860 -1630 0 0 {name=Vofs_I value=\{VDD\}
}
C {devices/vcvs.sym} 1860 -1750 0 0 {name=E10 value=1}
C {devices/gnd.sym} 1860 -1540 0 0 {name=l25 lab=GND}
C {devices/gnd.sym} 1780 -1540 0 0 {name=l55 lab=GND}
C {devices/gnd.sym} 1480 -1540 0 0 {name=l56 lab=GND}
C {devices/vsource.sym} 1480 -1610 0 0 {name=vpwm_sine_50 spice_ignore=true hide_texts=true value="dc 0 pwl(0.0 1.5 4.464285714285714e-09 1.5 5.022321428571428e-09 0.0 1.2834821428571427e-08 0.0 1.3392857142857143e-08 1.5 2.232142857142857e-08 1.5 2.2879464285714283e-08 0.0 3.069196428571428e-08 0.0 3.125e-08 1.5 4.0178571428571425e-08 1.5 4.073660714285714e-08 0.0 4.854910714285714e-08 0.0 4.910714285714285e-08 1.5 5.8035714285714284e-08 1.5 5.8593749999999995e-08 0.0 6.640625e-08 0.0 6.696428571428571e-08 1.5 7.589285714285714e-08 1.5 7.645089285714285e-08 0.0 8.426339285714285e-08 0.0 8.482142857142856e-08 1.5 9.374999999999999e-08 1.5 9.430803571428571e-08 0.0 1.021205357142857e-07 0.0 1.0267857142857142e-07 1.5 1.1160714285714285e-07 1.5 1.1216517857142857e-07 0.0 1.1997767857142856e-07 0.0 1.2053571428571428e-07 1.5 1.294642857142857e-07 1.5 1.3002232142857143e-07 0.0 1.378348214285714e-07 0.0 1.3839285714285713e-07 1.5 1.4732142857142856e-07 1.5 1.4787946428571428e-07 0.0 1.5569196428571426e-07 0.0 1.5624999999999999e-07 1.5 1.651785714285714e-07 1.5 1.6573660714285714e-07 0.0 1.7354910714285714e-07 0.0 1.7410714285714284e-07 1.5 1.8303571428571427e-07 1.5 1.8359375e-07 0.0 1.9140625e-07 0.0 1.919642857142857e-07 1.5 2.0089285714285712e-07 1.5 2.0145089285714284e-07 0.0 2.0926339285714285e-07 0.0 2.0982142857142854e-07 1.5 2.1875e-07 1.5 2.193080357142857e-07 0.0 2.271205357142857e-07 0.0 2.2767857142857142e-07 1.5 2.3660714285714285e-07 1.5 2.3716517857142855e-07 0.0 2.4497767857142855e-07 0.0 2.4553571428571425e-07 1.5 2.544642857142857e-07 1.5 2.550223214285714e-07 0.0 2.628348214285714e-07 0.0 2.633928571428571e-07 1.5 2.7232142857142853e-07 1.5 2.728794642857143e-07 0.0 2.8069196428571426e-07 0.0 2.8124999999999995e-07 1.5 2.9017857142857143e-07 1.5 2.9073660714285713e-07 0.0 2.985491071428571e-07 0.0 2.9910714285714286e-07 1.5 3.080357142857143e-07 1.5 3.0859375e-07 0.0 3.1640624999999996e-07 0.0 3.169642857142857e-07 1.5 3.2645089285714284e-07 1.5 3.2700892857142853e-07 0.0 3.337053571428571e-07 0.0 3.342633928571428e-07 1.5 3.443080357142857e-07 1.5 3.448660714285714e-07 0.0 3.5156249999999997e-07 0.0 3.5212053571428567e-07 1.5 3.6216517857142854e-07 1.5 3.6272321428571424e-07 0.0 3.694196428571428e-07 0.0 3.699776785714285e-07 1.5 3.800223214285714e-07 1.5 3.805803571428571e-07 0.0 3.872767857142857e-07 0.0 3.878348214285714e-07 1.5 3.9787946428571425e-07 1.5 3.984375e-07 0.0 4.0513392857142853e-07 0.0 4.056919642857143e-07 1.5 4.157366071428571e-07 1.5 4.1629464285714285e-07 0.0 4.229910714285714e-07 0.0 4.2354910714285713e-07 1.5 4.3359374999999995e-07 1.5 4.341517857142857e-07 0.0 4.4084821428571423e-07 0.0 4.4140625e-07 1.5 4.514508928571428e-07 1.5 4.5200892857142855e-07 0.0 4.587053571428571e-07 0.0 4.5926339285714284e-07 1.5 4.6930803571428566e-07 1.5 4.698660714285714e-07 0.0 4.765625e-07 0.0 4.771205357142856e-07 1.5 4.871651785714285e-07 1.5 4.877232142857142e-07 0.0 4.944196428571428e-07 0.0 4.949776785714285e-07 1.5 5.050223214285714e-07 1.5 5.055803571428571e-07 0.0 5.122767857142856e-07 0.0 5.128348214285713e-07 1.5 5.228794642857142e-07 1.5 5.234374999999999e-07 0.0 5.301339285714285e-07 0.0 5.306919642857143e-07 1.5 5.407366071428571e-07 1.5 5.412946428571429e-07 0.0 5.479910714285713e-07 0.0 5.485491071428572e-07 1.5 5.585937499999999e-07 1.5 5.591517857142857e-07 0.0 5.658482142857142e-07 0.0 5.6640625e-07 1.5 5.764508928571428e-07 1.5 5.770089285714286e-07 0.0 5.83705357142857e-07 0.0 5.842633928571429e-07 1.5 5.943080357142856e-07 1.5 5.948660714285714e-07 0.0 6.015624999999999e-07 0.0 6.021205357142857e-07 1.5 6.121651785714285e-07 1.5 6.127232142857143e-07 0.0 6.194196428571429e-07 0.0 6.199776785714286e-07 1.5 6.300223214285714e-07 1.5 6.305803571428571e-07 0.0 6.372767857142857e-07 0.0 6.378348214285714e-07 1.5 6.478794642857143e-07 1.5 6.484375e-07 0.0 6.551339285714286e-07 0.0 6.556919642857143e-07 1.5 6.657366071428571e-07 1.5 6.662946428571428e-07 0.0 6.724330357142856e-07 0.0 6.729910714285714e-07 1.5 6.841517857142857e-07 1.5 6.847098214285714e-07 0.0 6.902901785714285e-07 0.0 6.908482142857143e-07 1.5 7.020089285714285e-07 1.5 7.025669642857142e-07 0.0 7.081473214285714e-07 0.0 7.087053571428571e-07 1.5 7.198660714285714e-07 1.5 7.204241071428571e-07 0.0 7.260044642857143e-07 0.0 7.265625e-07 1.5 7.377232142857142e-07 1.5 7.382812499999999e-07 0.0 7.438616071428571e-07 0.0 7.444196428571428e-07 1.5 7.555803571428571e-07 1.5 7.561383928571428e-07 0.0 7.6171875e-07 0.0 7.622767857142857e-07 1.5 7.734375e-07 1.5 7.739955357142857e-07 0.0 7.795758928571428e-07 0.0 7.801339285714285e-07 1.5 7.912946428571428e-07 1.5 7.918526785714285e-07 0.0 7.974330357142857e-07 0.0 7.979910714285714e-07 1.5 8.091517857142857e-07 1.5 8.097098214285714e-07 0.0 8.152901785714285e-07 0.0 8.158482142857142e-07 1.5 8.270089285714285e-07 1.5 8.275669642857142e-07 0.0 8.331473214285714e-07 0.0 8.337053571428571e-07 1.5 8.448660714285714e-07 1.5 8.454241071428571e-07 0.0 8.510044642857142e-07 0.0 8.515624999999999e-07 1.5 8.627232142857142e-07 1.5 8.632812499999999e-07 0.0 8.688616071428571e-07 0.0 8.694196428571428e-07 1.5 8.805803571428571e-07 1.5 8.811383928571428e-07 0.0 8.8671875e-07 0.0 8.872767857142857e-07 1.5 8.984374999999999e-07 1.5 8.989955357142856e-07 0.0 9.045758928571428e-07 0.0 9.051339285714285e-07 1.5 9.162946428571428e-07 1.5 9.168526785714285e-07 0.0 9.224330357142857e-07 0.0 9.229910714285714e-07 1.5 9.341517857142856e-07 1.5 9.347098214285713e-07 0.0 9.402901785714285e-07 0.0 9.408482142857142e-07 1.5 9.520089285714285e-07 1.5 9.525669642857142e-07 0.0 9.581473214285714e-07 0.0 9.58705357142857e-07 1.5 9.698660714285714e-07 1.5 9.704241071428571e-07 0.0 9.760044642857141e-07 0.0 9.765625e-07 1.5 9.877232142857142e-07 1.5 9.882812499999999e-07 0.0 9.93861607142857e-07 0.0 9.944196428571428e-07 1.5 1.0055803571428571e-06 1.5 1.0061383928571428e-06 0.0 1.01171875e-06 0.0 1.0122767857142857e-06 1.5 1.0234374999999999e-06 1.5 1.0239955357142856e-06 0.0 1.0295758928571428e-06 0.0 1.0301339285714285e-06 1.5 1.0412946428571428e-06 1.5 1.0418526785714285e-06 0.0 1.0474330357142857e-06 0.0 1.0479910714285714e-06 1.5 1.0591517857142856e-06 1.5 1.0597098214285713e-06 0.0 1.0652901785714285e-06 0.0 1.0658482142857142e-06 1.5 1.0770089285714286e-06 1.5 1.0775669642857143e-06 0.0 1.0831473214285714e-06 0.0 1.0837053571428571e-06 1.5 1.095424107142857e-06 1.5 1.0959821428571427e-06 0.0 1.1004464285714285e-06 0.0 1.1010044642857142e-06 1.5 1.11328125e-06 1.5 1.1138392857142857e-06 0.0 1.1183035714285714e-06 0.0 1.1188616071428571e-06 1.5 1.1311383928571427e-06 1.5 1.1316964285714284e-06 0.0 1.1361607142857142e-06 0.0 1.1367187499999999e-06 1.5 1.1489955357142857e-06 1.5 1.1495535714285714e-06 0.0 1.1540178571428572e-06 0.0 1.1545758928571428e-06 1.5 1.1668526785714284e-06 1.5 1.167410714285714e-06 0.0 1.171875e-06 0.0 1.1724330357142856e-06 1.5 1.1847098214285714e-06 1.5 1.185267857142857e-06 0.0 1.1897321428571429e-06 0.0 1.1902901785714286e-06 1.5 1.2025669642857141e-06 1.5 1.2031249999999998e-06 0.0 1.2075892857142856e-06 0.0 1.2081473214285713e-06 1.5 1.220424107142857e-06 1.5 1.2209821428571428e-06 0.0 1.2254464285714286e-06 0.0 1.2260044642857143e-06 1.5 1.2382812499999998e-06 1.5 1.2388392857142857e-06 0.0 1.2433035714285713e-06 0.0 1.243861607142857e-06 1.5 1.2561383928571428e-06 1.5 1.2566964285714285e-06 0.0 1.2611607142857143e-06 0.0 1.26171875e-06 1.5 1.2739955357142855e-06 1.5 1.2745535714285714e-06 0.0 1.279017857142857e-06 0.0 1.2795758928571427e-06 1.5 1.2918526785714285e-06 1.5 1.2924107142857142e-06 0.0 1.296875e-06 0.0 1.2974330357142857e-06 1.5 1.3097098214285714e-06 1.5 1.3102678571428571e-06 0.0 1.3147321428571427e-06 0.0 1.3152901785714284e-06 1.5 1.3275669642857142e-06 1.5 1.3281249999999999e-06 0.0 1.3325892857142857e-06 0.0 1.3331473214285714e-06 1.5 1.3454241071428571e-06 1.5 1.3459821428571428e-06 0.0 1.3504464285714284e-06 0.0 1.3510044642857141e-06 1.5 1.3632812499999999e-06 1.5 1.3638392857142856e-06 0.0 1.3683035714285714e-06 0.0 1.368861607142857e-06 1.5 1.3811383928571428e-06 1.5 1.3816964285714285e-06 0.0 1.3861607142857141e-06 0.0 1.3867187499999998e-06 1.5 1.3989955357142856e-06 1.5 1.3995535714285713e-06 0.0 1.404017857142857e-06 0.0 1.4045758928571428e-06 1.5 1.4168526785714286e-06 1.5 1.4174107142857143e-06 0.0 1.4218749999999998e-06 0.0 1.4224330357142855e-06 1.5 1.4347098214285713e-06 1.5 1.435267857142857e-06 0.0 1.4397321428571428e-06 0.0 1.4402901785714285e-06 1.5 1.4525669642857143e-06 1.5 1.453125e-06 0.0 1.4575892857142855e-06 0.0 1.4581473214285712e-06 1.5 1.470424107142857e-06 1.5 1.4709821428571427e-06 0.0 1.4754464285714285e-06 0.0 1.4760044642857142e-06 1.5 1.48828125e-06 1.5 1.4888392857142857e-06 0.0 1.4933035714285712e-06 0.0 1.493861607142857e-06 1.5 1.5061383928571427e-06 1.5 1.5066964285714284e-06 0.0 1.5111607142857142e-06 0.0 1.51171875e-06 1.5 1.5239955357142857e-06 1.5 1.5245535714285714e-06 0.0 1.529017857142857e-06 0.0 1.5295758928571426e-06 1.5 1.5418526785714284e-06 1.5 1.5424107142857141e-06 0.0 1.546875e-06 0.0 1.5474330357142856e-06 1.5 1.5597098214285714e-06 1.5 1.560267857142857e-06 0.0 1.5647321428571427e-06 0.0 1.5652901785714286e-06 1.5 1.5775669642857141e-06 1.5 1.5781249999999998e-06 0.0 1.5825892857142856e-06 0.0 1.5831473214285713e-06 1.5 1.595424107142857e-06 1.5 1.5959821428571428e-06 0.0 1.6004464285714284e-06 0.0 1.6010044642857143e-06 1.5 1.6132812499999998e-06 1.5 1.6138392857142855e-06 0.0 1.6183035714285713e-06 0.0 1.618861607142857e-06 1.5 1.6311383928571428e-06 1.5 1.6316964285714285e-06 0.0 1.636160714285714e-06 0.0 1.63671875e-06 1.5 1.6489955357142855e-06 1.5 1.6495535714285712e-06 0.0 1.654017857142857e-06 0.0 1.6545758928571427e-06 1.5 1.6668526785714285e-06 1.5 1.6674107142857142e-06 0.0 1.671875e-06 0.0 1.6724330357142857e-06 1.5 1.6847098214285712e-06 1.5 1.685267857142857e-06 0.0 1.6897321428571427e-06 0.0 1.6902901785714284e-06 1.5 1.7025669642857142e-06 1.5 1.7031249999999999e-06 0.0 1.7075892857142857e-06 0.0 1.7081473214285714e-06 1.5 1.720424107142857e-06 1.5 1.7209821428571426e-06 0.0 1.7254464285714284e-06 0.0 1.7260044642857141e-06 1.5 1.73828125e-06 1.5 1.7388392857142856e-06 0.0 1.7433035714285714e-06 0.0 1.743861607142857e-06 1.5 1.7561383928571426e-06 1.5 1.7566964285714283e-06 0.0 1.7611607142857141e-06 0.0 1.7617187499999998e-06 1.5 1.7739955357142856e-06 1.5 1.7745535714285713e-06 0.0 1.779017857142857e-06 0.0 1.7795758928571428e-06 1.5 1.7918526785714284e-06 1.5 1.7924107142857143e-06 0.0 1.7968749999999998e-06 0.0 1.7974330357142855e-06 1.5 1.8097098214285713e-06 1.5 1.810267857142857e-06 0.0 1.8147321428571428e-06 0.0 1.8152901785714285e-06 1.5 1.827566964285714e-06 1.5 1.828125e-06 0.0 1.8325892857142855e-06 0.0 1.8331473214285712e-06 1.5 1.845424107142857e-06 1.5 1.8459821428571427e-06 0.0 1.8504464285714285e-06 0.0 1.8510044642857142e-06 1.5 1.8632812499999998e-06 1.5 1.8638392857142857e-06 0.0 1.8683035714285713e-06 0.0 1.868861607142857e-06 1.5 1.8811383928571427e-06 1.5 1.8816964285714284e-06 0.0 1.8861607142857142e-06 0.0 1.88671875e-06 1.5 1.8989955357142857e-06 1.5 1.8995535714285714e-06 0.0 1.904017857142857e-06 0.0 1.9045758928571427e-06 1.5 1.9168526785714286e-06 1.5 1.917410714285714e-06 0.0 1.9218749999999997e-06 0.0 1.9224330357142856e-06 1.5 1.9347098214285714e-06 1.5 1.935267857142857e-06 0.0 1.939732142857143e-06 0.0 1.9402901785714284e-06 1.5 1.952566964285714e-06 1.5 1.953125e-06 0.0 1.9575892857142856e-06 0.0 1.958147321428571e-06 1.5 1.970424107142857e-06 1.5 1.9709821428571428e-06 0.0 1.9754464285714284e-06 0.0 1.9760044642857143e-06 1.5 1.98828125e-06 1.5 1.9888392857142855e-06 0.0 1.993303571428571e-06 0.0 1.993861607142857e-06 1.5 2.006138392857143e-06 1.5 2.0066964285714283e-06 0.0 2.0111607142857143e-06 0.0 2.0117187499999998e-06 1.5 2.0239955357142855e-06 1.5 2.0245535714285715e-06 0.0 2.029017857142857e-06 0.0 2.0295758928571425e-06 1.5 2.0418526785714283e-06 1.5 2.042410714285714e-06 0.0 2.0468749999999998e-06 0.0 2.0474330357142857e-06 1.5 2.0597098214285715e-06 1.5 2.060267857142857e-06 0.0 2.0647321428571425e-06 0.0 2.0652901785714284e-06 1.5 2.077566964285714e-06 1.5 2.0781249999999997e-06 0.0 2.0825892857142857e-06 0.0 2.083147321428571e-06 1.5 2.095424107142857e-06 1.5 2.095982142857143e-06 0.0 2.1004464285714284e-06 0.0 2.101004464285714e-06 1.5 2.1132812499999997e-06 1.5 2.1138392857142856e-06 0.0 2.118303571428571e-06 0.0 2.118861607142857e-06 1.5 2.131138392857143e-06 1.5 2.1316964285714284e-06 0.0 2.136160714285714e-06 0.0 2.13671875e-06 1.5 2.1489955357142856e-06 1.5 2.149553571428571e-06 0.0 2.154017857142857e-06 0.0 2.1545758928571426e-06 1.5 2.1668526785714284e-06 1.5 2.1674107142857143e-06 0.0 2.171875e-06 0.0 2.1724330357142858e-06 1.5 2.184709821428571e-06 1.5 2.185267857142857e-06 0.0 2.1897321428571426e-06 0.0 2.1902901785714285e-06 1.5 2.2025669642857143e-06 1.5 2.2031249999999998e-06 0.0 2.2075892857142853e-06 0.0 2.2081473214285713e-06 1.5 2.220424107142857e-06 1.5 2.2209821428571425e-06 0.0 2.2254464285714285e-06 0.0 2.226004464285714e-06 1.5 2.2382812499999998e-06 1.5 2.2388392857142857e-06 0.0 2.2433035714285713e-06 0.0 2.243861607142857e-06 1.5 2.2561383928571425e-06 1.5 2.2566964285714284e-06 0.0 2.261160714285714e-06 0.0 2.26171875e-06 1.5 2.2739955357142857e-06 1.5 2.274553571428571e-06 0.0 2.279017857142857e-06 0.0 2.2795758928571427e-06 1.5 2.2918526785714284e-06 1.5 2.292410714285714e-06 0.0 2.296875e-06 0.0 2.2974330357142854e-06 1.5 2.309709821428571e-06 1.5 2.310267857142857e-06 0.0 2.3147321428571427e-06 0.0 2.3152901785714286e-06 1.5 2.327566964285714e-06 1.5 2.328125e-06 0.0 2.3325892857142854e-06 0.0 2.3331473214285713e-06 1.5 2.345424107142857e-06 1.5 2.3459821428571426e-06 0.0 2.3504464285714286e-06 0.0 2.351004464285714e-06 1.5 2.36328125e-06 1.5 2.3638392857142858e-06 0.0 2.3683035714285713e-06 0.0 2.368861607142857e-06 1.5 2.3811383928571426e-06 1.5 2.3816964285714285e-06 0.0 2.386160714285714e-06 0.0 2.38671875e-06 1.5 2.3989955357142853e-06 1.5 2.3995535714285712e-06 0.0 2.404017857142857e-06 0.0 2.4045758928571427e-06 1.5 2.4168526785714285e-06 1.5 2.417410714285714e-06 0.0 2.421875e-06 0.0 2.4224330357142855e-06 1.5 2.4347098214285713e-06 1.5 2.435267857142857e-06 0.0 2.4397321428571427e-06 0.0 2.4402901785714282e-06 1.5 2.452566964285714e-06 1.5 2.453125e-06 0.0 2.4575892857142855e-06 0.0 2.4581473214285714e-06 1.5 2.470424107142857e-06 1.5 2.4709821428571427e-06 0.0 2.4754464285714282e-06 0.0 2.476004464285714e-06 1.5 2.48828125e-06 1.5 2.4888392857142854e-06 0.0 2.4933035714285714e-06 0.0 2.493861607142857e-06 1.5 2.5061383928571427e-06 1.5 2.5066964285714286e-06 0.0 2.511160714285714e-06 0.0 2.5117187499999996e-06 1.5 2.5239955357142854e-06 1.5 2.5245535714285713e-06 0.0 2.529017857142857e-06 0.0 2.529575892857143e-06 1.5 2.5418526785714286e-06 1.5 2.542410714285714e-06 0.0 2.5468749999999996e-06 0.0 2.5474330357142856e-06 1.5 2.5597098214285713e-06 1.5 2.560267857142857e-06 0.0 2.564732142857143e-06 0.0 2.5652901785714283e-06 1.5 2.577566964285714e-06 1.5 2.578125e-06 0.0 2.5825892857142856e-06 0.0 2.583147321428571e-06 1.5 2.595424107142857e-06 1.5 2.5959821428571427e-06 0.0 2.6004464285714283e-06 0.0 2.6010044642857142e-06 1.5 2.61328125e-06 1.5 2.6138392857142855e-06 0.0 2.618303571428571e-06 0.0 2.618861607142857e-06 1.5 2.6311383928571427e-06 1.5 2.6316964285714282e-06 0.0 2.6361607142857142e-06 0.0 2.6367187499999997e-06 1.5 2.6489955357142855e-06 1.5 2.6495535714285714e-06 0.0 2.654017857142857e-06 0.0 2.6545758928571425e-06 1.5 2.6668526785714282e-06 1.5 2.667410714285714e-06 0.0 2.6718749999999997e-06 0.0 2.6724330357142856e-06 1.5 2.6847098214285714e-06 1.5 2.685267857142857e-06 0.0 2.6897321428571425e-06 0.0 2.6902901785714284e-06 1.5 2.702566964285714e-06 1.5 2.7031249999999996e-06 0.0 2.7075892857142856e-06 0.0 2.708147321428571e-06 1.5 2.720424107142857e-06 1.5 2.720982142857143e-06 0.0 2.7254464285714284e-06 0.0 2.7260044642857143e-06 1.5 2.7382812499999996e-06 1.5 2.7388392857142856e-06 0.0 2.743303571428571e-06 0.0 2.743861607142857e-06 1.5 2.756138392857143e-06 1.5 2.7566964285714283e-06 0.0 2.761160714285714e-06 0.0 2.76171875e-06 1.5 2.7739955357142856e-06 1.5 2.774553571428571e-06 0.0 2.779017857142857e-06 0.0 2.7795758928571425e-06 1.5 2.7918526785714283e-06 1.5 2.7924107142857142e-06 0.0 2.796875e-06 0.0 2.7974330357142857e-06 1.5 2.809709821428571e-06 1.5 2.810267857142857e-06 0.0 2.8147321428571425e-06 0.0 2.8152901785714285e-06 1.5 2.8275669642857142e-06 1.5 2.8281249999999997e-06 0.0 2.8325892857142857e-06 0.0 2.833147321428571e-06 1.5 2.845424107142857e-06 1.5 2.8459821428571425e-06 0.0 2.8504464285714285e-06 0.0 2.851004464285714e-06 1.5 2.8632812499999997e-06 1.5 2.8638392857142856e-06 0.0 2.868303571428571e-06 0.0 2.868861607142857e-06 1.5 2.8811383928571425e-06 1.5 2.8816964285714284e-06 0.0 2.886160714285714e-06 0.0 2.88671875e-06 1.5 2.8989955357142856e-06 1.5 2.899553571428571e-06 0.0 2.904017857142857e-06 0.0 2.9045758928571426e-06 1.5 2.9168526785714284e-06 1.5 2.917410714285714e-06 0.0 2.921875e-06 0.0 2.9224330357142854e-06 1.5 2.9341517857142856e-06 1.5 2.934709821428571e-06 0.0 2.9402901785714285e-06 0.0 2.940848214285714e-06 1.5 2.9520089285714284e-06 1.5 2.952566964285714e-06 0.0 2.9581473214285713e-06 0.0 2.9587053571428568e-06 1.5 2.969866071428571e-06 1.5 2.970424107142857e-06 0.0 2.976004464285714e-06 0.0 2.9765625e-06 1.5 2.987723214285714e-06 1.5 2.98828125e-06 0.0 2.9938616071428568e-06 0.0 2.9944196428571427e-06 1.5 3.005580357142857e-06 1.5 3.0061383928571425e-06 0.0 3.01171875e-06 0.0 3.0122767857142854e-06 1.5 3.0234375e-06 1.5 3.0239955357142857e-06 0.0 3.0295758928571427e-06 0.0 3.030133928571428e-06 1.5 3.0412946428571425e-06 1.5 3.0418526785714285e-06 0.0 3.0474330357142854e-06 0.0 3.0479910714285713e-06 1.5 3.0591517857142853e-06 1.5 3.059709821428571e-06 0.0 3.065290178571428e-06 0.0 3.065848214285714e-06 1.5 3.0770089285714285e-06 1.5 3.077566964285714e-06 0.0 3.0831473214285713e-06 0.0 3.083705357142857e-06 1.5 3.094866071428571e-06 1.5 3.095424107142857e-06 0.0 3.101004464285714e-06 0.0 3.1015624999999996e-06 1.5 3.112723214285714e-06 1.5 3.11328125e-06 0.0 3.118861607142857e-06 0.0 3.1194196428571428e-06 1.5 3.130580357142857e-06 1.5 3.1311383928571426e-06 0.0 3.1367187499999996e-06 0.0 3.1372767857142855e-06 1.5 3.1484375e-06 1.5 3.1489955357142854e-06 0.0 3.1545758928571428e-06 0.0 3.1551339285714282e-06 1.5 3.1662946428571426e-06 1.5 3.1668526785714285e-06 0.0 3.1724330357142855e-06 0.0 3.172991071428571e-06 1.5 3.1841517857142854e-06 1.5 3.1847098214285713e-06 0.0 3.1902901785714283e-06 0.0 3.190848214285714e-06 1.5 3.2020089285714285e-06 1.5 3.202566964285714e-06 0.0 3.208147321428571e-06 0.0 3.208705357142857e-06 1.5 3.2198660714285713e-06 1.5 3.2204241071428568e-06 0.0 3.226004464285714e-06 0.0 3.2265624999999997e-06 1.5 3.237723214285714e-06 1.5 3.23828125e-06 0.0 3.243861607142857e-06 0.0 3.244419642857143e-06 1.5 3.2555803571428568e-06 1.5 3.2561383928571427e-06 0.0 3.2617187499999997e-06 0.0 3.2622767857142856e-06 1.5 3.2734375e-06 1.5 3.2739955357142854e-06 0.0 3.279575892857143e-06 0.0 3.2801339285714283e-06 1.5 3.2912946428571427e-06 1.5 3.291852678571428e-06 0.0 3.2974330357142856e-06 0.0 3.297991071428571e-06 1.5 3.3091517857142854e-06 1.5 3.3097098214285713e-06 0.0 3.3152901785714283e-06 0.0 3.3158482142857142e-06 1.5 3.327008928571428e-06 1.5 3.327566964285714e-06 0.0 3.333147321428571e-06 0.0 3.333705357142857e-06 1.5 3.3443080357142854e-06 1.5 3.3448660714285714e-06 0.0 3.3515624999999997e-06 0.0 3.3521205357142856e-06 1.5 3.362165178571428e-06 1.5 3.362723214285714e-06 0.0 3.3694196428571425e-06 0.0 3.3699776785714284e-06 1.5 3.3800223214285714e-06 1.5 3.380580357142857e-06 0.0 3.3872767857142856e-06 0.0 3.387834821428571e-06 1.5 3.397879464285714e-06 1.5 3.3984374999999996e-06 0.0 3.4051339285714284e-06 0.0 3.405691964285714e-06 1.5 3.415736607142857e-06 1.5 3.4162946428571428e-06 0.0 3.422991071428571e-06 0.0 3.423549107142857e-06 1.5 3.4335937499999996e-06 1.5 3.4341517857142855e-06 0.0 3.440848214285714e-06 0.0 3.44140625e-06 1.5 3.4514508928571428e-06 1.5 3.4520089285714283e-06 0.0 3.458705357142857e-06 0.0 3.4592633928571425e-06 1.5 3.4693080357142855e-06 1.5 3.469866071428571e-06 0.0 3.4765625e-06 0.0 3.4771205357142853e-06 1.5 3.4871651785714283e-06 1.5 3.487723214285714e-06 0.0 3.4944196428571425e-06 0.0 3.4949776785714285e-06 1.5 3.505022321428571e-06 1.5 3.505580357142857e-06 0.0 3.5122767857142853e-06 0.0 3.512834821428571e-06 1.5 3.522879464285714e-06 1.5 3.5234374999999997e-06 0.0 3.5301339285714285e-06 0.0 3.530691964285714e-06 1.5 3.540736607142857e-06 1.5 3.5412946428571424e-06 0.0 3.547991071428571e-06 0.0 3.5485491071428567e-06 1.5 3.5585937499999997e-06 1.5 3.5591517857142856e-06 0.0 3.565848214285714e-06 0.0 3.56640625e-06 1.5 3.5764508928571424e-06 1.5 3.5770089285714283e-06 0.0 3.5837053571428567e-06 0.0 3.5842633928571426e-06 1.5 3.5943080357142856e-06 1.5 3.594866071428571e-06 0.0 3.6015625e-06 0.0 3.6021205357142854e-06 1.5 3.6121651785714283e-06 1.5 3.612723214285714e-06 0.0 3.6194196428571426e-06 0.0 3.619977678571428e-06 1.5 3.630022321428571e-06 1.5 3.630580357142857e-06 0.0 3.6372767857142854e-06 0.0 3.6378348214285713e-06 1.5 3.647879464285714e-06 1.5 3.6484374999999997e-06 0.0 3.655133928571428e-06 0.0 3.655691964285714e-06 1.5 3.665736607142857e-06 1.5 3.6662946428571425e-06 0.0 3.6729910714285713e-06 0.0 3.6735491071428568e-06 1.5 3.6835937499999998e-06 1.5 3.6841517857142857e-06 0.0 3.69140625e-06 0.0 3.6919642857142854e-06 1.5 3.700892857142857e-06 1.5 3.7014508928571425e-06 0.0 3.7092633928571427e-06 0.0 3.709821428571428e-06 1.5 3.7187499999999998e-06 1.5 3.7193080357142852e-06 0.0 3.7271205357142854e-06 0.0 3.7276785714285713e-06 1.5 3.7366071428571425e-06 1.5 3.7371651785714284e-06 0.0 3.744977678571428e-06 0.0 3.745535714285714e-06 1.5 3.7544642857142853e-06 1.5 3.755022321428571e-06 0.0 3.7628348214285714e-06 0.0 3.763392857142857e-06 1.5 3.7723214285714284e-06 1.5 3.772879464285714e-06 0.0 3.780691964285714e-06 0.0 3.7812499999999996e-06 1.5 3.790178571428571e-06 1.5 3.790736607142857e-06 0.0 3.798549107142857e-06 0.0 3.7991071428571428e-06 1.5 3.808035714285714e-06 1.5 3.80859375e-06 0.0 3.81640625e-06 0.0 3.816964285714285e-06 1.5 3.825892857142857e-06 1.5 3.826450892857143e-06 0.0 3.834263392857142e-06 0.0 3.834821428571428e-06 1.5 3.843749999999999e-06 1.5 3.844308035714285e-06 0.0 3.8521205357142855e-06 0.0 3.852678571428571e-06 1.5 3.861607142857143e-06 1.5 3.8621651785714285e-06 0.0 3.869977678571429e-06 0.0 3.870535714285714e-06 1.5 3.879464285714286e-06 1.5 3.880022321428571e-06 0.0 3.887834821428571e-06 0.0 3.888392857142857e-06 1.5 3.897321428571428e-06 1.5 3.897879464285714e-06 0.0 3.905691964285714e-06 0.0 3.90625e-06 1.5 3.915178571428571e-06 1.5 3.915736607142857e-06 0.0 3.9235491071428565e-06 0.0 3.924107142857142e-06 1.5 3.933035714285714e-06 1.5 3.9335937499999995e-06 0.0 3.94140625e-06 0.0 3.9419642857142856e-06 1.5 3.950892857142857e-06 1.5 3.951450892857143e-06 0.0 3.959263392857143e-06 0.0 3.959821428571428e-06 1.5 3.96875e-06 1.5 3.969308035714286e-06 0.0 3.977120535714285e-06 0.0 3.977678571428571e-06 1.5 3.986607142857142e-06 1.5 3.987165178571428e-06 0.0 3.994977678571428e-06 0.0 3.995535714285714e-06 1.5 4.004464285714285e-06 1.5 4.005022321428571e-06 0.0 4.0133928571428566e-06 0.0 4.0139508928571425e-06 1.5 4.021763392857143e-06 1.5 4.0223214285714286e-06 0.0 4.03125e-06 0.0 4.031808035714286e-06 1.5 4.039620535714286e-06 1.5 4.040178571428571e-06 0.0 4.049107142857143e-06 0.0 4.049665178571428e-06 1.5 4.057477678571428e-06 1.5 4.058035714285714e-06 0.0 4.066964285714285e-06 0.0 4.067522321428571e-06 1.5 4.075334821428571e-06 1.5 4.075892857142857e-06 0.0 4.084821428571428e-06 0.0 4.085379464285714e-06 1.5 4.093191964285714e-06 1.5 4.0937499999999996e-06 0.0 4.102678571428571e-06 0.0 4.103236607142857e-06 1.5 4.111049107142857e-06 1.5 4.111607142857143e-06 0.0 4.120535714285714e-06 0.0 4.12109375e-06 1.5 4.12890625e-06 1.5 4.129464285714285e-06 0.0 4.138392857142857e-06 0.0 4.138950892857143e-06 1.5 4.146763392857142e-06 1.5 4.147321428571428e-06 0.0 4.156249999999999e-06 0.0 4.156808035714285e-06 1.5 4.1646205357142855e-06 1.5 4.165178571428571e-06 0.0 4.1741071428571426e-06 0.0 4.1746651785714285e-06 1.5 4.182477678571429e-06 1.5 4.183035714285714e-06 0.0 4.191964285714286e-06 0.0 4.192522321428571e-06 1.5 4.200334821428571e-06 1.5 4.200892857142857e-06 0.0 4.209821428571428e-06 0.0 4.210379464285714e-06 1.5 4.218191964285714e-06 1.5 4.21875e-06 0.0 4.227678571428571e-06 0.0 4.228236607142857e-06 1.5 4.2360491071428565e-06 1.5 4.236607142857142e-06 0.0 4.245535714285714e-06 0.0 4.2460937499999994e-06 1.5 4.25390625e-06 1.5 4.2544642857142855e-06 0.0 4.263392857142857e-06 0.0 4.263950892857143e-06 1.5 4.271763392857143e-06 1.5 4.272321428571428e-06 0.0 4.28125e-06 0.0 4.281808035714286e-06 1.5 4.289620535714285e-06 1.5 4.290178571428571e-06 0.0 4.299107142857142e-06 0.0 4.299665178571428e-06 1.5 4.307477678571428e-06 1.5 4.308035714285714e-06 0.0 4.316964285714285e-06 0.0 4.317522321428571e-06 1.5 4.3253348214285715e-06 1.5 4.3258928571428565e-06 0.0 4.3348214285714285e-06 0.0 4.335379464285714e-06 1.5 4.342633928571428e-06 1.5 4.343191964285714e-06 0.0 4.353236607142857e-06 0.0 4.353794642857143e-06 1.5 4.360491071428571e-06 1.5 4.361049107142857e-06 0.0 4.37109375e-06 0.0 4.371651785714285e-06 1.5 4.378348214285714e-06 1.5 4.378906249999999e-06 0.0 4.388950892857142e-06 0.0 4.389508928571428e-06 1.5 4.3962053571428565e-06 1.5 4.3967633928571425e-06 0.0 4.4068080357142854e-06 0.0 4.407366071428571e-06 1.5 4.4140625e-06 1.5 4.414620535714286e-06 0.0 4.424665178571429e-06 0.0 4.425223214285714e-06 1.5 4.431919642857143e-06 1.5 4.432477678571428e-06 0.0 4.442522321428571e-06 0.0 4.443080357142857e-06 1.5 4.449776785714285e-06 1.5 4.450334821428571e-06 0.0 4.460379464285714e-06 0.0 4.4609375e-06 1.5 4.467633928571428e-06 1.5 4.468191964285714e-06 0.0 4.4782366071428564e-06 0.0 4.478794642857142e-06 1.5 4.485491071428571e-06 1.5 4.486049107142857e-06 0.0 4.49609375e-06 0.0 4.4966517857142855e-06 1.5 4.503348214285714e-06 1.5 4.50390625e-06 0.0 4.513950892857143e-06 0.0 4.514508928571428e-06 1.5 4.521205357142857e-06 1.5 4.521763392857143e-06 0.0 4.531808035714285e-06 0.0 4.532366071428571e-06 1.5 4.539062499999999e-06 1.5 4.539620535714285e-06 0.0 4.549665178571428e-06 0.0 4.550223214285714e-06 1.5 4.5569196428571425e-06 1.5 4.5574776785714284e-06 0.0 4.5675223214285714e-06 0.0 4.5680803571428565e-06 1.5 4.574776785714286e-06 1.5 4.575334821428571e-06 0.0 4.585379464285714e-06 0.0 4.5859375e-06 1.5 4.592633928571428e-06 1.5 4.593191964285714e-06 0.0 4.603236607142857e-06 0.0 4.603794642857143e-06 1.5 4.610491071428571e-06 1.5 4.611049107142857e-06 0.0 4.621093749999999e-06 0.0 4.621651785714285e-06 1.5 4.628348214285714e-06 1.5 4.6289062499999994e-06 0.0 4.638950892857142e-06 0.0 4.639508928571428e-06 1.5 4.646205357142857e-06 1.5 4.646763392857143e-06 0.0 4.656808035714286e-06 0.0 4.6573660714285715e-06 1.5 4.6640625e-06 1.5 4.664620535714286e-06 0.0 4.674665178571428e-06 0.0 4.675223214285714e-06 1.5 4.681361607142857e-06 1.5 4.681919642857142e-06 0.0 4.693080357142857e-06 0.0 4.693638392857143e-06 1.5 4.6992187499999995e-06 1.5 4.699776785714285e-06 0.0 4.710937499999999e-06 0.0 4.711495535714285e-06 1.5 4.717075892857143e-06 1.5 4.7176339285714285e-06 0.0 4.7287946428571425e-06 0.0 4.729352678571428e-06 1.5 4.734933035714286e-06 1.5 4.735491071428571e-06 0.0 4.746651785714286e-06 0.0 4.747209821428571e-06 1.5 4.752790178571428e-06 1.5 4.753348214285714e-06 0.0 4.764508928571428e-06 0.0 4.765066964285714e-06 1.5 4.770647321428571e-06 1.5 4.771205357142857e-06 0.0 4.782366071428571e-06 0.0 4.782924107142857e-06 1.5 4.788504464285714e-06 1.5 4.7890624999999995e-06 0.0 4.800223214285714e-06 0.0 4.800781249999999e-06 1.5 4.806361607142857e-06 1.5 4.806919642857143e-06 0.0 4.818080357142857e-06 0.0 4.8186383928571425e-06 1.5 4.82421875e-06 1.5 4.824776785714285e-06 0.0 4.8359375e-06 0.0 4.836495535714286e-06 1.5 4.842075892857142e-06 1.5 4.842633928571428e-06 0.0 4.853794642857142e-06 0.0 4.854352678571428e-06 1.5 4.8599330357142854e-06 1.5 4.860491071428571e-06 0.0 4.871651785714285e-06 0.0 4.872209821428571e-06 1.5 4.877790178571429e-06 1.5 4.878348214285714e-06 0.0 4.8895089285714285e-06 0.0 4.8900669642857135e-06 1.5 4.895647321428571e-06 1.5 4.896205357142857e-06 0.0 4.907366071428571e-06 0.0 4.907924107142857e-06 1.5 4.913504464285714e-06 1.5 4.9140625e-06 0.0 4.925223214285714e-06 0.0 4.92578125e-06 1.5 4.9313616071428564e-06 1.5 4.931919642857142e-06 0.0 4.943080357142857e-06 0.0 4.943638392857142e-06 1.5 4.94921875e-06 1.5 4.9497767857142855e-06 0.0 4.9609374999999995e-06 0.0 4.961495535714285e-06 1.5 4.967075892857143e-06 1.5 4.967633928571428e-06 0.0 4.978794642857143e-06 0.0 4.9793526785714285e-06 1.5 4.984933035714285e-06 1.5 4.985491071428571e-06 0.0 4.996651785714285e-06 0.0 4.997209821428571e-06 1.5 5.002790178571428e-06 1.5 5.003348214285714e-06 0.0 5.014508928571428e-06 0.0 5.015066964285714e-06 1.5 5.0206473214285714e-06 1.5 5.0212053571428565e-06 0.0 5.032366071428571e-06 0.0 5.032924107142857e-06 1.5 5.038504464285714e-06 1.5 5.0390625e-06 0.0 5.050223214285714e-06 0.0 5.0507812499999995e-06 1.5 5.056361607142857e-06 1.5 5.056919642857143e-06 0.0 5.068080357142857e-06 0.0 5.068638392857143e-06 1.5 5.074218749999999e-06 1.5 5.074776785714285e-06 0.0 5.0859375e-06 0.0 5.086495535714285e-06 1.5 5.092075892857142e-06 1.5 5.092633928571428e-06 0.0 5.104352678571428e-06 0.0 5.104910714285714e-06 1.5 5.109375e-06 1.5 5.109933035714286e-06 0.0 5.122209821428571e-06 0.0 5.122767857142856e-06 1.5 5.127232142857143e-06 1.5 5.127790178571428e-06 0.0 5.140066964285714e-06 0.0 5.140625e-06 1.5 5.145089285714285e-06 1.5 5.145647321428571e-06 0.0 5.157924107142857e-06 0.0 5.158482142857143e-06 1.5 5.162946428571428e-06 1.5 5.163504464285714e-06 0.0 5.17578125e-06 0.0 5.176339285714285e-06 1.5 5.180803571428571e-06 1.5 5.1813616071428566e-06 0.0 5.193638392857142e-06 0.0 5.194196428571428e-06 1.5 5.198660714285714e-06 1.5 5.19921875e-06 0.0 5.2114955357142855e-06 0.0 5.2120535714285714e-06 1.5 5.216517857142857e-06 1.5 5.217075892857142e-06 0.0 5.229352678571428e-06 0.0 5.229910714285714e-06 1.5 5.234374999999999e-06 1.5 5.234933035714285e-06 0.0 5.247209821428571e-06 0.0 5.247767857142857e-06 1.5 5.2522321428571425e-06 1.5 5.252790178571428e-06 0.0 5.265066964285714e-06 0.0 5.265624999999999e-06 1.5 5.270089285714286e-06 1.5 5.270647321428571e-06 0.0 5.2829241071428565e-06 0.0 5.283482142857142e-06 1.5 5.287946428571428e-06 1.5 5.288504464285714e-06 0.0 5.30078125e-06 0.0 5.301339285714286e-06 1.5 5.305803571428571e-06 1.5 5.306361607142857e-06 0.0 5.318638392857143e-06 0.0 5.319196428571428e-06 1.5 5.3236607142857135e-06 1.5 5.324218749999999e-06 0.0 5.336495535714285e-06 0.0 5.337053571428571e-06 1.5 5.341517857142857e-06 1.5 5.3420758928571426e-06 0.0 5.354352678571428e-06 0.0 5.354910714285714e-06 1.5 5.359375e-06 1.5 5.359933035714286e-06 0.0 5.372209821428571e-06 0.0 5.3727678571428566e-06 1.5 5.377232142857142e-06 1.5 5.377790178571428e-06 0.0 5.390066964285714e-06 0.0 5.390625e-06 1.5 5.395089285714285e-06 1.5 5.395647321428571e-06 0.0 5.407924107142857e-06 0.0 5.408482142857142e-06 1.5 5.4129464285714285e-06 1.5 5.4135044642857136e-06 0.0 5.425781249999999e-06 0.0 5.426339285714285e-06 1.5 5.430803571428571e-06 1.5 5.431361607142857e-06 0.0 5.4436383928571425e-06 0.0 5.444196428571428e-06 1.5 5.448660714285714e-06 1.5 5.44921875e-06 0.0 5.461495535714286e-06 0.0 5.462053571428571e-06 1.5 5.466517857142857e-06 1.5 5.467075892857142e-06 0.0 5.479352678571428e-06 0.0 5.479910714285714e-06 1.5 5.4843749999999995e-06 1.5 5.484933035714285e-06 0.0 5.497209821428571e-06 0.0 5.497767857142857e-06 1.5 5.502232142857143e-06 1.5 5.5027901785714286e-06 0.0 5.5150669642857135e-06 0.0 5.515624999999999e-06 1.5 5.520089285714285e-06 1.5 5.520647321428571e-06 0.0 5.532924107142857e-06 0.0 5.5334821428571426e-06 1.5 5.537946428571428e-06 1.5 5.538504464285714e-06 0.0 5.55078125e-06 0.0 5.551339285714286e-06 1.5 5.555803571428571e-06 1.5 5.556361607142856e-06 0.0 5.568638392857142e-06 0.0 5.569196428571428e-06 1.5 5.573660714285714e-06 1.5 5.5742187499999995e-06 0.0 5.586495535714285e-06 0.0 5.587053571428571e-06 1.5 5.591517857142857e-06 1.5 5.592075892857143e-06 0.0 5.6043526785714285e-06 0.0 5.6049107142857135e-06 1.5 5.609375e-06 1.5 5.609933035714285e-06 0.0 5.622209821428571e-06 0.0 5.622767857142857e-06 1.5 5.627232142857142e-06 1.5 5.627790178571428e-06 0.0 5.640066964285714e-06 0.0 5.640625e-06 1.5 5.6450892857142855e-06 1.5 5.645647321428571e-06 0.0 5.657924107142857e-06 0.0 5.658482142857142e-06 1.5 5.662946428571428e-06 1.5 5.663504464285714e-06 0.0 5.6757812499999995e-06 0.0 5.676339285714285e-06 1.5 5.680803571428571e-06 1.5 5.681361607142857e-06 0.0 5.693638392857143e-06 0.0 5.6941964285714286e-06 1.5 5.698660714285714e-06 1.5 5.699218749999999e-06 0.0 5.711495535714285e-06 0.0 5.712053571428571e-06 1.5 5.7165178571428565e-06 1.5 5.717075892857142e-06 0.0 5.729352678571428e-06 0.0 5.729910714285714e-06 1.5 5.734375e-06 1.5 5.7349330357142855e-06 0.0 5.747209821428571e-06 0.0 5.747767857142856e-06 1.5 5.752232142857143e-06 1.5 5.752790178571428e-06 0.0 5.765066964285714e-06 0.0 5.7656249999999995e-06 1.5 5.770089285714285e-06 1.5 5.770647321428571e-06 0.0 5.782924107142857e-06 0.0 5.783482142857143e-06 1.5 5.787946428571428e-06 1.5 5.788504464285714e-06 0.0 5.80078125e-06 0.0 5.801339285714285e-06 1.5 5.805803571428571e-06 1.5 5.8063616071428565e-06 0.0 5.818638392857142e-06 0.0 5.819196428571428e-06 1.5 5.823660714285714e-06 1.5 5.82421875e-06 0.0 5.8364955357142855e-06 0.0 5.837053571428571e-06 1.5 5.841517857142857e-06 1.5 5.842075892857143e-06 0.0 5.854352678571428e-06 0.0 5.854910714285714e-06 1.5 5.859374999999999e-06 1.5 5.859933035714285e-06 0.0 5.872209821428571e-06 0.0 5.872767857142857e-06 1.5 5.8772321428571424e-06 1.5 5.877790178571428e-06 0.0 5.890066964285714e-06 0.0 5.890624999999999e-06 1.5 5.895089285714286e-06 1.5 5.895647321428571e-06 0.0 5.9079241071428564e-06 0.0 5.908482142857142e-06 1.5 5.912946428571428e-06 1.5 5.913504464285714e-06 0.0 5.92578125e-06 0.0 5.9263392857142855e-06 1.5 5.930803571428571e-06 1.5 5.931361607142857e-06 0.0 5.943638392857143e-06 0.0 5.944196428571428e-06 1.5 5.948660714285714e-06 1.5 5.949218749999999e-06 0.0 5.961495535714285e-06 0.0 5.962053571428571e-06 1.5 5.966517857142857e-06 1.5 5.9670758928571425e-06 0.0 5.979352678571428e-06 0.0 5.979910714285714e-06 1.5 5.984375e-06 1.5 5.984933035714286e-06 0.0 5.997209821428571e-06 0.0 5.9977678571428565e-06 1.5 6.002232142857142e-06 1.5 6.002790178571428e-06 0.0 6.015066964285714e-06 0.0 6.015625e-06 1.5 6.020089285714285e-06 1.5 6.020647321428571e-06 0.0 6.032924107142857e-06 0.0 6.033482142857142e-06 1.5 6.0379464285714284e-06 1.5 6.0385044642857135e-06 0.0 6.050781249999999e-06 0.0 6.051339285714285e-06 1.5 6.055803571428571e-06 1.5 6.056361607142857e-06 0.0 6.0686383928571424e-06 0.0 6.069196428571428e-06 1.5 6.073660714285714e-06 1.5 6.07421875e-06 0.0 6.086495535714286e-06 0.0 6.087053571428571e-06 1.5 6.091517857142857e-06 1.5 6.092075892857142e-06 0.0 6.104352678571428e-06 0.0 6.104910714285714e-06 1.5 6.109374999999999e-06 1.5 6.109933035714285e-06 0.0 6.122209821428571e-06 0.0 6.122767857142857e-06 1.5 6.127232142857143e-06 1.5 6.1277901785714285e-06 0.0 6.1400669642857134e-06 0.0 6.140624999999999e-06 1.5 6.145089285714285e-06 1.5 6.145647321428571e-06 0.0 6.157924107142857e-06 0.0 6.1584821428571425e-06 1.5 6.162946428571428e-06 1.5 6.163504464285714e-06 0.0 6.17578125e-06 0.0 6.176339285714286e-06 1.5 6.180803571428571e-06 1.5 6.181361607142856e-06 0.0 6.193638392857142e-06 0.0 6.194196428571428e-06 1.5 6.198660714285714e-06 1.5 6.1992187499999995e-06 0.0 6.211495535714285e-06 0.0 6.212053571428571e-06 1.5 6.216517857142857e-06 1.5 6.217075892857143e-06 0.0 6.2293526785714284e-06 0.0 6.2299107142857135e-06 1.5 6.234375e-06 1.5 6.234933035714285e-06 0.0 6.247209821428571e-06 0.0 6.247767857142857e-06 1.5 6.252232142857142e-06 1.5 6.252790178571428e-06 0.0 6.265066964285714e-06 0.0 6.265625e-06 1.5 6.270089285714285e-06 1.5 6.270647321428571e-06 0.0 6.282924107142857e-06 0.0 6.283482142857142e-06 1.5 6.287946428571428e-06 1.5 6.288504464285714e-06 0.0 6.300781249999999e-06 0.0 6.301339285714285e-06 1.5 6.305803571428571e-06 1.5 6.306361607142857e-06 0.0 6.318638392857143e-06 0.0 6.3191964285714285e-06 1.5 6.323660714285714e-06 1.5 6.324218749999999e-06 0.0 6.336495535714285e-06 0.0 6.337053571428571e-06 1.5 6.341517857142856e-06 1.5 6.342075892857142e-06 0.0 6.354352678571428e-06 0.0 6.354910714285714e-06 1.5 6.3593749999999996e-06 1.5 6.3599330357142855e-06 0.0 6.372209821428571e-06 0.0 6.372767857142856e-06 1.5 6.377232142857143e-06 1.5 6.377790178571428e-06 0.0 6.3900669642857136e-06 0.0 6.3906249999999995e-06 1.5 6.395089285714285e-06 1.5 6.395647321428571e-06 0.0 6.407924107142857e-06 0.0 6.408482142857143e-06 1.5 6.412946428571428e-06 1.5 6.413504464285714e-06 0.0 6.42578125e-06 0.0 6.426339285714285e-06 1.5 6.4308035714285706e-06 1.5 6.4313616071428565e-06 0.0 6.443638392857142e-06 0.0 6.444196428571428e-06 1.5 6.448660714285714e-06 1.5 6.44921875e-06 0.0 6.461495535714285e-06 0.0 6.462053571428571e-06 1.5 6.466517857142857e-06 1.5 6.467075892857143e-06 0.0 6.479352678571428e-06 0.0 6.479910714285714e-06 1.5 6.484374999999999e-06 1.5 6.484933035714285e-06 0.0 6.497209821428571e-06 0.0 6.497767857142857e-06 1.5 6.502232142857142e-06 1.5 6.502790178571428e-06 0.0 6.515066964285714e-06 0.0 6.515624999999999e-06 1.5 6.5200892857142856e-06 1.5 6.520647321428571e-06 0.0 6.532924107142856e-06 0.0 6.533482142857142e-06 1.5 6.537946428571428e-06 1.5 6.538504464285714e-06 0.0 6.5507812499999996e-06 0.0 6.5513392857142855e-06 1.5 6.555803571428571e-06 1.5 6.556361607142857e-06 0.0 6.568638392857143e-06 0.0 6.569196428571428e-06 1.5 6.573660714285714e-06 1.5 6.574218749999999e-06 0.0 6.586495535714285e-06 0.0 6.587053571428571e-06 1.5 6.5915178571428565e-06 1.5 6.5920758928571425e-06 0.0 6.604352678571428e-06 0.0 6.604910714285714e-06 1.5 6.609375e-06 1.5 6.609933035714286e-06 0.0 6.6222098214285706e-06 0.0 6.6227678571428565e-06 1.5 6.627232142857142e-06 1.5 6.627790178571428e-06 0.0 6.640066964285714e-06 0.0 6.640625e-06 1.5 6.645089285714285e-06 1.5 6.645647321428571e-06 0.0 6.657924107142857e-06 0.0 6.658482142857143e-06 1.5 6.662946428571428e-06 1.5 6.6635044642857134e-06 0.0 6.675781249999999e-06 0.0 6.676339285714285e-06 1.5 6.680803571428571e-06 1.5 6.681361607142857e-06 0.0 6.693638392857142e-06 0.0 6.694196428571428e-06 1.5 6.698660714285714e-06 1.5 6.69921875e-06 0.0 6.7114955357142856e-06 0.0 6.712053571428571e-06 1.5 6.716517857142857e-06 1.5 6.717075892857142e-06 0.0 6.729352678571428e-06 0.0 6.729910714285714e-06 1.5 6.734374999999999e-06 1.5 6.734933035714285e-06 0.0 6.747209821428571e-06 0.0 6.747767857142857e-06 1.5 6.7522321428571425e-06 1.5 6.7527901785714284e-06 0.0 6.765066964285714e-06 0.0 6.765624999999999e-06 1.5 6.770089285714285e-06 1.5 6.770647321428571e-06 0.0 6.7829241071428565e-06 0.0 6.7834821428571425e-06 1.5 6.787946428571428e-06 1.5 6.788504464285714e-06 0.0 6.80078125e-06 0.0 6.801339285714286e-06 1.5 6.805803571428571e-06 1.5 6.806361607142856e-06 0.0 6.818638392857142e-06 0.0 6.819196428571428e-06 1.5 6.8236607142857135e-06 1.5 6.8242187499999994e-06 0.0 6.836495535714285e-06 0.0 6.837053571428571e-06 1.5 6.841517857142857e-06 1.5 6.842075892857143e-06 0.0 6.854352678571428e-06 0.0 6.8549107142857134e-06 1.5 6.859375e-06 1.5 6.859933035714285e-06 0.0 6.872209821428571e-06 0.0 6.872767857142857e-06 1.5 6.877232142857142e-06 1.5 6.877790178571428e-06 0.0 6.890066964285714e-06 0.0 6.890625e-06 1.5 6.895089285714285e-06 1.5 6.895647321428571e-06 0.0 6.907924107142857e-06 0.0 6.908482142857142e-06 1.5 6.912946428571428e-06 1.5 6.913504464285714e-06 0.0 6.925781249999999e-06 0.0 6.926339285714285e-06 1.5 6.930803571428571e-06 1.5 6.931361607142857e-06 0.0 6.943080357142857e-06 0.0 6.9436383928571425e-06 1.5 6.949218749999999e-06 1.5 6.949776785714285e-06 0.0 6.9609375e-06 0.0 6.961495535714285e-06 1.5 6.967075892857142e-06 1.5 6.967633928571428e-06 0.0 6.978794642857142e-06 0.0 6.979352678571428e-06 1.5 6.9849330357142854e-06 1.5 6.985491071428571e-06 0.0 6.996651785714285e-06 0.0 6.997209821428571e-06 1.5 7.002790178571428e-06 1.5 7.003348214285714e-06 0.0 7.0145089285714285e-06 0.0 7.0150669642857135e-06 1.5 7.020647321428571e-06 1.5 7.021205357142857e-06 0.0 7.032366071428571e-06 0.0 7.032924107142857e-06 1.5 7.038504464285714e-06 1.5 7.039062499999999e-06 0.0 7.050223214285714e-06 0.0 7.05078125e-06 1.5 7.056361607142856e-06 1.5 7.056919642857142e-06 0.0 7.068080357142856e-06 0.0 7.068638392857142e-06 1.5 7.07421875e-06 1.5 7.0747767857142855e-06 0.0 7.0859374999999994e-06 0.0 7.086495535714285e-06 1.5 7.092075892857143e-06 1.5 7.092633928571428e-06 0.0 7.103794642857143e-06 0.0 7.104352678571428e-06 1.5 7.109933035714285e-06 1.5 7.110491071428571e-06 0.0 7.121651785714285e-06 0.0 7.122209821428571e-06 1.5 7.127790178571428e-06 1.5 7.128348214285714e-06 0.0 7.139508928571428e-06 0.0 7.140066964285714e-06 1.5 7.1456473214285706e-06 1.5 7.1462053571428565e-06 0.0 7.157366071428571e-06 0.0 7.157924107142856e-06 1.5 7.163504464285714e-06 1.5 7.1640625e-06 0.0 7.175223214285714e-06 0.0 7.1757812499999995e-06 1.5 7.181361607142857e-06 1.5 7.181919642857142e-06 0.0 7.193080357142857e-06 0.0 7.193638392857143e-06 1.5 7.199218749999999e-06 1.5 7.199776785714285e-06 0.0 7.210937499999999e-06 0.0 7.211495535714285e-06 1.5 7.217075892857142e-06 1.5 7.217633928571428e-06 0.0 7.228794642857142e-06 0.0 7.229352678571428e-06 1.5 7.2349330357142856e-06 1.5 7.235491071428571e-06 0.0 7.2466517857142854e-06 0.0 7.2472098214285705e-06 1.5 7.252790178571428e-06 1.5 7.253348214285714e-06 0.0 7.264508928571428e-06 0.0 7.265066964285714e-06 1.5 7.270647321428571e-06 1.5 7.271205357142857e-06 0.0 7.282366071428571e-06 0.0 7.282924107142857e-06 1.5 7.288504464285713e-06 1.5 7.289062499999999e-06 0.0 7.300223214285714e-06 0.0 7.300781249999999e-06 1.5 7.3063616071428566e-06 1.5 7.3069196428571425e-06 0.0 7.318080357142856e-06 0.0 7.318638392857142e-06 1.5 7.32421875e-06 1.5 7.324776785714285e-06 0.0 7.3359375e-06 0.0 7.3364955357142855e-06 1.5 7.342075892857142e-06 1.5 7.342633928571428e-06 0.0 7.353794642857142e-06 0.0 7.354352678571428e-06 1.5 7.360491071428571e-06 1.5 7.361049107142856e-06 0.0 7.371093749999999e-06 0.0 7.371651785714285e-06 1.5 7.3783482142857135e-06 1.5 7.378906249999999e-06 0.0 7.388950892857142e-06 0.0 7.389508928571428e-06 1.5 7.396205357142857e-06 1.5 7.3967633928571425e-06 0.0 7.4068080357142855e-06 0.0 7.407366071428571e-06 1.5 7.4140625e-06 1.5 7.414620535714285e-06 0.0 7.424665178571428e-06 0.0 7.425223214285714e-06 1.5 7.431919642857142e-06 1.5 7.432477678571428e-06 0.0 7.442522321428571e-06 0.0 7.443080357142857e-06 1.5 7.449776785714285e-06 1.5 7.450334821428571e-06 0.0 7.460379464285713e-06 0.0 7.460937499999999e-06 1.5 7.4676339285714285e-06 1.5 7.4681919642857135e-06 0.0 7.4782366071428565e-06 0.0 7.478794642857142e-06 1.5 7.485491071428571e-06 1.5 7.486049107142857e-06 0.0 7.49609375e-06 0.0 7.496651785714286e-06 1.5 7.503348214285714e-06 1.5 7.50390625e-06 0.0 7.513950892857142e-06 0.0 7.514508928571428e-06 1.5 7.521205357142856e-06 1.5 7.521763392857142e-06 0.0 7.531808035714285e-06 0.0 7.532366071428571e-06 1.5 7.5390624999999994e-06 1.5 7.539620535714285e-06 0.0 7.549665178571428e-06 0.0 7.550223214285713e-06 1.5 7.556919642857143e-06 1.5 7.557477678571428e-06 0.0 7.567522321428571e-06 0.0 7.5680803571428566e-06 1.5 7.574776785714285e-06 1.5 7.575334821428571e-06 0.0 7.585379464285714e-06 0.0 7.5859375e-06 1.5 7.592633928571428e-06 1.5 7.593191964285714e-06 0.0 7.603236607142857e-06 0.0 7.603794642857142e-06 1.5 7.610491071428571e-06 1.5 7.611049107142856e-06 0.0 7.621093749999999e-06 0.0 7.621651785714285e-06 1.5 7.628348214285714e-06 1.5 7.6289062499999995e-06 0.0 7.638950892857142e-06 0.0 7.639508928571428e-06 1.5 7.646205357142857e-06 1.5 7.646763392857142e-06 0.0 7.656808035714285e-06 0.0 7.657366071428572e-06 1.5 7.664062499999999e-06 1.5 7.664620535714286e-06 0.0 7.674665178571429e-06 0.0 7.675223214285714e-06 1.5 7.681919642857143e-06 1.5 7.682477678571428e-06 0.0 7.692522321428571e-06 0.0 7.693080357142856e-06 1.5 7.699776785714285e-06 1.5 7.70033482142857e-06 0.0 7.709821428571428e-06 0.0 7.710379464285713e-06 1.5 7.718191964285715e-06 1.5 7.71875e-06 0.0 7.72767857142857e-06 0.0 7.728236607142856e-06 1.5 7.736049107142857e-06 1.5 7.736607142857142e-06 0.0 7.745535714285713e-06 0.0 7.74609375e-06 1.5 7.75390625e-06 1.5 7.754464285714286e-06 0.0 7.763392857142857e-06 0.0 7.763950892857142e-06 1.5 7.771763392857141e-06 1.5 7.772321428571428e-06 0.0 7.78125e-06 0.0 7.781808035714284e-06 1.5 7.789620535714286e-06 1.5 7.79017857142857e-06 0.0 7.799107142857142e-06 0.0 7.799665178571428e-06 1.5 7.807477678571428e-06 1.5 7.808035714285713e-06 0.0 7.816964285714286e-06 0.0 7.81752232142857e-06 1.5 7.82533482142857e-06 1.5 7.825892857142857e-06 0.0 7.834821428571428e-06 0.0 7.835379464285713e-06 1.5 7.843191964285714e-06 1.5 7.84375e-06 0.0 7.85267857142857e-06 0.0 7.853236607142857e-06 1.5 7.861049107142856e-06 1.5 7.861607142857142e-06 0.0 7.870535714285714e-06 0.0 7.87109375e-06 1.5 7.878906249999999e-06 1.5 7.879464285714286e-06 0.0 7.888392857142857e-06 0.0 7.888950892857142e-06 1.5 7.896763392857143e-06 1.5 7.897321428571428e-06 0.0 7.906249999999999e-06 0.0 7.906808035714286e-06 1.5 7.914620535714285e-06 1.5 7.91517857142857e-06 0.0 7.924107142857143e-06 0.0 7.924665178571428e-06 1.5 7.932477678571427e-06 1.5 7.933035714285714e-06 0.0 7.941964285714285e-06 0.0 7.94252232142857e-06 1.5 7.950334821428571e-06 1.5 7.950892857142857e-06 0.0 7.959821428571428e-06 0.0 7.960379464285714e-06 1.5 7.968191964285714e-06 1.5 7.968749999999999e-06 0.0 7.97767857142857e-06 0.0 7.978236607142857e-06 1.5 7.986049107142856e-06 1.5 7.986607142857143e-06 0.0 7.995535714285714e-06 0.0 7.996093749999999e-06 1.5 8.00390625e-06 1.5 8.004464285714285e-06 0.0 8.013392857142856e-06 0.0 8.013950892857141e-06 1.5 8.021763392857142e-06 1.5 8.022321428571428e-06 0.0 8.030691964285714e-06 0.0 8.031249999999999e-06 1.5 8.040178571428572e-06 1.5 8.040736607142857e-06 0.0 8.048549107142856e-06 0.0 8.049107142857143e-06 1.5 8.058035714285714e-06 1.5 8.058593749999999e-06 0.0 8.06640625e-06 0.0 8.066964285714285e-06 1.5 8.075892857142856e-06 1.5 8.076450892857143e-06 0.0 8.084263392857142e-06 0.0 8.084821428571427e-06 1.5 8.09375e-06 1.5 8.094308035714285e-06 0.0 8.102120535714285e-06 0.0 8.102678571428571e-06 1.5 8.111607142857143e-06 1.5 8.112165178571428e-06 0.0 8.119977678571429e-06 0.0 8.120535714285714e-06 1.5 8.129464285714285e-06 1.5 8.130022321428572e-06 0.0 8.137834821428571e-06 0.0 8.138392857142856e-06 1.5 8.147321428571427e-06 1.5 8.147879464285714e-06 0.0 8.155691964285713e-06 0.0 8.15625e-06 1.5 8.165178571428571e-06 1.5 8.165736607142856e-06 0.0 8.173549107142857e-06 0.0 8.174107142857142e-06 1.5 8.183035714285714e-06 1.5 8.183593749999999e-06 0.0 8.19140625e-06 0.0 8.191964285714285e-06 1.5 8.200892857142856e-06 1.5 8.201450892857143e-06 0.0 8.209263392857142e-06 0.0 8.209821428571429e-06 1.5 8.21875e-06 1.5 8.219308035714285e-06 0.0 8.227120535714284e-06 0.0 8.227678571428571e-06 1.5 8.236607142857142e-06 1.5 8.237165178571427e-06 0.0 8.244977678571428e-06 0.0 8.245535714285713e-06 1.5 8.254464285714285e-06 1.5 8.255022321428571e-06 0.0 8.26283482142857e-06 0.0 8.263392857142857e-06 1.5 8.272321428571429e-06 1.5 8.272879464285714e-06 0.0 8.280691964285713e-06 0.0 8.28125e-06 1.5 8.290178571428571e-06 1.5 8.290736607142856e-06 0.0 8.298549107142857e-06 0.0 8.299107142857142e-06 1.5 8.308035714285713e-06 1.5 8.30859375e-06 0.0 8.31640625e-06 0.0 8.316964285714284e-06 1.5 8.325892857142857e-06 1.5 8.326450892857142e-06 0.0 8.334263392857142e-06 0.0 8.334821428571428e-06 1.5 8.34375e-06 1.5 8.344308035714285e-06 0.0 8.351562499999999e-06 0.0 8.352120535714286e-06 1.5 8.362165178571429e-06 1.5 8.362723214285714e-06 0.0 8.369419642857143e-06 0.0 8.369977678571428e-06 1.5 8.380022321428571e-06 1.5 8.380580357142856e-06 0.0 8.387276785714285e-06 0.0 8.38783482142857e-06 1.5 8.397879464285713e-06 1.5 8.3984375e-06 0.0 8.405133928571428e-06 0.0 8.405691964285714e-06 1.5 8.415736607142857e-06 1.5 8.416294642857142e-06 0.0 8.422991071428572e-06 0.0 8.423549107142857e-06 1.5 8.43359375e-06 1.5 8.434151785714285e-06 0.0 8.440848214285714e-06 0.0 8.441406249999999e-06 1.5 8.451450892857142e-06 1.5 8.452008928571429e-06 0.0 8.458705357142856e-06 0.0 8.459263392857143e-06 1.5 8.469308035714286e-06 1.5 8.469866071428571e-06 0.0 8.4765625e-06 0.0 8.477120535714285e-06 1.5 8.487165178571428e-06 1.5 8.487723214285713e-06 0.0 8.494419642857143e-06 0.0 8.494977678571428e-06 1.5 8.50502232142857e-06 1.5 8.505580357142857e-06 0.0 8.512276785714285e-06 0.0 8.512834821428572e-06 1.5 8.522879464285713e-06 1.5 8.5234375e-06 0.0 8.530133928571427e-06 0.0 8.530691964285714e-06 1.5 8.540736607142857e-06 1.5 8.541294642857142e-06 0.0 8.547991071428571e-06 0.0 8.548549107142856e-06 1.5 8.55859375e-06 1.5 8.559151785714284e-06 0.0 8.565848214285714e-06 0.0 8.566406249999999e-06 1.5 8.576450892857142e-06 1.5 8.577008928571428e-06 0.0 8.583705357142856e-06 0.0 8.584263392857143e-06 1.5 8.594308035714286e-06 1.5 8.59486607142857e-06 0.0 8.6015625e-06 0.0 8.602120535714285e-06 1.5 8.612165178571428e-06 1.5 8.612723214285713e-06 0.0 8.619419642857142e-06 0.0 8.619977678571427e-06 1.5 8.63002232142857e-06 1.5 8.630580357142857e-06 0.0 8.637276785714285e-06 0.0 8.637834821428571e-06 1.5 8.647879464285714e-06 1.5 8.6484375e-06 0.0 8.655133928571429e-06 0.0 8.655691964285714e-06 1.5 8.665736607142857e-06 1.5 8.666294642857142e-06 0.0 8.672991071428571e-06 0.0 8.673549107142856e-06 1.5 8.683593749999999e-06 1.5 8.684151785714286e-06 0.0 8.690848214285713e-06 0.0 8.69140625e-06 1.5 8.702008928571428e-06 1.5 8.702566964285713e-06 0.0 8.70814732142857e-06 0.0 8.708705357142857e-06 1.5 8.71986607142857e-06 1.5 8.720424107142857e-06 0.0 8.726004464285714e-06 0.0 8.7265625e-06 1.5 8.737723214285714e-06 1.5 8.73828125e-06 0.0 8.743861607142857e-06 0.0 8.744419642857142e-06 1.5 8.755580357142857e-06 1.5 8.756138392857142e-06 0.0 8.761718749999999e-06 0.0 8.762276785714286e-06 1.5 8.773437499999999e-06 1.5 8.773995535714286e-06 0.0 8.779575892857141e-06 0.0 8.780133928571428e-06 1.5 8.791294642857143e-06 1.5 8.791852678571428e-06 0.0 8.797433035714285e-06 0.0 8.79799107142857e-06 1.5 8.809151785714285e-06 1.5 8.80970982142857e-06 0.0 8.815290178571428e-06 0.0 8.815848214285713e-06 1.5 8.827008928571428e-06 1.5 8.827566964285714e-06 0.0 8.83314732142857e-06 0.0 8.833705357142857e-06 1.5 8.844866071428572e-06 1.5 8.845424107142857e-06 0.0 8.851004464285714e-06 0.0 8.8515625e-06 1.5 8.862723214285714e-06 1.5 8.863281249999999e-06 0.0 8.868861607142856e-06 0.0 8.869419642857141e-06 1.5 8.880580357142856e-06 1.5 8.881138392857143e-06 0.0 8.886718749999999e-06 0.0 8.887276785714286e-06 1.5 8.898437499999999e-06 1.5 8.898995535714285e-06 0.0 8.904575892857143e-06 0.0 8.905133928571428e-06 1.5 8.916294642857143e-06 1.5 8.916852678571428e-06 0.0 8.922433035714285e-06 0.0 8.92299107142857e-06 1.5 8.934151785714285e-06 1.5 8.93470982142857e-06 0.0 8.940290178571427e-06 0.0 8.940848214285714e-06 1.5 8.952008928571427e-06 1.5 8.952566964285714e-06 0.0 8.958147321428571e-06 0.0 8.958705357142856e-06 1.5 8.969866071428571e-06 1.5 8.970424107142856e-06 0.0 8.976004464285714e-06 0.0 8.976562499999999e-06 1.5 8.987723214285714e-06 1.5 8.988281249999999e-06 0.0 8.993861607142856e-06 0.0 8.994419642857143e-06 1.5 9.005580357142856e-06 1.5 9.006138392857143e-06 0.0 9.01171875e-06 0.0 9.012276785714285e-06 1.5 9.0234375e-06 1.5 9.023995535714285e-06 0.0 9.029575892857142e-06 0.0 9.030133928571427e-06 1.5 9.041294642857142e-06 1.5 9.041852678571427e-06 0.0 9.047433035714285e-06 0.0 9.047991071428571e-06 1.5 9.059151785714285e-06 1.5 9.059709821428571e-06 0.0 9.065290178571429e-06 0.0 9.065848214285714e-06 1.5 9.077008928571429e-06 1.5 9.077566964285714e-06 0.0 9.083147321428571e-06 0.0 9.083705357142856e-06 1.5 9.094866071428571e-06 1.5 9.095424107142856e-06 0.0 9.101004464285713e-06 0.0 9.1015625e-06 1.5 9.11328125e-06 1.5 9.113839285714285e-06 0.0 9.11830357142857e-06 0.0 9.118861607142856e-06 1.5 9.131138392857142e-06 1.5 9.131696428571427e-06 0.0 9.136160714285713e-06 0.0 9.13671875e-06 1.5 9.148995535714285e-06 1.5 9.149553571428571e-06 0.0 9.154017857142857e-06 0.0 9.154575892857142e-06 1.5 9.166852678571429e-06 1.5 9.167410714285714e-06 0.0 9.171875e-06 0.0 9.172433035714284e-06 1.5 9.184709821428571e-06 1.5 9.185267857142856e-06 0.0 9.189732142857142e-06 0.0 9.190290178571428e-06 1.5 9.202566964285713e-06 1.5 9.203125e-06 0.0 9.207589285714286e-06 0.0 9.20814732142857e-06 1.5 9.220424107142856e-06 1.5 9.220982142857142e-06 0.0 9.225446428571428e-06 0.0 9.226004464285713e-06 1.5 9.23828125e-06 1.5 9.238839285714285e-06 0.0 9.24330357142857e-06 0.0 9.243861607142857e-06 1.5 9.256138392857142e-06 1.5 9.256696428571429e-06 0.0 9.261160714285714e-06 0.0 9.26171875e-06 1.5 9.273995535714284e-06 1.5 9.274553571428571e-06 0.0 9.279017857142857e-06 0.0 9.279575892857142e-06 1.5 9.291852678571428e-06 1.5 9.292410714285713e-06 0.0 9.296874999999999e-06 0.0 9.297433035714286e-06 1.5 9.30970982142857e-06 1.5 9.310267857142856e-06 0.0 9.314732142857143e-06 0.0 9.315290178571428e-06 1.5 9.327566964285713e-06 1.5 9.328125e-06 0.0 9.332589285714285e-06 0.0 9.33314732142857e-06 1.5 9.345424107142857e-06 1.5 9.345982142857142e-06 0.0 9.350446428571428e-06 0.0 9.351004464285714e-06 1.5 9.36328125e-06 1.5 9.363839285714284e-06 0.0 9.36830357142857e-06 0.0 9.368861607142857e-06 1.5 9.381138392857142e-06 1.5 9.381696428571428e-06 0.0 9.386160714285714e-06 0.0 9.386718749999999e-06 1.5 9.398995535714286e-06 1.5 9.39955357142857e-06 0.0 9.404017857142856e-06 0.0 9.404575892857141e-06 1.5 9.416852678571428e-06 1.5 9.417410714285713e-06 0.0 9.421874999999999e-06 0.0 9.422433035714285e-06 1.5 9.43470982142857e-06 1.5 9.435267857142857e-06 0.0 9.439732142857143e-06 0.0 9.440290178571428e-06 1.5 9.452566964285714e-06 1.5 9.453125e-06 0.0 9.457589285714285e-06 0.0 9.45814732142857e-06 1.5 9.470424107142857e-06 1.5 9.470982142857142e-06 0.0 9.475446428571427e-06 0.0 9.476004464285714e-06 1.5 9.488281249999999e-06 1.5 9.488839285714286e-06 0.0 9.493303571428571e-06 0.0 9.493861607142856e-06 1.5 9.506138392857143e-06 1.5 9.506696428571428e-06 0.0 9.511160714285714e-06 0.0 9.511718749999999e-06 1.5 9.523995535714285e-06 1.5 9.52455357142857e-06 0.0 9.529017857142856e-06 0.0 9.529575892857143e-06 1.5 9.541852678571428e-06 1.5 9.542410714285714e-06 0.0 9.546875e-06 0.0 9.547433035714285e-06 1.5 9.55970982142857e-06 1.5 9.560267857142857e-06 0.0 9.564732142857142e-06 0.0 9.565290178571427e-06 1.5 9.577566964285714e-06 1.5 9.578124999999999e-06 0.0 9.582589285714285e-06 0.0 9.583147321428571e-06 1.5 9.595424107142856e-06 1.5 9.595982142857141e-06 0.0 9.600446428571429e-06 0.0 9.601004464285714e-06 1.5 9.613281249999999e-06 1.5 9.613839285714285e-06 0.0 9.618303571428571e-06 0.0 9.618861607142856e-06 1.5 9.631138392857143e-06 1.5 9.631696428571428e-06 0.0 9.636160714285713e-06 0.0 9.63671875e-06 1.5 9.648995535714285e-06 1.5 9.64955357142857e-06 0.0 9.654017857142857e-06 0.0 9.654575892857142e-06 1.5 9.666852678571427e-06 1.5 9.667410714285714e-06 0.0 9.671875e-06 0.0 9.672433035714285e-06 1.5 9.684709821428571e-06 1.5 9.685267857142856e-06 0.0 9.689732142857142e-06 0.0 9.690290178571429e-06 1.5 9.702566964285714e-06 1.5 9.703124999999999e-06 0.0 9.707589285714284e-06 0.0 9.708147321428571e-06 1.5 9.720424107142856e-06 1.5 9.720982142857143e-06 0.0 9.725446428571428e-06 0.0 9.726004464285713e-06 1.5 9.73828125e-06 1.5 9.738839285714285e-06 0.0 9.74330357142857e-06 0.0 9.743861607142856e-06 1.5 9.756138392857142e-06 1.5 9.756696428571427e-06 0.0 9.761160714285713e-06 0.0 9.76171875e-06 1.5 9.773995535714285e-06 1.5 9.774553571428571e-06 0.0 9.779017857142857e-06 0.0 9.779575892857142e-06 1.5 9.791852678571429e-06 1.5 9.792410714285714e-06 0.0 9.796875e-06 0.0 9.797433035714284e-06 1.5 9.809709821428571e-06 1.5 9.810267857142856e-06 0.0 9.814732142857142e-06 0.0 9.815290178571428e-06 1.5 9.827566964285713e-06 1.5 9.828125e-06 0.0 9.832589285714286e-06 0.0 9.83314732142857e-06 1.5 9.845424107142856e-06 1.5 9.845982142857142e-06 0.0 9.850446428571428e-06 0.0 9.851004464285713e-06 1.5 9.86328125e-06 1.5 9.863839285714285e-06 0.0 9.86830357142857e-06 0.0 9.868861607142857e-06 1.5 9.881138392857142e-06 1.5 9.881696428571429e-06 0.0 9.886160714285714e-06 0.0 9.88671875e-06 1.5 9.898995535714284e-06 1.5 9.899553571428571e-06 0.0 9.904017857142857e-06 0.0 9.904575892857142e-06 1.5 9.916852678571428e-06 1.5 9.917410714285713e-06 0.0 9.921874999999999e-06 0.0 9.922433035714286e-06 1.5 9.93470982142857e-06 1.5 9.935267857142856e-06 0.0 9.939732142857143e-06 0.0 9.940290178571428e-06 1.5 9.952566964285713e-06 1.5 9.953125e-06 0.0 9.957589285714285e-06 0.0 9.95814732142857e-06 1.5 9.970424107142857e-06 1.5 9.970982142857142e-06 0.0 9.975446428571428e-06 0.0 9.976004464285714e-06 1.5 9.98828125e-06 1.5 9.988839285714284e-06 0.0 9.99330357142857e-06 0.0 9.993861607142857e-06 1.5 1.0006138392857142e-05 1.5 1.0006696428571428e-05 0.0 1.0011160714285714e-05 0.0 1.0011718749999999e-05 1.5 1.0023995535714286e-05 1.5 1.002455357142857e-05 0.0 1.0029017857142856e-05 0.0 1.0029575892857141e-05 1.5 1.0041852678571428e-05 1.5 1.0042410714285713e-05 0.0 1.0046874999999999e-05 0.0 1.0047433035714285e-05 1.5 1.005970982142857e-05 1.5 1.0060267857142857e-05 0.0 1.0064732142857143e-05 0.0 1.0065290178571428e-05 1.5 1.0077566964285714e-05 1.5 1.0078125e-05 0.0 1.0082589285714285e-05 0.0 1.008314732142857e-05 1.5 1.0095424107142857e-05 1.5 1.0095982142857142e-05 0.0 1.0100446428571427e-05 0.0 1.0101004464285714e-05 1.5 1.0113281249999999e-05 1.5 1.0113839285714286e-05 0.0 1.0118303571428571e-05 0.0 1.0118861607142856e-05 1.5 1.0131138392857143e-05 1.5 1.0131696428571428e-05 0.0 1.0136160714285714e-05 0.0 1.0136718749999999e-05 1.5 1.0148995535714285e-05 1.5 1.014955357142857e-05 0.0 1.0154017857142856e-05 0.0 1.0154575892857143e-05 1.5 1.0166852678571428e-05 1.5 1.0167410714285714e-05 0.0 1.0171875e-05 0.0 1.0172433035714285e-05 1.5 1.018470982142857e-05 1.5 1.0185267857142857e-05 0.0 1.0189732142857142e-05 0.0 1.0190290178571427e-05 1.5 1.0202566964285714e-05 1.5 1.0203124999999999e-05 0.0 1.0207589285714285e-05 0.0 1.0208147321428571e-05 1.5 1.0220424107142856e-05 1.5 1.0220982142857141e-05 0.0 1.0225446428571429e-05 0.0 1.0226004464285714e-05 1.5 1.0238281249999999e-05 1.5 1.0238839285714285e-05 0.0 1.0243303571428571e-05 0.0 1.0243861607142856e-05 1.5 1.0256138392857143e-05 1.5 1.0256696428571428e-05 0.0 1.0261160714285713e-05 0.0 1.026171875e-05 1.5 1.0273995535714285e-05 1.5 1.027455357142857e-05 0.0 1.0279017857142857e-05 0.0 1.0279575892857142e-05 1.5 1.0291852678571427e-05 1.5 1.0292410714285714e-05 0.0 1.0296875e-05 0.0 1.0297433035714285e-05 1.5 1.0309709821428571e-05 1.5 1.0310267857142856e-05 0.0 1.0314732142857142e-05 0.0 1.0315290178571429e-05 1.5 1.0327566964285714e-05 1.5 1.0328124999999999e-05 0.0 1.0332589285714284e-05 0.0 1.0333147321428571e-05 1.5 1.0345424107142856e-05 1.5 1.0345982142857143e-05 0.0 1.0350446428571428e-05 0.0 1.0351004464285713e-05 1.5 1.036328125e-05 1.5 1.0363839285714285e-05 0.0 1.036830357142857e-05 0.0 1.0368861607142856e-05 1.5 1.0381138392857142e-05 1.5 1.0381696428571427e-05 0.0 1.0386160714285713e-05 0.0 1.038671875e-05 1.5 1.0398995535714285e-05 1.5 1.0399553571428571e-05 0.0 1.0404017857142857e-05 0.0 1.0404575892857142e-05 1.5 1.0416852678571429e-05 1.5 1.0417410714285714e-05 0.0 1.0421875e-05 0.0 1.0422433035714284e-05 1.5 1.0434709821428571e-05 1.5 1.0435267857142856e-05 0.0 1.0439732142857142e-05 0.0 1.0440290178571428e-05 1.5 1.0452566964285713e-05 1.5 1.0453125e-05 0.0 1.0457589285714286e-05 0.0 1.045814732142857e-05 1.5 1.0470424107142857e-05 1.5 1.0470982142857142e-05 0.0 1.0475446428571428e-05 0.0 1.0476004464285713e-05 1.5 1.048828125e-05 1.5 1.0488839285714285e-05 0.0 1.049330357142857e-05 0.0 1.0493861607142857e-05 1.5 1.0506138392857142e-05 1.5 1.0506696428571429e-05 0.0 1.0511160714285714e-05 0.0 1.051171875e-05 1.5 1.0523995535714284e-05 1.5 1.0524553571428571e-05 0.0 1.0529017857142857e-05 0.0 1.0529575892857142e-05 1.5 1.0541852678571428e-05 1.5 1.0542410714285713e-05 0.0 1.0546874999999999e-05 0.0 1.0547433035714286e-05 1.5 1.055970982142857e-05 1.5 1.0560267857142856e-05 0.0 1.0564732142857143e-05 0.0 1.0565290178571428e-05 1.5 1.0577566964285713e-05 1.5 1.0578125e-05 0.0 1.0582589285714285e-05 0.0 1.058314732142857e-05 1.5 1.0595424107142857e-05 1.5 1.0595982142857142e-05 0.0 1.0600446428571428e-05 0.0 1.0601004464285714e-05 1.5 1.061328125e-05 1.5 1.0613839285714284e-05 0.0 1.061830357142857e-05 0.0 1.0618861607142857e-05 1.5 1.0631138392857142e-05 1.5 1.0631696428571428e-05 0.0 1.0636160714285714e-05 0.0 1.0636718749999999e-05 1.5 1.0648995535714286e-05 1.5 1.064955357142857e-05 0.0 1.0654017857142856e-05 0.0 1.0654575892857141e-05 1.5 1.0666852678571428e-05 1.5 1.0667410714285713e-05 0.0 1.0671874999999999e-05 0.0 1.0672433035714285e-05 1.5 1.068470982142857e-05 1.5 1.0685267857142857e-05 0.0 1.0689732142857143e-05 0.0 1.0690290178571428e-05 1.5 1.0702566964285714e-05 1.5 1.0703125e-05 0.0 1.0707589285714285e-05 0.0 1.070814732142857e-05 1.5 1.0720424107142857e-05 1.5 1.0720982142857142e-05 0.0 1.0725446428571427e-05 0.0 1.0726004464285714e-05 1.5 1.0738281249999999e-05 1.5 1.0738839285714286e-05 0.0 1.0743303571428571e-05 0.0 1.0743861607142856e-05 1.5 1.0756138392857143e-05 1.5 1.0756696428571428e-05 0.0 1.0761160714285714e-05 0.0 1.0761718749999999e-05 1.5 1.0773995535714285e-05 1.5 1.077455357142857e-05 0.0 1.0779017857142856e-05 0.0 1.0779575892857143e-05 1.5 1.0791852678571428e-05 1.5 1.0792410714285714e-05 0.0 1.0796875e-05 0.0 1.0797433035714285e-05 1.5 1.080970982142857e-05 1.5 1.0810267857142857e-05 0.0 1.0814732142857142e-05 0.0 1.0815290178571427e-05 1.5 1.0827566964285714e-05 1.5 1.0828124999999999e-05 0.0 1.0832589285714285e-05 0.0 1.0833147321428571e-05 1.5 1.0845424107142856e-05 1.5 1.0845982142857141e-05 0.0 1.0850446428571429e-05 0.0 1.0851004464285714e-05 1.5 1.0863281249999999e-05 1.5 1.0863839285714285e-05 0.0 1.086830357142857e-05 0.0 1.0868861607142856e-05 1.5 1.0881138392857143e-05 1.5 1.0881696428571428e-05 0.0 1.0886160714285713e-05 0.0 1.088671875e-05 1.5 1.0898995535714285e-05 1.5 1.089955357142857e-05 0.0 1.0904017857142857e-05 0.0 1.0904575892857142e-05 1.5 1.0916852678571427e-05 1.5 1.0917410714285714e-05 0.0 1.0921875e-05 0.0 1.0922433035714285e-05 1.5 1.0934709821428571e-05 1.5 1.0935267857142856e-05 0.0 1.0939732142857142e-05 0.0 1.0940290178571429e-05 1.5 1.0952566964285714e-05 1.5 1.0953124999999999e-05 0.0 1.0958147321428571e-05 0.0 1.0958705357142856e-05 1.5 1.096986607142857e-05 1.5 1.0970424107142856e-05 0.0 1.0976004464285713e-05 0.0 1.09765625e-05 1.5 1.0987723214285713e-05 1.5 1.098828125e-05 0.0 1.0993861607142856e-05 0.0 1.0994419642857142e-05 1.5 1.1005580357142857e-05 1.5 1.1006138392857142e-05 0.0 1.101171875e-05 0.0 1.1012276785714285e-05 1.5 1.10234375e-05 1.5 1.1023995535714284e-05 0.0 1.1029575892857142e-05 0.0 1.1030133928571427e-05 1.5 1.1041294642857142e-05 1.5 1.1041852678571429e-05 0.0 1.1047433035714284e-05 0.0 1.1047991071428571e-05 1.5 1.1059151785714284e-05 1.5 1.105970982142857e-05 0.0 1.1065290178571428e-05 0.0 1.1065848214285713e-05 1.5 1.1077008928571428e-05 1.5 1.1077566964285713e-05 0.0 1.108314732142857e-05 0.0 1.1083705357142856e-05 1.5 1.109486607142857e-05 1.5 1.1095424107142857e-05 0.0 1.1101004464285713e-05 0.0 1.11015625e-05 1.5 1.1112723214285713e-05 1.5 1.111328125e-05 0.0 1.1118861607142857e-05 0.0 1.1119419642857142e-05 1.5 1.1130580357142857e-05 1.5 1.1131138392857142e-05 0.0 1.113671875e-05 0.0 1.1137276785714284e-05 1.5 1.1148437499999999e-05 1.5 1.1148995535714284e-05 0.0 1.1154575892857142e-05 0.0 1.1155133928571428e-05 1.5 1.1166294642857141e-05 1.5 1.1166852678571428e-05 0.0 1.1172433035714286e-05 0.0 1.117299107142857e-05 1.5 1.1184151785714285e-05 1.5 1.118470982142857e-05 0.0 1.1190290178571428e-05 0.0 1.1190848214285713e-05 1.5 1.1202008928571428e-05 1.5 1.1202566964285713e-05 0.0 1.120814732142857e-05 0.0 1.1208705357142857e-05 1.5 1.121986607142857e-05 1.5 1.1220424107142857e-05 0.0 1.1226004464285714e-05 0.0 1.12265625e-05 1.5 1.1237723214285714e-05 1.5 1.123828125e-05 0.0 1.1243861607142857e-05 0.0 1.1244419642857142e-05 1.5 1.1255580357142856e-05 1.5 1.1256138392857141e-05 0.0 1.1261718749999999e-05 0.0 1.1262276785714286e-05 1.5 1.1273437499999999e-05 1.5 1.1273995535714285e-05 0.0 1.1279575892857143e-05 0.0 1.1280133928571428e-05 1.5 1.1291294642857143e-05 1.5 1.1291852678571428e-05 0.0 1.1297433035714285e-05 0.0 1.129799107142857e-05 1.5 1.1309151785714285e-05 1.5 1.130970982142857e-05 0.0 1.1315290178571428e-05 0.0 1.1315848214285714e-05 1.5 1.1327008928571427e-05 1.5 1.1327566964285714e-05 0.0 1.133314732142857e-05 0.0 1.1333705357142857e-05 1.5 1.1344866071428571e-05 1.5 1.1345424107142856e-05 0.0 1.1351004464285714e-05 0.0 1.1351562499999999e-05 1.5 1.1362723214285714e-05 1.5 1.1363281249999999e-05 0.0 1.1368861607142856e-05 0.0 1.1369419642857141e-05 1.5 1.1380022321428571e-05 1.5 1.1380580357142856e-05 0.0 1.1387276785714285e-05 0.0 1.138783482142857e-05 1.5 1.1397879464285713e-05 1.5 1.1398437499999998e-05 0.0 1.1405133928571428e-05 0.0 1.1405691964285713e-05 1.5 1.1415736607142856e-05 1.5 1.1416294642857142e-05 0.0 1.142299107142857e-05 0.0 1.1423549107142857e-05 1.5 1.143359375e-05 1.5 1.1434151785714285e-05 0.0 1.1440848214285714e-05 0.0 1.1441406249999999e-05 1.5 1.1451450892857142e-05 1.5 1.1452008928571427e-05 0.0 1.1458705357142856e-05 0.0 1.1459263392857141e-05 1.5 1.1469308035714284e-05 1.5 1.1469866071428571e-05 0.0 1.1476562499999999e-05 0.0 1.1477120535714285e-05 1.5 1.1487165178571428e-05 1.5 1.1487723214285713e-05 0.0 1.1494419642857143e-05 0.0 1.1494977678571428e-05 1.5 1.150502232142857e-05 1.5 1.1505580357142856e-05 0.0 1.1512276785714285e-05 0.0 1.151283482142857e-05 1.5 1.1522879464285713e-05 1.5 1.15234375e-05 0.0 1.1530133928571427e-05 0.0 1.1530691964285714e-05 1.5 1.1540736607142857e-05 1.5 1.1541294642857142e-05 0.0 1.1547991071428571e-05 0.0 1.1548549107142856e-05 1.5 1.155859375e-05 1.5 1.1559151785714284e-05 0.0 1.1565848214285714e-05 0.0 1.1566406249999999e-05 1.5 1.1576450892857142e-05 1.5 1.1577008928571428e-05 0.0 1.1583705357142856e-05 0.0 1.1584263392857143e-05 1.5 1.1594308035714286e-05 1.5 1.159486607142857e-05 0.0 1.16015625e-05 0.0 1.1602120535714285e-05 1.5 1.1612165178571428e-05 1.5 1.1612723214285713e-05 0.0 1.1619419642857142e-05 0.0 1.1619977678571427e-05 1.5 1.163002232142857e-05 1.5 1.1630580357142857e-05 0.0 1.1637276785714285e-05 0.0 1.1637834821428571e-05 1.5 1.1647879464285713e-05 1.5 1.16484375e-05 0.0 1.1655133928571427e-05 0.0 1.1655691964285714e-05 1.5 1.1665736607142857e-05 1.5 1.1666294642857142e-05 0.0 1.1672991071428571e-05 0.0 1.1673549107142856e-05 1.5 1.1683593749999999e-05 1.5 1.1684151785714286e-05 0.0 1.1690848214285713e-05 0.0 1.169140625e-05 1.5 1.1701450892857141e-05 1.5 1.1702008928571428e-05 0.0 1.1708705357142856e-05 0.0 1.1709263392857142e-05 1.5 1.1718749999999999e-05 1.5 1.1719308035714285e-05 0.0 1.1727120535714285e-05 0.0 1.1727678571428571e-05 1.5 1.1736607142857143e-05 1.5 1.1737165178571428e-05 0.0 1.1744977678571427e-05 0.0 1.1745535714285714e-05 1.5 1.1754464285714285e-05 1.5 1.175502232142857e-05 0.0 1.1762834821428571e-05 0.0 1.1763392857142856e-05 1.5 1.1772321428571427e-05 1.5 1.1772879464285714e-05 0.0 1.1780691964285713e-05 0.0 1.1781249999999998e-05 1.5 1.1790178571428571e-05 1.5 1.1790736607142856e-05 0.0 1.1798549107142856e-05 0.0 1.1799107142857142e-05 1.5 1.1808035714285714e-05 1.5 1.1808593749999999e-05 0.0 1.181640625e-05 0.0 1.1816964285714285e-05 1.5 1.1825892857142856e-05 1.5 1.1826450892857143e-05 0.0 1.1834263392857142e-05 0.0 1.1834821428571427e-05 1.5 1.184375e-05 1.5 1.1844308035714285e-05 0.0 1.1852120535714284e-05 0.0 1.1852678571428571e-05 1.5 1.1861607142857142e-05 1.5 1.1862165178571427e-05 0.0 1.1869977678571428e-05 0.0 1.1870535714285713e-05 1.5 1.1879464285714285e-05 1.5 1.1880022321428571e-05 0.0 1.188783482142857e-05 0.0 1.1888392857142856e-05 1.5 1.1897321428571429e-05 1.5 1.1897879464285714e-05 0.0 1.1905691964285713e-05 0.0 1.190625e-05 1.5 1.1915178571428571e-05 1.5 1.1915736607142856e-05 0.0 1.1923549107142857e-05 0.0 1.1924107142857142e-05 1.5 1.1933035714285713e-05 1.5 1.193359375e-05 0.0 1.194140625e-05 0.0 1.1941964285714284e-05 1.5 1.1950892857142856e-05 1.5 1.1951450892857142e-05 0.0 1.1959263392857142e-05 0.0 1.1959821428571428e-05 1.5 1.196875e-05 1.5 1.1969308035714285e-05 0.0 1.1977120535714286e-05 0.0 1.197767857142857e-05 1.5 1.1986607142857142e-05 1.5 1.1987165178571427e-05 0.0 1.1994977678571428e-05 0.0 1.1995535714285713e-05 1.5 1.2004464285714284e-05 1.5 1.2005022321428571e-05 0.0 1.201283482142857e-05 0.0 1.2013392857142857e-05 1.5 1.2022321428571428e-05 1.5 1.2022879464285713e-05 0.0 1.2030691964285713e-05 0.0 1.203125e-05 1.5 1.2039620535714285e-05 1.5 1.204017857142857e-05 0.0 1.2049107142857142e-05 0.0 1.2049665178571428e-05 1.5 1.2057477678571428e-05 1.5 1.2058035714285713e-05 0.0 1.2066964285714284e-05 0.0 1.206752232142857e-05 1.5 1.207533482142857e-05 1.5 1.2075892857142857e-05 0.0 1.2084821428571428e-05 0.0 1.2085379464285713e-05 1.5 1.2093191964285714e-05 1.5 1.209375e-05 0.0 1.210267857142857e-05 0.0 1.2103236607142857e-05 1.5 1.2111049107142856e-05 1.5 1.2111607142857142e-05 0.0 1.2120535714285713e-05 0.0 1.212109375e-05 1.5 1.2128906249999999e-05 1.5 1.2129464285714286e-05 0.0 1.2138392857142857e-05 0.0 1.2138950892857142e-05 1.5 1.2146763392857143e-05 1.5 1.2147321428571428e-05 0.0 1.2156249999999999e-05 0.0 1.2156808035714284e-05 1.5 1.2164620535714285e-05 1.5 1.216517857142857e-05 0.0 1.2174107142857141e-05 0.0 1.2174665178571428e-05 1.5 1.2182477678571427e-05 1.5 1.2183035714285714e-05 0.0 1.2191964285714285e-05 0.0 1.219252232142857e-05 1.5 1.220033482142857e-05 1.5 1.2200892857142857e-05 0.0 1.2209821428571428e-05 0.0 1.2210379464285713e-05 1.5 1.2218191964285714e-05 1.5 1.2218749999999999e-05 0.0 1.222767857142857e-05 0.0 1.2228236607142857e-05 1.5 1.2236049107142856e-05 1.5 1.2236607142857141e-05 0.0 1.2245535714285714e-05 0.0 1.2246093749999999e-05 1.5 1.2253906249999998e-05 1.5 1.2254464285714285e-05 0.0 1.2263392857142856e-05 0.0 1.2263950892857141e-05 1.5 1.2271763392857142e-05 1.5 1.2272321428571428e-05 0.0 1.2281249999999999e-05 0.0 1.2281808035714285e-05 1.5 1.2289620535714285e-05 1.5 1.229017857142857e-05 0.0 1.2299107142857143e-05 0.0 1.2299665178571428e-05 1.5 1.2307477678571427e-05 1.5 1.2308035714285714e-05 0.0 1.2316964285714285e-05 0.0 1.231752232142857e-05 1.5 1.2325334821428571e-05 1.5 1.2325892857142856e-05 0.0 1.2334821428571427e-05 0.0 1.2335379464285714e-05 1.5 1.2343191964285713e-05 1.5 1.2343749999999998e-05 0.0 1.2352678571428571e-05 0.0 1.2353236607142856e-05 1.5 1.2361049107142856e-05 1.5 1.2361607142857143e-05 0.0 1.2371093749999999e-05 0.0 1.2371651785714285e-05 1.5 1.2378348214285713e-05 1.5 1.237890625e-05 0.0 1.2388950892857143e-05 0.0 1.2389508928571428e-05 1.5 1.2396205357142857e-05 1.5 1.2396763392857142e-05 0.0 1.2406808035714285e-05 0.0 1.240736607142857e-05 1.5 1.24140625e-05 1.5 1.2414620535714284e-05 0.0 1.2424665178571427e-05 0.0 1.2425223214285714e-05 1.5 1.2431919642857142e-05 1.5 1.2432477678571428e-05 0.0 1.244252232142857e-05 0.0 1.2443080357142856e-05 1.5 1.2449776785714284e-05 1.5 1.245033482142857e-05 0.0 1.2460379464285714e-05 0.0 1.2460937499999999e-05 1.5 1.2467633928571428e-05 1.5 1.2468191964285713e-05 0.0 1.2478236607142856e-05 0.0 1.2478794642857141e-05 1.5 1.248549107142857e-05 1.5 1.2486049107142855e-05 0.0 1.2496093749999998e-05 0.0 1.2496651785714285e-05 1.5 1.2503348214285713e-05 1.5 1.250390625e-05 0.0 1.2513950892857142e-05 0.0 1.2514508928571427e-05 1.5 1.2521205357142857e-05 1.5 1.2521763392857142e-05 0.0 1.2531808035714285e-05 0.0 1.253236607142857e-05 1.5 1.2539062499999999e-05 1.5 1.2539620535714284e-05 0.0 1.2549665178571427e-05 0.0 1.2550223214285714e-05 1.5 1.2556919642857141e-05 1.5 1.2557477678571428e-05 0.0 1.2567522321428571e-05 0.0 1.2568080357142856e-05 1.5 1.2574776785714285e-05 1.5 1.257533482142857e-05 0.0 1.2585379464285713e-05 0.0 1.2585937499999998e-05 1.5 1.2592633928571428e-05 1.5 1.2593191964285713e-05 0.0 1.2603236607142856e-05 0.0 1.2603794642857142e-05 1.5 1.261049107142857e-05 1.5 1.2611049107142857e-05 0.0 1.262109375e-05 0.0 1.2621651785714285e-05 1.5 1.2628348214285714e-05 1.5 1.2628906249999999e-05 0.0 1.2638950892857142e-05 0.0 1.2639508928571427e-05 1.5 1.2646205357142856e-05 1.5 1.2646763392857141e-05 0.0 1.2656808035714284e-05 0.0 1.2657366071428571e-05 1.5 1.2664062499999999e-05 1.5 1.2664620535714285e-05 0.0 1.2674665178571428e-05 0.0 1.2675223214285713e-05 1.5 1.2681919642857143e-05 1.5 1.2682477678571428e-05 0.0 1.269252232142857e-05 0.0 1.2693080357142856e-05 1.5 1.2699776785714285e-05 1.5 1.270033482142857e-05 0.0 1.27109375e-05 0.0 1.2711495535714285e-05 1.5 1.2717075892857142e-05 1.5 1.2717633928571427e-05 0.0 1.2728794642857142e-05 0.0 1.2729352678571427e-05 1.5 1.2734933035714285e-05 1.5 1.2735491071428571e-05 0.0 1.2746651785714284e-05 0.0 1.2747209821428571e-05 1.5 1.2752790178571427e-05 1.5 1.2753348214285714e-05 0.0 1.2764508928571428e-05 0.0 1.2765066964285714e-05 1.5 1.2770647321428571e-05 1.5 1.2771205357142856e-05 0.0 1.278236607142857e-05 0.0 1.2782924107142856e-05 1.5 1.2788504464285713e-05 1.5 1.2789062499999998e-05 0.0 1.2800223214285713e-05 0.0 1.280078125e-05 1.5 1.2806361607142856e-05 1.5 1.2806919642857142e-05 0.0 1.2818080357142855e-05 0.0 1.2818638392857142e-05 1.5 1.282421875e-05 1.5 1.2824776785714285e-05 0.0 1.28359375e-05 0.0 1.2836495535714285e-05 1.5 1.2842075892857142e-05 1.5 1.2842633928571427e-05 0.0 1.2853794642857142e-05 0.0 1.2854352678571427e-05 1.5 1.2859933035714284e-05 1.5 1.2860491071428571e-05 0.0 1.2871651785714284e-05 0.0 1.2872209821428571e-05 1.5 1.2877790178571428e-05 1.5 1.2878348214285713e-05 0.0 1.2889508928571428e-05 0.0 1.2890066964285713e-05 1.5 1.289564732142857e-05 1.5 1.2896205357142856e-05 0.0 1.290736607142857e-05 0.0 1.2907924107142855e-05 1.5 1.2913504464285713e-05 1.5 1.29140625e-05 0.0 1.2925223214285713e-05 0.0 1.292578125e-05 1.5 1.2931361607142857e-05 1.5 1.2931919642857142e-05 0.0 1.2943080357142857e-05 0.0 1.2943638392857142e-05 1.5 1.294921875e-05 1.5 1.2949776785714284e-05 0.0 1.2960937499999999e-05 0.0 1.2961495535714284e-05 1.5 1.2967075892857142e-05 1.5 1.2967633928571428e-05 0.0 1.2978794642857141e-05 0.0 1.2979352678571428e-05 1.5 1.2984933035714286e-05 1.5 1.298549107142857e-05 0.0 1.2996651785714285e-05 0.0 1.299720982142857e-05 1.5 1.3002790178571428e-05 1.5 1.3003348214285713e-05 0.0 1.3014508928571428e-05 0.0 1.3015066964285713e-05 1.5 1.302064732142857e-05 1.5 1.3021205357142857e-05 0.0 1.303236607142857e-05 0.0 1.3032924107142857e-05 1.5 1.3038504464285713e-05 1.5 1.30390625e-05 0.0 1.3050223214285714e-05 0.0 1.305078125e-05 1.5 1.3056361607142857e-05 1.5 1.3056919642857142e-05 0.0 1.3068080357142856e-05 0.0 1.3068638392857141e-05 1.5 1.3074218749999999e-05 1.5 1.3074776785714284e-05 0.0 1.3085937499999999e-05 0.0 1.3086495535714286e-05 1.5 1.3092075892857141e-05 1.5 1.3092633928571428e-05 0.0 1.3103794642857141e-05 0.0 1.3104352678571428e-05 1.5 1.3109933035714285e-05 1.5 1.311049107142857e-05 0.0 1.312220982142857e-05 0.0 1.3122767857142857e-05 1.5 1.3127232142857142e-05 1.5 1.3127790178571428e-05 0.0 1.3140066964285714e-05 0.0 1.3140625e-05 1.5 1.3145089285714285e-05 1.5 1.314564732142857e-05 0.0 1.3157924107142856e-05 0.0 1.3158482142857142e-05 1.5 1.3162946428571427e-05 1.5 1.3163504464285714e-05 0.0 1.3175781249999999e-05 0.0 1.3176339285714286e-05 1.5 1.3180803571428571e-05 1.5 1.3181361607142856e-05 0.0 1.3193638392857141e-05 0.0 1.3194196428571428e-05 1.5 1.3198660714285713e-05 1.5 1.3199218749999999e-05 0.0 1.3211495535714285e-05 0.0 1.321205357142857e-05 1.5 1.3216517857142856e-05 1.5 1.3217075892857143e-05 0.0 1.3229352678571427e-05 0.0 1.3229910714285713e-05 1.5 1.3234375e-05 1.5 1.3234933035714285e-05 0.0 1.324720982142857e-05 0.0 1.3247767857142857e-05 1.5 1.3252232142857142e-05 1.5 1.3252790178571427e-05 0.0 1.3265066964285714e-05 0.0 1.3265624999999999e-05 1.5 1.3270089285714284e-05 1.5 1.3270647321428571e-05 0.0 1.3282924107142856e-05 0.0 1.3283482142857141e-05 1.5 1.3287946428571427e-05 1.5 1.3288504464285714e-05 0.0 1.3300781249999998e-05 0.0 1.3301339285714285e-05 1.5 1.330580357142857e-05 1.5 1.3306361607142856e-05 0.0 1.3318638392857142e-05 0.0 1.3319196428571428e-05 1.5 1.3323660714285713e-05 1.5 1.332421875e-05 0.0 1.3336495535714285e-05 0.0 1.333705357142857e-05 1.5 1.3341517857142855e-05 1.5 1.3342075892857142e-05 0.0 1.3354352678571427e-05 0.0 1.3354910714285714e-05 1.5 1.3359375e-05 1.5 1.3359933035714285e-05 0.0 1.3372209821428571e-05 0.0 1.3372767857142856e-05 1.5 1.3377232142857142e-05 1.5 1.3377790178571427e-05 0.0 1.3390066964285713e-05 0.0 1.3390624999999999e-05 1.5 1.3395089285714284e-05 1.5 1.3395647321428571e-05 0.0 1.3407924107142856e-05 0.0 1.3408482142857143e-05 1.5 1.3412946428571428e-05 1.5 1.3413504464285713e-05 0.0 1.342578125e-05 0.0 1.3426339285714285e-05 1.5 1.343080357142857e-05 1.5 1.3431361607142856e-05 0.0 1.3443638392857142e-05 0.0 1.3444196428571427e-05 1.5 1.3448660714285713e-05 1.5 1.344921875e-05 0.0 1.3461495535714284e-05 0.0 1.3462053571428571e-05 1.5 1.3466517857142857e-05 1.5 1.3467075892857142e-05 0.0 1.3479352678571427e-05 0.0 1.3479910714285714e-05 1.5 1.3484374999999999e-05 1.5 1.3484933035714284e-05 0.0 1.349720982142857e-05 0.0 1.3497767857142856e-05 1.5 1.3502232142857141e-05 1.5 1.3502790178571428e-05 0.0 1.3515066964285713e-05 0.0 1.3515625e-05 1.5 1.3520089285714285e-05 1.5 1.352064732142857e-05 0.0 1.3532924107142855e-05 0.0 1.3533482142857142e-05 1.5 1.3537946428571428e-05 1.5 1.3538504464285713e-05 0.0 1.355078125e-05 0.0 1.3551339285714285e-05 1.5 1.355580357142857e-05 1.5 1.3556361607142857e-05 0.0 1.3568638392857142e-05 0.0 1.3569196428571427e-05 1.5 1.3573660714285714e-05 1.5 1.357421875e-05 0.0 1.3586495535714284e-05 0.0 1.3587053571428571e-05 1.5 1.3591517857142856e-05 1.5 1.3592075892857142e-05 0.0 1.3604352678571428e-05 0.0 1.3604910714285713e-05 1.5 1.3609374999999999e-05 1.5 1.3609933035714286e-05 0.0 1.362220982142857e-05 0.0 1.3622767857142856e-05 1.5 1.3627232142857141e-05 1.5 1.3627790178571428e-05 0.0 1.3640066964285713e-05 0.0 1.3640625e-05 1.5 1.3645089285714285e-05 1.5 1.364564732142857e-05 0.0 1.3657924107142857e-05 0.0 1.3658482142857142e-05 1.5 1.3662946428571427e-05 1.5 1.3663504464285712e-05 0.0 1.3675781249999999e-05 0.0 1.3676339285714284e-05 1.5 1.368080357142857e-05 1.5 1.3681361607142857e-05 0.0 1.3693638392857141e-05 0.0 1.3694196428571428e-05 1.5 1.3698660714285714e-05 1.5 1.3699218749999999e-05 0.0 1.3711495535714285e-05 0.0 1.371205357142857e-05 1.5 1.3716517857142856e-05 1.5 1.3717075892857141e-05 0.0 1.3729352678571428e-05 0.0 1.3729910714285713e-05 1.5 1.3734374999999998e-05 1.5 1.3734933035714285e-05 0.0 1.374720982142857e-05 0.0 1.3747767857142857e-05 1.5 1.3752232142857142e-05 1.5 1.3752790178571427e-05 0.0 1.3765066964285714e-05 0.0 1.3765625e-05 1.5 1.3770089285714285e-05 1.5 1.377064732142857e-05 0.0 1.3782924107142856e-05 0.0 1.3783482142857141e-05 1.5 1.3787946428571427e-05 1.5 1.3788504464285714e-05 0.0 1.3800781249999999e-05 0.0 1.3801339285714286e-05 1.5 1.3805803571428571e-05 1.5 1.3806361607142856e-05 0.0 1.3818638392857141e-05 0.0 1.3819196428571428e-05 1.5 1.3823660714285713e-05 1.5 1.3824218749999998e-05 0.0 1.3836495535714285e-05 0.0 1.383705357142857e-05 1.5 1.3841517857142856e-05 1.5 1.3842075892857142e-05 0.0 1.3854352678571427e-05 0.0 1.3854910714285712e-05 1.5 1.3859375e-05 1.5 1.3859933035714285e-05 0.0 1.387220982142857e-05 0.0 1.3872767857142857e-05 1.5 1.3877232142857142e-05 1.5 1.3877790178571427e-05 0.0 1.3890066964285714e-05 0.0 1.3890624999999999e-05 1.5 1.3895089285714284e-05 1.5 1.3895647321428571e-05 0.0 1.3907924107142856e-05 0.0 1.3908482142857141e-05 1.5 1.3912946428571427e-05 1.5 1.3913504464285713e-05 0.0 1.3925781249999998e-05 0.0 1.3926339285714285e-05 1.5 1.393080357142857e-05 1.5 1.3931361607142856e-05 0.0 1.3943638392857142e-05 0.0 1.3944196428571427e-05 1.5 1.3948660714285713e-05 1.5 1.394921875e-05 0.0 1.3961495535714285e-05 0.0 1.396205357142857e-05 1.5 1.3966517857142855e-05 1.5 1.3967075892857142e-05 0.0 1.3979352678571427e-05 0.0 1.3979910714285714e-05 1.5 1.3984375e-05 1.5 1.3984933035714284e-05 0.0 1.3997209821428571e-05 0.0 1.3997767857142856e-05 1.5 1.4002232142857142e-05 1.5 1.4002790178571427e-05 0.0 1.4015066964285713e-05 0.0 1.4015624999999998e-05 1.5 1.4020089285714284e-05 1.5 1.402064732142857e-05 0.0 1.4032924107142856e-05 0.0 1.4033482142857142e-05 1.5 1.4037946428571428e-05 1.5 1.4038504464285713e-05 0.0 1.405078125e-05 0.0 1.4051339285714285e-05 1.5 1.405580357142857e-05 1.5 1.4056361607142855e-05 0.0 1.4068638392857142e-05 0.0 1.4069196428571427e-05 1.5 1.4073660714285713e-05 1.5 1.407421875e-05 0.0 1.4086495535714284e-05 0.0 1.4087053571428571e-05 1.5 1.4091517857142857e-05 1.5 1.4092075892857142e-05 0.0 1.4104352678571427e-05 0.0 1.4104910714285713e-05 1.5 1.4109374999999999e-05 1.5 1.4109933035714284e-05 0.0 1.412220982142857e-05 0.0 1.4122767857142856e-05 1.5 1.4127232142857141e-05 1.5 1.4127790178571428e-05 0.0 1.4140066964285713e-05 0.0 1.4140625e-05 1.5 1.4145089285714285e-05 1.5 1.414564732142857e-05 0.0 1.4157924107142855e-05 0.0 1.4158482142857142e-05 1.5 1.4162946428571428e-05 1.5 1.4163504464285713e-05 0.0 1.417578125e-05 0.0 1.4176339285714284e-05 1.5 1.418080357142857e-05 1.5 1.4181361607142857e-05 0.0 1.4193638392857142e-05 0.0 1.4194196428571427e-05 1.5 1.4198660714285714e-05 1.5 1.4199218749999999e-05 0.0 1.4211495535714284e-05 0.0 1.421205357142857e-05 1.5 1.4216517857142856e-05 1.5 1.4217075892857141e-05 0.0 1.4229352678571428e-05 0.0 1.4229910714285713e-05 1.5 1.4234374999999999e-05 1.5 1.4234933035714285e-05 0.0 1.424720982142857e-05 0.0 1.4247767857142855e-05 1.5 1.4252232142857141e-05 1.5 1.4252790178571428e-05 0.0 1.4265066964285713e-05 0.0 1.4265625e-05 1.5 1.4270089285714285e-05 1.5 1.427064732142857e-05 0.0 1.4282924107142857e-05 0.0 1.4283482142857142e-05 1.5 1.4287946428571427e-05 1.5 1.4288504464285712e-05 0.0 1.4300781249999999e-05 0.0 1.4301339285714284e-05 1.5 1.430580357142857e-05 1.5 1.4306361607142856e-05 0.0 1.4318638392857141e-05 0.0 1.4319196428571428e-05 1.5 1.4323660714285714e-05 1.5 1.4324218749999999e-05 0.0 1.4336495535714285e-05 0.0 1.433705357142857e-05 1.5 1.4341517857142856e-05 1.5 1.4342075892857141e-05 0.0 1.4354352678571428e-05 0.0 1.4354910714285713e-05 1.5 1.4359374999999998e-05 1.5 1.4359933035714285e-05 0.0 1.437220982142857e-05 0.0 1.4372767857142857e-05 1.5 1.4377232142857142e-05 1.5 1.4377790178571427e-05 0.0 1.4390066964285714e-05 0.0 1.4390624999999999e-05 1.5 1.4395089285714285e-05 1.5 1.439564732142857e-05 0.0 1.4407924107142856e-05 0.0 1.4408482142857141e-05 1.5 1.4412946428571427e-05 1.5 1.4413504464285714e-05 0.0 1.4425781249999999e-05 0.0 1.4426339285714285e-05 1.5 1.4430803571428571e-05 1.5 1.4431361607142856e-05 0.0 1.4443638392857141e-05 0.0 1.4444196428571428e-05 1.5 1.4448660714285713e-05 1.5 1.4449218749999998e-05 0.0 1.4461495535714285e-05 0.0 1.446205357142857e-05 1.5 1.4466517857142856e-05 1.5 1.4467075892857142e-05 0.0 1.4479352678571427e-05 0.0 1.4479910714285712e-05 1.5 1.4484375e-05 1.5 1.4484933035714285e-05 0.0 1.449720982142857e-05 0.0 1.4497767857142856e-05 1.5 1.4502232142857142e-05 1.5 1.4502790178571427e-05 0.0 1.4515066964285714e-05 0.0 1.4515624999999999e-05 1.5 1.4520089285714284e-05 1.5 1.4520647321428571e-05 0.0 1.4532924107142856e-05 0.0 1.4533482142857141e-05 1.5 1.4537946428571428e-05 1.5 1.4538504464285713e-05 0.0 1.4550781249999998e-05 0.0 1.4551339285714285e-05 1.5 1.455580357142857e-05 1.5 1.4556361607142856e-05 0.0 1.4568638392857142e-05 0.0 1.4569196428571427e-05 1.5 1.4573660714285713e-05 1.5 1.457421875e-05 0.0 1.4586495535714285e-05 0.0 1.458705357142857e-05 1.5 1.4591517857142855e-05 1.5 1.4592075892857142e-05 0.0 1.4604352678571427e-05 0.0 1.4604910714285714e-05 1.5 1.4609375e-05 1.5 1.4609933035714284e-05 0.0 1.4622209821428571e-05 0.0 1.4622767857142856e-05 1.5 1.4627232142857142e-05 1.5 1.4627790178571427e-05 0.0 1.4640066964285713e-05 0.0 1.4640624999999998e-05 1.5 1.4645089285714284e-05 1.5 1.464564732142857e-05 0.0 1.4657924107142856e-05 0.0 1.4658482142857142e-05 1.5 1.4662946428571428e-05 1.5 1.4663504464285713e-05 0.0 1.467578125e-05 0.0 1.4676339285714285e-05 1.5 1.468080357142857e-05 1.5 1.4681361607142855e-05 0.0 1.4693638392857142e-05 0.0 1.4694196428571427e-05 1.5 1.4698660714285713e-05 1.5 1.469921875e-05 0.0 1.4711495535714284e-05 0.0 1.4712053571428571e-05 1.5 1.4716517857142857e-05 1.5 1.4717075892857142e-05 0.0 1.4729352678571427e-05 0.0 1.4729910714285713e-05 1.5 1.4734374999999999e-05 1.5 1.4734933035714284e-05 0.0 1.474720982142857e-05 0.0 1.4747767857142856e-05 1.5 1.4752232142857141e-05 1.5 1.4752790178571428e-05 0.0 1.4765066964285713e-05 0.0 1.4765625e-05 1.5 1.4770089285714285e-05 1.5 1.477064732142857e-05 0.0 1.4782924107142855e-05 0.0 1.4783482142857142e-05 1.5 1.4787946428571428e-05 1.5 1.4788504464285713e-05 0.0 1.480078125e-05 0.0 1.4801339285714284e-05 1.5 1.480580357142857e-05 1.5 1.4806361607142857e-05 0.0 1.4818638392857142e-05 0.0 1.4819196428571427e-05 1.5 1.4823660714285714e-05 1.5 1.4824218749999999e-05 0.0 1.4836495535714284e-05 0.0 1.483705357142857e-05 1.5 1.4841517857142856e-05 1.5 1.4842075892857141e-05 0.0 1.4854352678571428e-05 0.0 1.4854910714285713e-05 1.5 1.4859374999999999e-05 1.5 1.4859933035714285e-05 0.0 1.487220982142857e-05 0.0 1.4872767857142855e-05 1.5 1.4877232142857141e-05 1.5 1.4877790178571428e-05 0.0 1.4890066964285713e-05 0.0 1.4890625e-05 1.5 1.4895089285714285e-05 1.5 1.489564732142857e-05 0.0 1.4907924107142857e-05 0.0 1.4908482142857142e-05 1.5 1.4912946428571427e-05 1.5 1.4913504464285712e-05 0.0 1.4925781249999999e-05 0.0 1.4926339285714284e-05 1.5 1.493080357142857e-05 1.5 1.4931361607142856e-05 0.0 1.4943638392857141e-05 0.0 1.4944196428571428e-05 1.5 1.4948660714285714e-05 1.5 1.4949218749999999e-05 0.0 1.4961495535714285e-05 0.0 1.496205357142857e-05 1.5 1.4966517857142856e-05 1.5 1.4967075892857141e-05 0.0 1.4978794642857143e-05 0.0 1.4979352678571428e-05 1.5 1.4984933035714285e-05 1.5 1.498549107142857e-05 0.0 1.4996651785714285e-05 0.0 1.499720982142857e-05 1.5 1.5002790178571427e-05 1.5 1.5003348214285712e-05 0.0 1.5014508928571427e-05 0.0 1.5015066964285714e-05 1.5 1.502064732142857e-05 1.5 1.5021205357142856e-05 0.0 1.503236607142857e-05 0.0 1.5032924107142856e-05 1.5 1.5038504464285714e-05 1.5 1.5039062499999999e-05 0.0 1.5050223214285714e-05 0.0 1.5050781249999999e-05 1.5 1.5056361607142856e-05 1.5 1.5056919642857141e-05 0.0 1.5068080357142856e-05 0.0 1.5068638392857141e-05 1.5 1.5074218749999998e-05 1.5 1.5074776785714285e-05 0.0 1.5085937499999998e-05 0.0 1.5086495535714285e-05 1.5 1.5092075892857142e-05 1.5 1.5092633928571427e-05 0.0 1.5103794642857142e-05 0.0 1.5104352678571427e-05 1.5 1.5109933035714285e-05 1.5 1.511049107142857e-05 0.0 1.5121651785714285e-05 0.0 1.512220982142857e-05 1.5 1.5127790178571427e-05 1.5 1.5128348214285714e-05 0.0 1.5139508928571427e-05 0.0 1.5140066964285714e-05 1.5 1.5145647321428571e-05 1.5 1.5146205357142856e-05 0.0 1.5157366071428571e-05 0.0 1.5157924107142856e-05 1.5 1.5163504464285713e-05 1.5 1.5164062499999998e-05 0.0 1.5175223214285713e-05 0.0 1.5175781249999998e-05 1.5 1.5181361607142856e-05 1.5 1.5181919642857142e-05 0.0 1.5193080357142856e-05 0.0 1.5193638392857142e-05 1.5 1.519921875e-05 1.5 1.5199776785714285e-05 0.0 1.52109375e-05 0.0 1.5211495535714285e-05 1.5 1.5217075892857142e-05 1.5 1.5217633928571427e-05 0.0 1.5228794642857142e-05 0.0 1.5229352678571427e-05 1.5 1.5234933035714284e-05 1.5 1.5235491071428571e-05 0.0 1.5246651785714284e-05 0.0 1.5247209821428571e-05 1.5 1.5252790178571427e-05 1.5 1.5253348214285713e-05 0.0 1.5264508928571427e-05 0.0 1.5265066964285713e-05 1.5 1.527064732142857e-05 1.5 1.5271205357142857e-05 0.0 1.528236607142857e-05 0.0 1.5282924107142856e-05 1.5 1.5288504464285713e-05 1.5 1.52890625e-05 0.0 1.5300223214285715e-05 0.0 1.5300781249999998e-05 1.5 1.5306361607142855e-05 1.5 1.5306919642857142e-05 0.0 1.5318080357142857e-05 0.0 1.531863839285714e-05 1.5 1.5324218749999998e-05 1.5 1.5324776785714284e-05 0.0 1.53359375e-05 0.0 1.5336495535714286e-05 1.5 1.5342075892857143e-05 1.5 1.5342633928571427e-05 0.0 1.535379464285714e-05 0.0 1.535435267857143e-05 1.5 1.5359933035714286e-05 1.5 1.536049107142857e-05 0.0 1.5371651785714284e-05 0.0 1.537220982142857e-05 1.5 1.5377790178571428e-05 1.5 1.5378348214285715e-05 0.0 1.5388950892857143e-05 0.0 1.5389508928571426e-05 1.5 1.5396205357142857e-05 1.5 1.539676339285714e-05 0.0 1.5406808035714285e-05 0.0 1.5407366071428572e-05 1.5 1.54140625e-05 1.5 1.5414620535714286e-05 0.0 1.5424665178571427e-05 0.0 1.5425223214285714e-05 1.5 1.5431919642857142e-05 1.5 1.543247767857143e-05 0.0 1.544252232142857e-05 0.0 1.5443080357142857e-05 1.5 1.5449776785714284e-05 1.5 1.545033482142857e-05 0.0 1.5460379464285712e-05 0.0 1.54609375e-05 1.5 1.5467633928571426e-05 1.5 1.5468191964285713e-05 0.0 1.5478236607142854e-05 0.0 1.547879464285714e-05 1.5 1.548549107142857e-05 1.5 1.5486049107142855e-05 0.0 1.549609375e-05 0.0 1.5496651785714284e-05 1.5 1.5503348214285714e-05 1.5 1.5503906249999998e-05 0.0 1.5513950892857142e-05 0.0 1.5514508928571426e-05 1.5 1.5521205357142857e-05 1.5 1.552176339285714e-05 0.0 1.5531808035714285e-05 0.0 1.553236607142857e-05 1.5 1.55390625e-05 1.5 1.5539620535714286e-05 0.0 1.5549665178571427e-05 0.0 1.5550223214285714e-05 1.5 1.555691964285714e-05 1.5 1.5557477678571428e-05 0.0 1.556752232142857e-05 0.0 1.5568080357142856e-05 1.5 1.5574776785714284e-05 1.5 1.557533482142857e-05 0.0 1.5585379464285712e-05 0.0 1.55859375e-05 1.5 1.5592633928571426e-05 1.5 1.5593191964285713e-05 0.0 1.5603236607142857e-05 0.0 1.560379464285714e-05 1.5 1.5610491071428572e-05 1.5 1.5611049107142855e-05 0.0 1.562109375e-05 0.0 1.5621651785714283e-05 1.5 1.5628348214285714e-05 1.5 1.5628906249999997e-05 0.0 1.5638950892857142e-05 0.0 1.563950892857143e-05 1.5 1.5646205357142856e-05 1.5 1.5646763392857143e-05 0.0 1.5656808035714284e-05 0.0 1.565736607142857e-05 1.5 1.56640625e-05 1.5 1.5664620535714285e-05 0.0 1.5674665178571427e-05 0.0 1.5675223214285714e-05 1.5 1.568191964285714e-05 1.5 1.5682477678571428e-05 0.0 1.569252232142857e-05 0.0 1.5693080357142856e-05 1.5 1.5699776785714283e-05 1.5 1.570033482142857e-05 0.0 1.5710379464285715e-05 0.0 1.5710937499999998e-05 1.5 1.571763392857143e-05 1.5 1.5718191964285712e-05 0.0 1.5728236607142857e-05 0.0 1.572879464285714e-05 1.5 1.5736049107142855e-05 1.5 1.573660714285714e-05 0.0 1.5745535714285713e-05 0.0 1.574609375e-05 1.5 1.575390625e-05 1.5 1.5754464285714284e-05 0.0 1.5763392857142855e-05 0.0 1.5763950892857142e-05 1.5 1.5771763392857143e-05 1.5 1.5772321428571426e-05 0.0 1.5781249999999997e-05 0.0 1.5781808035714284e-05 1.5 1.5789620535714285e-05 1.5 1.5790178571428572e-05 0.0 1.5799107142857143e-05 0.0 1.5799665178571426e-05 1.5 1.5807477678571427e-05 1.5 1.5808035714285714e-05 0.0 1.5816964285714285e-05 0.0 1.581752232142857e-05 1.5 1.582533482142857e-05 1.5 1.5825892857142857e-05 0.0 1.5834821428571428e-05 0.0 1.5835379464285714e-05 1.5 1.5843191964285712e-05 1.5 1.584375e-05 0.0 1.585267857142857e-05 0.0 1.5853236607142857e-05 1.5 1.5861049107142854e-05 1.5 1.586160714285714e-05 0.0 1.5870535714285712e-05 0.0 1.587109375e-05 1.5 1.587890625e-05 1.5 1.5879464285714284e-05 0.0 1.5888392857142855e-05 0.0 1.588895089285714e-05 1.5 1.5896763392857142e-05 1.5 1.5897321428571426e-05 0.0 1.590625e-05 0.0 1.5906808035714284e-05 1.5 1.5914620535714285e-05 1.5 1.591517857142857e-05 0.0 1.5924107142857143e-05 0.0 1.5924665178571426e-05 1.5 1.5932477678571427e-05 1.5 1.5933035714285714e-05 0.0 1.5941964285714285e-05 0.0 1.5942522321428572e-05 1.5 1.595033482142857e-05 1.5 1.5950892857142856e-05 0.0 1.5959821428571427e-05 0.0 1.5960379464285714e-05 1.5 1.5968191964285712e-05 1.5 1.596875e-05 0.0 1.597767857142857e-05 0.0 1.5978236607142856e-05 1.5 1.5986049107142857e-05 1.5 1.598660714285714e-05 0.0 1.5995535714285712e-05 0.0 1.599609375e-05 1.5 1.600390625e-05 1.5 1.6004464285714283e-05 0.0 1.6013392857142854e-05 0.0 1.601395089285714e-05 1.5 1.6021763392857142e-05 1.5 1.602232142857143e-05 0.0 1.603125e-05 0.0 1.6031808035714283e-05 1.5 1.6039620535714284e-05 1.5 1.604017857142857e-05 0.0 1.6049107142857142e-05 0.0 1.6049665178571426e-05 1.5 1.6058035714285714e-05 1.5 1.605859375e-05 0.0 1.6066406249999998e-05 0.0 1.6066964285714285e-05 1.5 1.6075892857142856e-05 1.5 1.6076450892857143e-05 0.0 1.608426339285714e-05 0.0 1.6084821428571427e-05 1.5 1.6093749999999998e-05 1.5 1.6094308035714285e-05 0.0 1.6102120535714286e-05 0.0 1.610267857142857e-05 1.5 1.611160714285714e-05 1.5 1.6112165178571427e-05 0.0 1.6119977678571428e-05 0.0 1.612053571428571e-05 1.5 1.6129464285714286e-05 1.5 1.613002232142857e-05 0.0 1.613783482142857e-05 0.0 1.6138392857142857e-05 1.5 1.614732142857143e-05 1.5 1.6147879464285712e-05 0.0 1.6155691964285713e-05 0.0 1.615625e-05 1.5 1.616517857142857e-05 1.5 1.6165736607142858e-05 0.0 1.6173549107142855e-05 0.0 1.6174107142857142e-05 1.5 1.6183035714285713e-05 1.5 1.618359375e-05 0.0 1.6191406249999998e-05 0.0 1.6191964285714284e-05 1.5 1.6200892857142855e-05 1.5 1.6201450892857142e-05 0.0 1.6209263392857143e-05 0.0 1.6209821428571427e-05 1.5 1.6218749999999998e-05 1.5 1.6219308035714285e-05 0.0 1.6227120535714286e-05 0.0 1.622767857142857e-05 1.5 1.623660714285714e-05 1.5 1.6237165178571427e-05 0.0 1.6244977678571428e-05 0.0 1.6245535714285715e-05 1.5 1.6254464285714286e-05 1.5 1.625502232142857e-05 0.0 1.626283482142857e-05 0.0 1.6263392857142857e-05 1.5 1.6272321428571428e-05 1.5 1.627287946428571e-05 0.0 1.6280691964285713e-05 0.0 1.628125e-05 1.5 1.629017857142857e-05 1.5 1.6290736607142857e-05 0.0 1.6298549107142855e-05 0.0 1.629910714285714e-05 1.5 1.6308035714285713e-05 1.5 1.630859375e-05 0.0 1.6316406249999997e-05 0.0 1.6316964285714284e-05 1.5 1.6325892857142855e-05 1.5 1.6326450892857142e-05 0.0 1.6334263392857143e-05 0.0 1.6334821428571426e-05 1.5 1.6343749999999997e-05 1.5 1.6344308035714284e-05 0.0 1.6352120535714285e-05 0.0 1.635267857142857e-05 1.5 1.6361607142857143e-05 1.5 1.6362165178571427e-05 0.0 1.6369977678571428e-05 0.0 1.6370535714285714e-05 1.5 1.638002232142857e-05 1.5 1.6380580357142856e-05 0.0 1.6387276785714283e-05 0.0 1.638783482142857e-05 1.5 1.6397879464285715e-05 1.5 1.6398437499999998e-05 0.0 1.640513392857143e-05 0.0 1.6405691964285712e-05 1.5 1.6415736607142857e-05 1.5 1.641629464285714e-05 0.0 1.642299107142857e-05 0.0 1.6423549107142855e-05 1.5 1.643359375e-05 1.5 1.6434151785714286e-05 0.0 1.6440848214285714e-05 0.0 1.644140625e-05 1.5 1.645145089285714e-05 1.5 1.645200892857143e-05 0.0 1.6458705357142856e-05 0.0 1.6459263392857143e-05 1.5 1.6469308035714284e-05 1.5 1.646986607142857e-05 0.0 1.6476562499999998e-05 0.0 1.6477120535714285e-05 1.5 1.6487165178571426e-05 1.5 1.6487723214285713e-05 0.0 1.649441964285714e-05 0.0 1.6494977678571427e-05 1.5 1.6505022321428572e-05 1.5 1.6505580357142855e-05 0.0 1.6512276785714286e-05 0.0 1.651283482142857e-05 1.5 1.6522879464285714e-05 1.5 1.6523437499999998e-05 0.0 1.653013392857143e-05 0.0 1.6530691964285712e-05 1.5 1.6540736607142857e-05 1.5 1.6541294642857143e-05 0.0 1.654799107142857e-05 0.0 1.6548549107142858e-05 1.5 1.655859375e-05 1.5 1.6559151785714286e-05 0.0 1.6565848214285713e-05 0.0 1.656640625e-05 1.5 1.657645089285714e-05 1.5 1.6577008928571428e-05 0.0 1.6583705357142855e-05 0.0 1.6584263392857142e-05 1.5 1.6594308035714284e-05 1.5 1.659486607142857e-05 0.0 1.6601562499999998e-05 0.0 1.6602120535714285e-05 1.5 1.6612165178571426e-05 1.5 1.6612723214285713e-05 0.0 1.661941964285714e-05 0.0 1.6619977678571427e-05 1.5 1.663002232142857e-05 1.5 1.6630580357142855e-05 0.0 1.6637276785714286e-05 0.0 1.663783482142857e-05 1.5 1.6647879464285714e-05 1.5 1.6648437499999997e-05 0.0 1.6655133928571428e-05 0.0 1.665569196428571e-05 1.5 1.6665736607142856e-05 1.5 1.6666294642857143e-05 0.0 1.667299107142857e-05 0.0 1.6673549107142857e-05 1.5 1.668359375e-05 1.5 1.6684151785714285e-05 0.0 1.6690848214285713e-05 0.0 1.669140625e-05 1.5 1.670145089285714e-05 1.5 1.6702008928571428e-05 0.0 1.6708705357142855e-05 0.0 1.6709263392857142e-05 1.5 1.6719308035714283e-05 1.5 1.671986607142857e-05 0.0 1.6726004464285714e-05 0.0 1.6726562499999997e-05 1.5 1.6737723214285712e-05 1.5 1.673828125e-05 0.0 1.6743861607142856e-05 0.0 1.6744419642857143e-05 1.5 1.6755580357142855e-05 1.5 1.675613839285714e-05 0.0 1.676171875e-05 0.0 1.6762276785714285e-05 1.5 1.67734375e-05 1.5 1.6773995535714284e-05 0.0 1.677957589285714e-05 0.0 1.6780133928571428e-05 1.5 1.6791294642857143e-05 1.5 1.6791852678571426e-05 0.0 1.6797433035714283e-05 0.0 1.679799107142857e-05 1.5 1.6809151785714285e-05 1.5 1.680970982142857e-05 0.0 1.6815290178571426e-05 0.0 1.6815848214285712e-05 1.5 1.6827008928571427e-05 1.5 1.6827566964285714e-05 0.0 1.683314732142857e-05 0.0 1.6833705357142855e-05 1.5 1.684486607142857e-05 1.5 1.6845424107142856e-05 0.0 1.6851004464285714e-05 0.0 1.6851562499999997e-05 1.5 1.6862723214285712e-05 1.5 1.686328125e-05 0.0 1.6868861607142856e-05 0.0 1.6869419642857143e-05 1.5 1.6880580357142858e-05 1.5 1.688113839285714e-05 0.0 1.688671875e-05 0.0 1.6887276785714285e-05 1.5 1.68984375e-05 1.5 1.6898995535714283e-05 0.0 1.690457589285714e-05 0.0 1.6905133928571427e-05 1.5 1.6916294642857142e-05 1.5 1.691685267857143e-05 0.0 1.6922433035714283e-05 0.0 1.692299107142857e-05 1.5 1.6934151785714285e-05 1.5 1.693470982142857e-05 0.0 1.694029017857143e-05 0.0 1.6940848214285712e-05 1.5 1.6952008928571427e-05 1.5 1.6952566964285714e-05 0.0 1.695814732142857e-05 0.0 1.6958705357142854e-05 1.5 1.696986607142857e-05 1.5 1.6970424107142856e-05 0.0 1.6976004464285713e-05 0.0 1.69765625e-05 1.5 1.698772321428571e-05 1.5 1.698828125e-05 0.0 1.6993861607142856e-05 0.0 1.6994419642857142e-05 1.5 1.7005580357142857e-05 1.5 1.700613839285714e-05 0.0 1.7011718749999998e-05 0.0 1.7012276785714285e-05 1.5 1.70234375e-05 1.5 1.7023995535714283e-05 0.0 1.702957589285714e-05 0.0 1.7030133928571427e-05 1.5 1.7041294642857142e-05 1.5 1.704185267857143e-05 0.0 1.7047433035714286e-05 0.0 1.704799107142857e-05 1.5 1.7059151785714284e-05 1.5 1.705970982142857e-05 0.0 1.706529017857143e-05 0.0 1.7065848214285712e-05 1.5 1.7077008928571427e-05 1.5 1.7077566964285713e-05 0.0 1.708314732142857e-05 0.0 1.7083705357142857e-05 1.5 1.709486607142857e-05 1.5 1.7095424107142856e-05 0.0 1.7101004464285713e-05 0.0 1.71015625e-05 1.5 1.7112723214285715e-05 1.5 1.7113281249999998e-05 0.0 1.7118861607142855e-05 0.0 1.7119419642857142e-05 1.5 1.7130580357142857e-05 1.5 1.713113839285714e-05 0.0 1.7136160714285714e-05 0.0 1.7136718749999998e-05 1.5 1.7148995535714286e-05 1.5 1.714955357142857e-05 0.0 1.7154017857142857e-05 0.0 1.715457589285714e-05 1.5 1.716685267857143e-05 1.5 1.716741071428571e-05 0.0 1.7171875e-05 0.0 1.7172433035714286e-05 1.5 1.718470982142857e-05 1.5 1.7185267857142857e-05 0.0 1.718973214285714e-05 0.0 1.7190290178571428e-05 1.5 1.7202566964285713e-05 1.5 1.7203125e-05 0.0 1.7207589285714284e-05 0.0 1.720814732142857e-05 1.5 1.7220424107142855e-05 1.5 1.7220982142857142e-05 0.0 1.7225446428571426e-05 0.0 1.7226004464285713e-05 1.5 1.7238281249999998e-05 1.5 1.7238839285714284e-05 0.0 1.724330357142857e-05 0.0 1.7243861607142855e-05 1.5 1.725613839285714e-05 1.5 1.7256696428571427e-05 0.0 1.7261160714285714e-05 0.0 1.7261718749999997e-05 1.5 1.7273995535714286e-05 1.5 1.727455357142857e-05 0.0 1.7279017857142856e-05 0.0 1.7279575892857143e-05 1.5 1.7291852678571428e-05 1.5 1.7292410714285715e-05 0.0 1.7296875e-05 0.0 1.7297433035714285e-05 1.5 1.730970982142857e-05 1.5 1.7310267857142857e-05 0.0 1.731473214285714e-05 0.0 1.7315290178571428e-05 1.5 1.7327566964285713e-05 1.5 1.7328125e-05 0.0 1.7332589285714283e-05 0.0 1.733314732142857e-05 1.5 1.7345424107142855e-05 1.5 1.7345982142857142e-05 0.0 1.735044642857143e-05 0.0 1.7351004464285712e-05 1.5 1.7363281249999997e-05 1.5 1.7363839285714284e-05 0.0 1.736830357142857e-05 0.0 1.7368861607142855e-05 1.5 1.7381138392857143e-05 1.5 1.7381696428571426e-05 0.0 1.7386160714285714e-05 0.0 1.738671875e-05 1.5 1.7398995535714285e-05 1.5 1.739955357142857e-05 0.0 1.7404017857142856e-05 0.0 1.7404575892857143e-05 1.5 1.7416852678571428e-05 1.5 1.7417410714285714e-05 0.0 1.7421874999999998e-05 0.0 1.7422433035714285e-05 1.5 1.743470982142857e-05 1.5 1.7435267857142857e-05 0.0 1.743973214285714e-05 0.0 1.7440290178571427e-05 1.5 1.7452566964285712e-05 1.5 1.7453125e-05 0.0 1.7457589285714283e-05 0.0 1.745814732142857e-05 1.5 1.7470424107142855e-05 1.5 1.747098214285714e-05 0.0 1.747544642857143e-05 0.0 1.7476004464285712e-05 1.5 1.748828125e-05 1.5 1.7488839285714284e-05 0.0 1.749330357142857e-05 0.0 1.7493861607142854e-05 1.5 1.7506138392857143e-05 1.5 1.7506696428571426e-05 0.0 1.7511160714285713e-05 0.0 1.751171875e-05 1.5 1.7523995535714285e-05 1.5 1.7524553571428572e-05 0.0 1.7529017857142856e-05 0.0 1.7529575892857142e-05 1.5 1.7541852678571427e-05 1.5 1.7542410714285714e-05 0.0 1.7546874999999998e-05 0.0 1.7547433035714285e-05 1.5 1.755970982142857e-05 1.5 1.7560267857142856e-05 0.0 1.756473214285714e-05 0.0 1.7565290178571427e-05 1.5 1.7577566964285712e-05 1.5 1.7578125e-05 0.0 1.7582589285714286e-05 0.0 1.758314732142857e-05 1.5 1.7595424107142854e-05 1.5 1.759598214285714e-05 0.0 1.7600446428571428e-05 0.0 1.760100446428571e-05 1.5 1.761328125e-05 1.5 1.7613839285714283e-05 0.0 1.761830357142857e-05 0.0 1.7618861607142857e-05 1.5 1.7631138392857142e-05 1.5 1.7631696428571426e-05 0.0 1.7636160714285713e-05 0.0 1.763671875e-05 1.5 1.7648995535714285e-05 1.5 1.764955357142857e-05 0.0 1.7654017857142855e-05 0.0 1.7654575892857142e-05 1.5 1.7666852678571427e-05 1.5 1.7667410714285714e-05 0.0 1.7671874999999998e-05 0.0 1.7672433035714284e-05 1.5 1.768470982142857e-05 1.5 1.7685267857142856e-05 0.0 1.7689732142857143e-05 0.0 1.7690290178571427e-05 1.5 1.770256696428571e-05 1.5 1.7703125e-05 0.0 1.7707589285714286e-05 0.0 1.770814732142857e-05 1.5 1.7720424107142857e-05 1.5 1.772098214285714e-05 0.0 1.7725446428571428e-05 0.0 1.7726004464285715e-05 1.5 1.773828125e-05 1.5 1.7738839285714283e-05 0.0 1.774330357142857e-05 0.0 1.7743861607142857e-05 1.5 1.7756138392857142e-05 1.5 1.775669642857143e-05 0.0 1.7761160714285713e-05 0.0 1.776171875e-05 1.5 1.7773995535714284e-05 1.5 1.777455357142857e-05 0.0 1.7779017857142855e-05 0.0 1.777957589285714e-05 1.5 1.7791852678571427e-05 1.5 1.7792410714285713e-05 0.0 1.7796874999999997e-05 0.0 1.7797433035714284e-05 1.5 1.780970982142857e-05 1.5 1.7810267857142856e-05 0.0 1.7814732142857143e-05 0.0 1.7815290178571426e-05 1.5 1.7827566964285715e-05 1.5 1.7828124999999998e-05 0.0 1.7832589285714285e-05 0.0 1.783314732142857e-05 1.5 1.7845424107142857e-05 1.5 1.784598214285714e-05 0.0 1.7850446428571428e-05 0.0 1.7851004464285714e-05 1.5 1.786328125e-05 1.5 1.7863839285714286e-05 0.0 1.786830357142857e-05 0.0 1.7868861607142857e-05 1.5 1.788113839285714e-05 1.5 1.788169642857143e-05 0.0 1.7886160714285712e-05 0.0 1.788671875e-05 1.5 1.7898995535714284e-05 1.5 1.789955357142857e-05 0.0 1.7904017857142855e-05 0.0 1.790457589285714e-05 1.5 1.7916852678571426e-05 1.5 1.7917410714285713e-05 0.0 1.7921875e-05 0.0 1.7922433035714284e-05 1.5 1.793470982142857e-05 1.5 1.7935267857142855e-05 0.0 1.7939732142857143e-05 0.0 1.7940290178571426e-05 1.5 1.7952566964285714e-05 1.5 1.7953124999999998e-05 0.0 1.7957589285714285e-05 0.0 1.795814732142857e-05 1.5 1.7970424107142857e-05 1.5 1.797098214285714e-05 0.0 1.7975446428571427e-05 0.0 1.7976004464285714e-05 1.5 1.798828125e-05 1.5 1.7988839285714286e-05 0.0 1.799330357142857e-05 0.0 1.7993861607142856e-05 1.5 1.800613839285714e-05 1.5 1.8006696428571428e-05 0.0 1.8011160714285712e-05 0.0 1.801171875e-05 1.5 1.8023995535714284e-05 1.5 1.802455357142857e-05 0.0 1.8029017857142854e-05 0.0 1.802957589285714e-05 1.5 1.8041852678571426e-05 1.5 1.8042410714285713e-05 0.0 1.8046875e-05 0.0 1.8047433035714283e-05 1.5 1.805970982142857e-05 1.5 1.8060267857142855e-05 0.0 1.8064732142857142e-05 0.0 1.8065290178571426e-05 1.5 1.8077566964285714e-05 1.5 1.8078124999999997e-05 0.0 1.8082589285714285e-05 0.0 1.808314732142857e-05 1.5 1.8095424107142856e-05 1.5 1.8095982142857143e-05 0.0 1.8100446428571427e-05 0.0 1.8101004464285714e-05 1.5 1.811328125e-05 1.5 1.8113839285714285e-05 0.0 1.811830357142857e-05 0.0 1.8118861607142856e-05 1.5 1.813113839285714e-05 1.5 1.8131696428571428e-05 0.0 1.813616071428571e-05 0.0 1.8136718749999998e-05 1.5 1.8148995535714283e-05 1.5 1.814955357142857e-05 0.0 1.8154017857142857e-05 0.0 1.815457589285714e-05 1.5 1.816685267857143e-05 1.5 1.8167410714285712e-05 0.0 1.8171875e-05 0.0 1.8172433035714283e-05 1.5 1.818470982142857e-05 1.5 1.8185267857142855e-05 0.0 1.8189732142857142e-05 0.0 1.819029017857143e-05 1.5 1.8202566964285714e-05 1.5 1.8203125e-05 0.0 1.8207589285714284e-05 0.0 1.820814732142857e-05 1.5 1.8220424107142856e-05 1.5 1.8220982142857143e-05 0.0 1.8225446428571427e-05 0.0 1.8226004464285713e-05 1.5 1.8238281249999998e-05 1.5 1.8238839285714285e-05 0.0 1.824330357142857e-05 0.0 1.8243861607142856e-05 1.5 1.825613839285714e-05 1.5 1.8256696428571427e-05 0.0 1.8261160714285715e-05 0.0 1.8261718749999998e-05 1.5 1.8273995535714283e-05 1.5 1.827455357142857e-05 0.0 1.8279017857142857e-05 0.0 1.827957589285714e-05 1.5 1.829185267857143e-05 1.5 1.8292410714285712e-05 0.0 1.8296875e-05 0.0 1.8297433035714286e-05 1.5 1.830970982142857e-05 1.5 1.8310267857142854e-05 0.0 1.831473214285714e-05 0.0 1.8315290178571428e-05 1.5 1.8327566964285713e-05 1.5 1.8328125e-05 0.0 1.8332589285714284e-05 0.0 1.833314732142857e-05 1.5 1.8345424107142856e-05 1.5 1.8345982142857142e-05 0.0 1.8350446428571426e-05 0.0 1.8351004464285713e-05 1.5 1.8363281249999998e-05 1.5 1.8363839285714285e-05 0.0 1.836830357142857e-05 0.0 1.8368861607142855e-05 1.5 1.838113839285714e-05 1.5 1.8381696428571427e-05 0.0 1.8386160714285714e-05 0.0 1.8386718749999998e-05 1.5 1.8398995535714286e-05 1.5 1.839955357142857e-05 0.0 1.8404017857142857e-05 0.0 1.840457589285714e-05 1.5 1.8416852678571428e-05 1.5 1.841741071428571e-05 0.0 1.8421875e-05 0.0 1.8422433035714286e-05 1.5 1.843470982142857e-05 1.5 1.8435267857142857e-05 0.0 1.843973214285714e-05 0.0 1.8440290178571428e-05 1.5 1.8452566964285713e-05 1.5 1.8453125e-05 0.0 1.8457589285714283e-05 0.0 1.845814732142857e-05 1.5 1.8470424107142855e-05 1.5 1.8470982142857142e-05 0.0 1.8475446428571426e-05 0.0 1.8476004464285713e-05 1.5 1.8488281249999998e-05 1.5 1.8488839285714284e-05 0.0 1.849330357142857e-05 0.0 1.8493861607142855e-05 1.5 1.8506138392857143e-05 1.5 1.8506696428571427e-05 0.0 1.8511160714285714e-05 0.0 1.8511718749999997e-05 1.5 1.8523995535714286e-05 1.5 1.852455357142857e-05 0.0 1.8529017857142856e-05 0.0 1.8529575892857143e-05 1.5 1.8541852678571428e-05 1.5 1.8542410714285715e-05 0.0 1.8546875e-05 0.0 1.8547433035714285e-05 1.5 1.855970982142857e-05 1.5 1.8560267857142857e-05 0.0 1.856473214285714e-05 0.0 1.8565290178571428e-05 1.5 1.8577566964285713e-05 1.5 1.8578125e-05 0.0 1.8582589285714283e-05 0.0 1.858314732142857e-05 1.5 1.8595424107142855e-05 1.5 1.859598214285714e-05 0.0 1.860044642857143e-05 0.0 1.8601004464285712e-05 1.5 1.8613281249999997e-05 1.5 1.8613839285714284e-05 0.0 1.861830357142857e-05 0.0 1.8618861607142855e-05 1.5 1.8631138392857143e-05 1.5 1.8631696428571426e-05 0.0 1.8636160714285714e-05 0.0 1.863671875e-05 1.5 1.8648995535714285e-05 1.5 1.864955357142857e-05 0.0 1.8654017857142856e-05 0.0 1.8654575892857143e-05 1.5 1.8666852678571428e-05 1.5 1.8667410714285714e-05 0.0 1.8671874999999998e-05 0.0 1.8672433035714285e-05 1.5 1.868470982142857e-05 1.5 1.8685267857142857e-05 0.0 1.868973214285714e-05 0.0 1.8690290178571427e-05 1.5 1.8702566964285712e-05 1.5 1.8703125e-05 0.0 1.8707589285714283e-05 0.0 1.870814732142857e-05 1.5 1.8720424107142854e-05 1.5 1.872098214285714e-05 0.0 1.872544642857143e-05 0.0 1.8726004464285712e-05 1.5 1.873828125e-05 1.5 1.8738839285714284e-05 0.0 1.874330357142857e-05 0.0 1.8743861607142854e-05 1.5 1.8756138392857143e-05 1.5 1.8756696428571426e-05 0.0 1.8761160714285713e-05 0.0 1.876171875e-05 1.5 1.8773995535714285e-05 1.5 1.877455357142857e-05 0.0 1.8779017857142855e-05 0.0 1.8779575892857142e-05 1.5 1.8791852678571427e-05 1.5 1.8792410714285714e-05 0.0 1.8796874999999998e-05 0.0 1.8797433035714285e-05 1.5 1.880970982142857e-05 1.5 1.8810267857142856e-05 0.0 1.881473214285714e-05 0.0 1.8815290178571427e-05 1.5 1.8827566964285712e-05 1.5 1.8828125e-05 0.0 1.8832589285714286e-05 0.0 1.883314732142857e-05 1.5 1.8845424107142854e-05 1.5 1.884598214285714e-05 0.0 1.8850446428571428e-05 0.0 1.885100446428571e-05 1.5 1.886328125e-05 1.5 1.8863839285714283e-05 0.0 1.886830357142857e-05 0.0 1.8868861607142857e-05 1.5 1.8881138392857142e-05 1.5 1.8881696428571426e-05 0.0 1.8886160714285713e-05 0.0 1.888671875e-05 1.5 1.8898995535714284e-05 1.5 1.889955357142857e-05 0.0 1.8904017857142855e-05 0.0 1.8904575892857142e-05 1.5 1.8916852678571427e-05 1.5 1.8917410714285714e-05 0.0 1.8921874999999997e-05 0.0 1.8922433035714284e-05 1.5 1.893470982142857e-05 1.5 1.8935267857142856e-05 0.0 1.8939732142857143e-05 0.0 1.8940290178571427e-05 1.5 1.895256696428571e-05 1.5 1.8953124999999998e-05 0.0 1.8957589285714285e-05 0.0 1.895814732142857e-05 1.5 1.8970424107142857e-05 1.5 1.897098214285714e-05 0.0 1.8975446428571428e-05 0.0 1.8976004464285715e-05 1.5 1.8987723214285713e-05 1.5 1.898828125e-05 0.0 1.8993861607142857e-05 0.0 1.899441964285714e-05 1.5 1.9005580357142855e-05 1.5 1.9006138392857142e-05 0.0 1.901171875e-05 0.0 1.9012276785714286e-05 1.5 1.9023437499999997e-05 1.5 1.9023995535714284e-05 0.0 1.902957589285714e-05 0.0 1.9030133928571428e-05 1.5 1.9041294642857143e-05 1.5 1.9041852678571426e-05 0.0 1.9047433035714284e-05 0.0 1.904799107142857e-05 1.5 1.9059151785714285e-05 1.5 1.905970982142857e-05 0.0 1.9065290178571426e-05 0.0 1.9065848214285713e-05 1.5 1.9077008928571428e-05 1.5 1.9077566964285714e-05 0.0 1.908314732142857e-05 0.0 1.9083705357142855e-05 1.5 1.909486607142857e-05 1.5 1.9095424107142857e-05 0.0 1.9101004464285714e-05 0.0 1.9101562499999998e-05 1.5 1.9112723214285712e-05 1.5 1.911328125e-05 0.0 1.9118861607142857e-05 0.0 1.911941964285714e-05 1.5 1.9130580357142855e-05 1.5 1.913113839285714e-05 0.0 1.913671875e-05 0.0 1.9137276785714286e-05 1.5 1.9148437499999997e-05 1.5 1.9148995535714284e-05 0.0 1.915457589285714e-05 0.0 1.9155133928571428e-05 1.5 1.9166294642857143e-05 1.5 1.9166852678571426e-05 0.0 1.9172433035714284e-05 0.0 1.917299107142857e-05 1.5 1.9184151785714285e-05 1.5 1.918470982142857e-05 0.0 1.9190290178571426e-05 0.0 1.9190848214285713e-05 1.5 1.9202008928571427e-05 1.5 1.9202566964285714e-05 0.0 1.920814732142857e-05 0.0 1.9208705357142855e-05 1.5 1.921986607142857e-05 1.5 1.9220424107142856e-05 0.0 1.9226004464285714e-05 0.0 1.9226562499999997e-05 1.5 1.9237723214285712e-05 1.5 1.923828125e-05 0.0 1.9243861607142856e-05 0.0 1.9244419642857143e-05 1.5 1.9255580357142854e-05 1.5 1.925613839285714e-05 0.0 1.926171875e-05 0.0 1.9262276785714285e-05 1.5 1.92734375e-05 1.5 1.9273995535714283e-05 0.0 1.927957589285714e-05 0.0 1.9280133928571428e-05 1.5 1.9291294642857142e-05 1.5 1.9291852678571426e-05 0.0 1.9297433035714283e-05 0.0 1.929799107142857e-05 1.5 1.9309151785714285e-05 1.5 1.930970982142857e-05 0.0 1.931529017857143e-05 0.0 1.9315848214285712e-05 1.5 1.9327008928571427e-05 1.5 1.9327566964285714e-05 0.0 1.933314732142857e-05 0.0 1.9333705357142855e-05 1.5 1.934486607142857e-05 1.5 1.9345424107142856e-05 0.0 1.9351004464285714e-05 0.0 1.93515625e-05 1.5 1.936272321428571e-05 1.5 1.936328125e-05 0.0 1.9368861607142856e-05 0.0 1.9369419642857143e-05 1.5 1.9380580357142857e-05 1.5 1.938113839285714e-05 0.0 1.9386718749999998e-05 0.0 1.9387276785714285e-05 1.5 1.9397879464285713e-05 1.5 1.93984375e-05 0.0 1.9405133928571427e-05 0.0 1.9405691964285714e-05 1.5 1.9415736607142855e-05 1.5 1.9416294642857142e-05 0.0 1.942299107142857e-05 0.0 1.9423549107142856e-05 1.5 1.9433593749999998e-05 1.5 1.9434151785714284e-05 0.0 1.9440848214285712e-05 0.0 1.944140625e-05 1.5 1.945145089285714e-05 1.5 1.9452008928571427e-05 0.0 1.9458705357142854e-05 0.0 1.945926339285714e-05 1.5 1.9469308035714286e-05 1.5 1.946986607142857e-05 0.0 1.94765625e-05 0.0 1.9477120535714283e-05 1.5 1.9487165178571428e-05 1.5 1.948772321428571e-05 0.0 1.9494419642857142e-05 0.0 1.9494977678571426e-05 1.5 1.950502232142857e-05 1.5 1.9505580357142857e-05 0.0 1.9512276785714285e-05 0.0 1.951283482142857e-05 1.5 1.9522879464285713e-05 1.5 1.95234375e-05 0.0 1.9530133928571427e-05 0.0 1.9530691964285714e-05 1.5 1.9540736607142855e-05 1.5 1.954129464285714e-05 0.0 1.954799107142857e-05 0.0 1.9548549107142856e-05 1.5 1.9558593749999997e-05 1.5 1.9559151785714284e-05 0.0 1.956584821428571e-05 0.0 1.9566406249999998e-05 1.5 1.9576450892857143e-05 1.5 1.9577008928571426e-05 0.0 1.9583705357142857e-05 0.0 1.958426339285714e-05 1.5 1.9594308035714285e-05 1.5 1.959486607142857e-05 0.0 1.96015625e-05 0.0 1.9602120535714283e-05 1.5 1.9612165178571428e-05 1.5 1.9612723214285714e-05 0.0 1.9619419642857142e-05 0.0 1.961997767857143e-05 1.5 1.963002232142857e-05 1.5 1.9630580357142857e-05 0.0 1.9637276785714284e-05 0.0 1.963783482142857e-05 1.5 1.9647879464285712e-05 1.5 1.96484375e-05 0.0 1.9655133928571427e-05 0.0 1.9655691964285713e-05 1.5 1.9665736607142855e-05 1.5 1.966629464285714e-05 0.0 1.967299107142857e-05 0.0 1.9673549107142856e-05 1.5 1.9683593749999997e-05 1.5 1.9684151785714284e-05 0.0 1.969084821428571e-05 0.0 1.9691406249999998e-05 1.5 1.9701450892857143e-05 1.5 1.9702008928571426e-05 0.0 1.9708705357142857e-05 0.0 1.970926339285714e-05 1.5 1.9719308035714285e-05 1.5 1.9719866071428572e-05 0.0 1.97265625e-05 0.0 1.9727120535714286e-05 1.5 1.9737165178571427e-05 1.5 1.9737723214285714e-05 0.0 1.9744977678571428e-05 0.0 1.974553571428571e-05 1.5 1.9754464285714283e-05 1.5 1.975502232142857e-05 0.0 1.976283482142857e-05 0.0 1.9763392857142857e-05 1.5 1.977232142857143e-05 1.5 1.9772879464285712e-05 0.0 1.9780691964285713e-05 0.0 1.978125e-05 1.5 1.979017857142857e-05 1.5 1.9790736607142854e-05 0.0 1.9798549107142855e-05 0.0 1.9799107142857142e-05 1.5 1.9808035714285713e-05 1.5 1.980859375e-05 0.0 1.9816406249999998e-05 0.0 1.9816964285714284e-05 1.5 1.9825892857142856e-05 1.5 1.9826450892857142e-05 0.0 1.983426339285714e-05 0.0 1.9834821428571427e-05 1.5 1.9843749999999998e-05 1.5 1.9844308035714285e-05 0.0 1.9852120535714286e-05 0.0 1.985267857142857e-05 1.5 1.986160714285714e-05 1.5 1.9862165178571427e-05 0.0 1.9869977678571428e-05 0.0 1.987053571428571e-05 1.5 1.9879464285714286e-05 1.5 1.988002232142857e-05 0.0 1.988783482142857e-05 0.0 1.9888392857142857e-05 1.5 1.9897321428571428e-05 1.5 1.989787946428571e-05 0.0 1.9905691964285713e-05 0.0 1.990625e-05 1.5 1.991517857142857e-05 1.5 1.9915736607142857e-05 0.0 1.9923549107142855e-05 0.0 1.992410714285714e-05 1.5 1.9933035714285713e-05 1.5 1.993359375e-05 0.0 1.9941406249999997e-05 0.0 1.9941964285714284e-05 1.5 1.9950892857142855e-05 1.5 1.9951450892857142e-05 0.0 1.9959263392857143e-05 0.0 1.9959821428571426e-05 1.5 1.9968749999999997e-05 1.5 1.9969308035714284e-05 0.0 1.9977120535714285e-05 0.0 1.997767857142857e-05 1.5 1.998660714285714e-05 1.5 1.9987165178571427e-05 0.0 1.9994977678571428e-05 0.0 1.9995535714285714e-05 1.5 2.0004464285714286e-05 1.5 2.000502232142857e-05 0.0 2.001283482142857e-05 0.0 2.0013392857142857e-05 1.5 2.0022321428571428e-05 1.5 2.002287946428571e-05 0.0 2.0030691964285712e-05 0.0 2.003125e-05 1.5 2.004017857142857e-05 1.5 2.0040736607142857e-05 0.0 2.0048549107142855e-05 0.0 2.004910714285714e-05 1.5 2.0058035714285712e-05 1.5 2.005859375e-05 0.0 2.0066964285714284e-05 0.0 2.006752232142857e-05 1.5 2.007533482142857e-05 1.5 2.0075892857142855e-05 0.0 2.0084821428571426e-05 0.0 2.0085379464285713e-05 1.5 2.0093191964285714e-05 1.5 2.0093749999999997e-05 0.0 2.0102678571428568e-05 0.0 2.0103236607142855e-05 1.5 2.0111049107142856e-05 1.5 2.0111607142857143e-05 0.0 2.0120535714285714e-05 0.0 2.0121093749999997e-05 1.5 2.012890625e-05 1.5 2.0129464285714285e-05 0.0 2.0138392857142856e-05 0.0 2.0138950892857143e-05 1.5 2.014676339285714e-05 1.5 2.0147321428571427e-05 0.0 2.015625e-05 0.0 2.0156808035714285e-05 1.5 2.0164620535714283e-05 1.5 2.016517857142857e-05 0.0 2.017410714285714e-05 0.0 2.0174665178571428e-05 1.5 2.018247767857143e-05 1.5 2.0183035714285712e-05 0.0 2.0191964285714283e-05 0.0 2.019252232142857e-05 1.5 2.020033482142857e-05 1.5 2.0200892857142854e-05 0.0 2.0209821428571426e-05 0.0 2.0210379464285712e-05 1.5 2.0218191964285713e-05 1.5 2.021875e-05 0.0 2.022767857142857e-05 0.0 2.0228236607142855e-05 1.5 2.0236049107142856e-05 1.5 2.0236607142857143e-05 0.0 2.0245535714285714e-05 0.0 2.0246093749999997e-05 1.5 2.0253906249999998e-05 1.5 2.0254464285714285e-05 0.0 2.0263392857142856e-05 0.0 2.0263950892857143e-05 1.5 2.027176339285714e-05 1.5 2.0272321428571427e-05 0.0 2.028125e-05 0.0 2.0281808035714285e-05 1.5 2.0289620535714283e-05 1.5 2.029017857142857e-05 0.0 2.029910714285714e-05 0.0 2.0299665178571427e-05 1.5 2.030747767857143e-05 1.5 2.0308035714285712e-05 0.0 2.0316964285714283e-05 0.0 2.031752232142857e-05 1.5 2.032533482142857e-05 1.5 2.0325892857142854e-05 0.0 2.033482142857143e-05 0.0 2.0335379464285712e-05 1.5 2.0343191964285713e-05 1.5 2.034375e-05 0.0 2.035267857142857e-05 0.0 2.0353236607142854e-05 1.5 2.0361049107142855e-05 1.5 2.0361607142857142e-05 0.0 2.0370535714285713e-05 0.0 2.037109375e-05 1.5 2.0378906249999998e-05 1.5 2.0379464285714284e-05 0.0 2.0388950892857142e-05 0.0 2.0389508928571426e-05 1.5 2.0396205357142857e-05 1.5 2.039676339285714e-05 0.0 2.0406808035714285e-05 0.0 2.040736607142857e-05 1.5 2.04140625e-05 1.5 2.0414620535714286e-05 0.0 2.0424665178571427e-05 0.0 2.0425223214285714e-05 1.5 2.043191964285714e-05 1.5 2.0432477678571428e-05 0.0 2.044252232142857e-05 0.0 2.0443080357142856e-05 1.5 2.0449776785714284e-05 1.5 2.045033482142857e-05 0.0 2.046037946428571e-05 0.0 2.04609375e-05 1.5 2.0467633928571426e-05 1.5 2.0468191964285713e-05 0.0 2.0478236607142854e-05 0.0 2.047879464285714e-05 1.5 2.0485491071428568e-05 1.5 2.0486049107142855e-05 0.0 2.049609375e-05 0.0 2.0496651785714283e-05 1.5 2.0503348214285714e-05 1.5 2.0503906249999997e-05 0.0 2.0513950892857142e-05 0.0 2.0514508928571425e-05 1.5 2.0521205357142856e-05 1.5 2.0521763392857143e-05 0.0 2.0531808035714284e-05 0.0 2.053236607142857e-05 1.5 2.05390625e-05 1.5 2.0539620535714285e-05 0.0 2.0549665178571427e-05 0.0 2.0550223214285713e-05 1.5 2.055691964285714e-05 1.5 2.0557477678571428e-05 0.0 2.056752232142857e-05 0.0 2.0568080357142856e-05 1.5 2.0574776785714283e-05 1.5 2.057533482142857e-05 0.0 2.058537946428571e-05 0.0 2.0585937499999998e-05 1.5 2.0592633928571426e-05 1.5 2.0593191964285712e-05 0.0 2.0603236607142857e-05 0.0 2.060379464285714e-05 1.5 2.061049107142857e-05 1.5 2.0611049107142855e-05 0.0 2.062109375e-05 0.0 2.0621651785714283e-05 1.5 2.0628348214285714e-05 1.5 2.0628906249999997e-05 0.0 2.063895089285714e-05 0.0 2.063950892857143e-05 1.5 2.0646205357142856e-05 1.5 2.0646763392857143e-05 0.0 2.0656808035714284e-05 0.0 2.065736607142857e-05 1.5 2.0664062499999998e-05 1.5 2.0664620535714285e-05 0.0 2.0674665178571426e-05 0.0 2.0675223214285713e-05 1.5 2.068191964285714e-05 1.5 2.0682477678571427e-05 0.0 2.069252232142857e-05 0.0 2.0693080357142855e-05 1.5 2.0699776785714283e-05 1.5 2.070033482142857e-05 0.0 2.0710379464285714e-05 0.0 2.0710937499999998e-05 1.5 2.071763392857143e-05 1.5 2.0718191964285712e-05 0.0 2.0728236607142857e-05 0.0 2.072879464285714e-05 1.5 2.0734933035714284e-05 1.5 2.073549107142857e-05 0.0 2.0746651785714286e-05 0.0 2.074720982142857e-05 1.5 2.0752790178571427e-05 1.5 2.0753348214285713e-05 0.0 2.0764508928571428e-05 0.0 2.076506696428571e-05 1.5 2.077064732142857e-05 1.5 2.0771205357142856e-05 0.0 2.078236607142857e-05 0.0 2.0782924107142857e-05 1.5 2.078850446428571e-05 1.5 2.0789062499999998e-05 0.0 2.0800223214285713e-05 0.0 2.080078125e-05 1.5 2.0806361607142857e-05 1.5 2.080691964285714e-05 0.0 2.0818080357142855e-05 0.0 2.0818638392857142e-05 1.5 2.082421875e-05 1.5 2.0824776785714283e-05 0.0 2.0835937499999997e-05 0.0 2.0836495535714284e-05 1.5 2.084207589285714e-05 1.5 2.0842633928571428e-05 0.0 2.085379464285714e-05 0.0 2.0854352678571426e-05 1.5 2.0859933035714284e-05 1.5 2.086049107142857e-05 0.0 2.0871651785714285e-05 0.0 2.087220982142857e-05 1.5 2.0877790178571426e-05 1.5 2.0878348214285713e-05 0.0 2.0889508928571428e-05 0.0 2.089006696428571e-05 1.5 2.089564732142857e-05 1.5 2.0896205357142855e-05 0.0 2.090736607142857e-05 0.0 2.0907924107142857e-05 1.5 2.0913504464285714e-05 1.5 2.0914062499999998e-05 0.0 2.0925223214285712e-05 0.0 2.092578125e-05 1.5 2.0931361607142857e-05 1.5 2.093191964285714e-05 0.0 2.0943080357142855e-05 0.0 2.094363839285714e-05 1.5 2.094921875e-05 1.5 2.0949776785714286e-05 0.0 2.0960937499999997e-05 0.0 2.0961495535714284e-05 1.5 2.096707589285714e-05 1.5 2.0967633928571428e-05 0.0 2.0978794642857143e-05 0.0 2.0979352678571426e-05 1.5 2.0984933035714284e-05 1.5 2.098549107142857e-05 0.0 2.0996651785714285e-05 0.0 2.099720982142857e-05 1.5 2.1002790178571426e-05 1.5 2.1003348214285713e-05 0.0 2.1014508928571427e-05 0.0 2.1015066964285714e-05 1.5 2.102064732142857e-05 1.5 2.1021205357142855e-05 0.0 2.103236607142857e-05 0.0 2.1032924107142856e-05 1.5 2.1038504464285714e-05 1.5 2.1039062499999997e-05 0.0 2.1050223214285712e-05 0.0 2.105078125e-05 1.5 2.1056361607142856e-05 1.5 2.1056919642857143e-05 0.0 2.1068080357142854e-05 0.0 2.106863839285714e-05 1.5 2.107421875e-05 1.5 2.1074776785714285e-05 0.0 2.10859375e-05 0.0 2.1086495535714283e-05 1.5 2.109207589285714e-05 1.5 2.1092633928571428e-05 0.0 2.1103794642857142e-05 0.0 2.1104352678571426e-05 1.5 2.1109933035714283e-05 1.5 2.111049107142857e-05 0.0 2.1121651785714285e-05 0.0 2.112220982142857e-05 1.5 2.1127790178571425e-05 1.5 2.1128348214285712e-05 0.0 2.1139508928571427e-05 0.0 2.1140066964285714e-05 1.5 2.114564732142857e-05 1.5 2.1146205357142855e-05 0.0 2.1157924107142856e-05 0.0 2.1158482142857143e-05 1.5 2.1162946428571427e-05 1.5 2.1163504464285714e-05 0.0 2.117578125e-05 0.0 2.1176339285714285e-05 1.5 2.118080357142857e-05 1.5 2.1181361607142856e-05 0.0 2.119363839285714e-05 0.0 2.1194196428571428e-05 1.5 2.119866071428571e-05 1.5 2.1199218749999998e-05 0.0 2.1211495535714283e-05 0.0 2.121205357142857e-05 1.5 2.1216517857142857e-05 1.5 2.121707589285714e-05 0.0 2.1229352678571425e-05 0.0 2.1229910714285712e-05 1.5 2.1234375e-05 1.5 2.1234933035714283e-05 0.0 2.124720982142857e-05 0.0 2.1247767857142855e-05 1.5 2.1252232142857142e-05 1.5 2.125279017857143e-05 0.0 2.1265066964285713e-05 0.0 2.1265624999999997e-05 1.5 2.1270089285714284e-05 1.5 2.127064732142857e-05 0.0 2.1282924107142856e-05 0.0 2.1283482142857143e-05 1.5 2.1287946428571426e-05 1.5 2.1288504464285713e-05 0.0 2.1300781249999998e-05 0.0 2.1301339285714285e-05 1.5 2.130580357142857e-05 1.5 2.1306361607142856e-05 0.0 2.131863839285714e-05 0.0 2.1319196428571427e-05 1.5 2.132366071428571e-05 1.5 2.1324218749999998e-05 0.0 2.1336495535714283e-05 0.0 2.133705357142857e-05 1.5 2.1341517857142857e-05 1.5 2.134207589285714e-05 0.0 2.135435267857143e-05 0.0 2.1354910714285712e-05 1.5 2.1359375e-05 1.5 2.1359933035714286e-05 0.0 2.137220982142857e-05 0.0 2.1372767857142854e-05 1.5 2.137723214285714e-05 1.5 2.1377790178571428e-05 0.0 2.1390066964285713e-05 0.0 2.1390625e-05 1.5 2.1395089285714284e-05 1.5 2.139564732142857e-05 0.0 2.1407924107142855e-05 0.0 2.1408482142857142e-05 1.5 2.1412946428571426e-05 1.5 2.1413504464285713e-05 0.0 2.1425781249999998e-05 0.0 2.1426339285714285e-05 1.5 2.143080357142857e-05 1.5 2.1431361607142855e-05 0.0 2.144363839285714e-05 0.0 2.1444196428571427e-05 1.5 2.1448660714285714e-05 1.5 2.1449218749999997e-05 0.0 2.1461495535714286e-05 0.0 2.146205357142857e-05 1.5 2.1466517857142856e-05 1.5 2.146707589285714e-05 0.0 2.1479352678571428e-05 0.0 2.147991071428571e-05 1.5 2.1484375e-05 1.5 2.1484933035714286e-05 0.0 2.149720982142857e-05 0.0 2.1497767857142857e-05 1.5 2.150223214285714e-05 1.5 2.1502790178571428e-05 0.0 2.1515066964285713e-05 0.0 2.1515625e-05 1.5 2.1520089285714283e-05 1.5 2.152064732142857e-05 0.0 2.1532924107142855e-05 0.0 2.1533482142857142e-05 1.5 2.1537946428571426e-05 1.5 2.1538504464285712e-05 0.0 2.1550781249999997e-05 0.0 2.1551339285714284e-05 1.5 2.155580357142857e-05 1.5 2.1556361607142855e-05 0.0 2.156863839285714e-05 0.0 2.1569196428571426e-05 1.5 2.1573660714285714e-05 1.5 2.1574218749999997e-05 0.0 2.1586495535714285e-05 0.0 2.158705357142857e-05 1.5 2.1591517857142856e-05 1.5 2.1592075892857143e-05 0.0 2.1604352678571428e-05 0.0 2.160491071428571e-05 1.5 2.1609375e-05 1.5 2.1609933035714285e-05 0.0 2.162220982142857e-05 0.0 2.1622767857142857e-05 1.5 2.162723214285714e-05 1.5 2.1627790178571427e-05 0.0 2.1640066964285712e-05 0.0 2.1640625e-05 1.5 2.1645089285714283e-05 1.5 2.164564732142857e-05 0.0 2.1657924107142855e-05 0.0 2.165848214285714e-05 1.5 2.1662946428571425e-05 1.5 2.1663504464285712e-05 0.0 2.1675781249999997e-05 0.0 2.1676339285714284e-05 1.5 2.168080357142857e-05 1.5 2.1681361607142854e-05 0.0 2.1693638392857143e-05 0.0 2.1694196428571426e-05 1.5 2.1698660714285713e-05 1.5 2.1699218749999997e-05 0.0 2.1711495535714285e-05 0.0 2.171205357142857e-05 1.5 2.1716517857142856e-05 1.5 2.1717075892857142e-05 0.0 2.1729352678571427e-05 0.0 2.1729910714285714e-05 1.5 2.1734374999999998e-05 1.5 2.1734933035714285e-05 0.0 2.174720982142857e-05 0.0 2.1747767857142856e-05 1.5 2.175223214285714e-05 1.5 2.1752790178571427e-05 0.0 2.1765066964285712e-05 0.0 2.1765625e-05 1.5 2.1770089285714283e-05 1.5 2.177064732142857e-05 0.0 2.1782924107142854e-05 0.0 2.178348214285714e-05 1.5 2.178794642857143e-05 1.5 2.1788504464285712e-05 0.0 2.180078125e-05 0.0 2.1801339285714283e-05 1.5 2.180580357142857e-05 1.5 2.1806361607142854e-05 0.0 2.1818638392857142e-05 0.0 2.1819196428571426e-05 1.5 2.1823660714285713e-05 1.5 2.182421875e-05 0.0 2.1836495535714285e-05 0.0 2.183705357142857e-05 1.5 2.1841517857142855e-05 1.5 2.1842075892857142e-05 0.0 2.1854352678571427e-05 0.0 2.1854910714285714e-05 1.5 2.1859374999999998e-05 1.5 2.1859933035714284e-05 0.0 2.187220982142857e-05 0.0 2.1872767857142856e-05 1.5 2.187723214285714e-05 1.5 2.1877790178571427e-05 0.0 2.1890066964285712e-05 0.0 2.1890625e-05 1.5 2.1895089285714286e-05 1.5 2.189564732142857e-05 0.0 2.1907924107142854e-05 0.0 2.190848214285714e-05 1.5 2.1912946428571428e-05 1.5 2.191350446428571e-05 0.0 2.192578125e-05 0.0 2.1926339285714283e-05 1.5 2.193080357142857e-05 1.5 2.1931361607142857e-05 0.0 2.1943638392857142e-05 0.0 2.1944196428571425e-05 1.5 2.1948660714285713e-05 1.5 2.194921875e-05 0.0 2.1961495535714284e-05 0.0 2.196205357142857e-05 1.5 2.1966517857142855e-05 1.5 2.1967075892857142e-05 0.0 2.1979352678571427e-05 0.0 2.1979910714285713e-05 1.5 2.1984374999999997e-05 1.5 2.1984933035714284e-05 0.0 2.199720982142857e-05 0.0 2.1997767857142856e-05 1.5 2.200223214285714e-05 1.5 2.2002790178571426e-05 0.0 2.201506696428571e-05 0.0 2.2015624999999998e-05 1.5 2.2020089285714285e-05 1.5 2.202064732142857e-05 0.0 2.2032924107142857e-05 0.0 2.203348214285714e-05 1.5 2.2037946428571428e-05 1.5 2.203850446428571e-05 0.0 2.205078125e-05 0.0 2.2051339285714283e-05 1.5 2.205580357142857e-05 1.5 2.2056361607142857e-05 0.0 2.2068638392857142e-05 0.0 2.206919642857143e-05 1.5 2.2073660714285712e-05 1.5 2.207421875e-05 0.0 2.2086495535714284e-05 0.0 2.208705357142857e-05 1.5 2.2091517857142855e-05 1.5 2.209207589285714e-05 0.0 2.2104352678571426e-05 0.0 2.2104910714285713e-05 1.5 2.2109374999999997e-05 1.5 2.2109933035714284e-05 0.0 2.212220982142857e-05 0.0 2.2122767857142855e-05 1.5 2.2127232142857143e-05 1.5 2.2127790178571426e-05 0.0 2.214006696428571e-05 0.0 2.2140624999999998e-05 1.5 2.2145089285714285e-05 1.5 2.214564732142857e-05 0.0 2.2157924107142857e-05 0.0 2.215848214285714e-05 1.5 2.2162946428571427e-05 1.5 2.2163504464285714e-05 0.0 2.217578125e-05 0.0 2.2176339285714286e-05 1.5 2.218080357142857e-05 1.5 2.2181361607142856e-05 0.0 2.219363839285714e-05 0.0 2.2194196428571428e-05 1.5 2.2198660714285712e-05 1.5 2.219921875e-05 0.0 2.2211495535714284e-05 0.0 2.221205357142857e-05 1.5 2.2216517857142854e-05 1.5 2.221707589285714e-05 0.0 2.2229352678571426e-05 0.0 2.2229910714285713e-05 1.5 2.2234375e-05 1.5 2.2234933035714283e-05 0.0 2.224720982142857e-05 0.0 2.2247767857142855e-05 1.5 2.2252232142857142e-05 1.5 2.2252790178571426e-05 0.0 2.2265066964285714e-05 0.0 2.2265624999999997e-05 1.5 2.2270089285714285e-05 1.5 2.227064732142857e-05 0.0 2.2282924107142856e-05 0.0 2.228348214285714e-05 1.5 2.2287946428571427e-05 1.5 2.2288504464285714e-05 0.0 2.230078125e-05 0.0 2.2301339285714285e-05 1.5 2.230580357142857e-05 1.5 2.2306361607142856e-05 0.0 2.231863839285714e-05 0.0 2.2319196428571428e-05 1.5 2.232366071428571e-05 1.5 2.232421875e-05 0.0 2.2336495535714283e-05 0.0 2.233705357142857e-05 1.5 2.2341517857142854e-05 1.5 2.234207589285714e-05 0.0 2.2354352678571426e-05 0.0 2.2354910714285712e-05 1.5 2.2359375e-05 1.5 2.2359933035714283e-05 0.0 2.237220982142857e-05 0.0 2.2372767857142855e-05 1.5 2.2377232142857142e-05 1.5 2.2377790178571425e-05 0.0 2.2390066964285714e-05 0.0 2.2390624999999997e-05 1.5 2.2395089285714284e-05 1.5 2.239564732142857e-05 0.0 2.2407924107142856e-05 0.0 2.2408482142857143e-05 1.5 2.2412946428571427e-05 1.5 2.2413504464285713e-05 0.0 2.242578125e-05 0.0 2.2426339285714285e-05 1.5 2.243080357142857e-05 1.5 2.2431361607142856e-05 0.0 2.244363839285714e-05 0.0 2.2444196428571427e-05 1.5 2.244866071428571e-05 1.5 2.2449218749999998e-05 0.0 2.2461495535714283e-05 0.0 2.246205357142857e-05 1.5 2.2466517857142857e-05 1.5 2.246707589285714e-05 0.0 2.2479352678571425e-05 0.0 2.2479910714285712e-05 1.5 2.2484375e-05 1.5 2.2484933035714283e-05 0.0 2.249720982142857e-05 0.0 2.2497767857142854e-05 1.5 2.250223214285714e-05 1.5 2.250279017857143e-05 0.0 2.2515066964285713e-05 0.0 2.2515624999999997e-05 1.5 2.2520089285714284e-05 1.5 2.252064732142857e-05 0.0 2.2532924107142856e-05 0.0 2.2533482142857142e-05 1.5 2.2537946428571426e-05 1.5 2.2538504464285713e-05 0.0 2.2550781249999998e-05 0.0 2.2551339285714285e-05 1.5 2.255580357142857e-05 1.5 2.2556361607142855e-05 0.0 2.256863839285714e-05 0.0 2.2569196428571427e-05 1.5 2.2573660714285714e-05 1.5 2.2574218749999998e-05 0.0 2.2586495535714283e-05 0.0 2.258705357142857e-05 1.5 2.2591517857142857e-05 1.5 2.259207589285714e-05 0.0 2.260435267857143e-05 0.0 2.2604910714285712e-05 1.5 2.2609375e-05 1.5 2.2609933035714286e-05 0.0 2.262220982142857e-05 0.0 2.2622767857142854e-05 1.5 2.262723214285714e-05 1.5 2.2627790178571428e-05 0.0 2.2640066964285713e-05 0.0 2.2640625e-05 1.5 2.2645089285714284e-05 1.5 2.264564732142857e-05 0.0 2.2657924107142855e-05 0.0 2.2658482142857142e-05 1.5 2.2662946428571426e-05 1.5 2.2663504464285713e-05 0.0 2.2675781249999998e-05 0.0 2.2676339285714284e-05 1.5 2.2680803571428568e-05 1.5 2.2681361607142855e-05 0.0 2.269363839285714e-05 0.0 2.2694196428571427e-05 1.5 2.2698660714285714e-05 1.5 2.2699218749999997e-05 0.0 2.2711495535714286e-05 0.0 2.271205357142857e-05 1.5 2.2716517857142856e-05 1.5 2.271707589285714e-05 0.0 2.2729352678571428e-05 0.0 2.272991071428571e-05 1.5 2.2734375e-05 1.5 2.2734933035714285e-05 0.0 2.274720982142857e-05 0.0 2.2747767857142857e-05 1.5 2.275223214285714e-05 1.5 2.2752790178571428e-05 0.0 2.2765066964285713e-05 0.0 2.2765625e-05 1.5 2.2770089285714283e-05 1.5 2.277064732142857e-05 0.0 2.2782924107142855e-05 0.0 2.2783482142857142e-05 1.5 2.2787946428571426e-05 1.5 2.2788504464285712e-05 0.0 2.2800781249999997e-05 0.0 2.2801339285714284e-05 1.5 2.280580357142857e-05 1.5 2.2806361607142855e-05 0.0 2.281863839285714e-05 0.0 2.2819196428571426e-05 1.5 2.2823660714285714e-05 1.5 2.2824218749999997e-05 0.0 2.2836495535714285e-05 0.0 2.283705357142857e-05 1.5 2.2841517857142856e-05 1.5 2.2842075892857143e-05 0.0 2.2854352678571428e-05 0.0 2.285491071428571e-05 1.5 2.2859374999999998e-05 1.5 2.2859933035714285e-05 0.0 2.287220982142857e-05 0.0 2.2872767857142857e-05 1.5 2.287723214285714e-05 1.5 2.2877790178571427e-05 0.0 2.2890066964285712e-05 0.0 2.2890625e-05 1.5 2.2895089285714283e-05 1.5 2.289564732142857e-05 0.0 2.2907924107142855e-05 0.0 2.290848214285714e-05 1.5 2.2912946428571425e-05 1.5 2.2913504464285712e-05 0.0 2.2925781249999997e-05 0.0 2.2926339285714284e-05 1.5 2.293080357142857e-05 1.5 2.2931361607142854e-05 0.0 2.2943638392857143e-05 0.0 2.2944196428571426e-05 1.5 2.2948660714285713e-05 1.5 2.2949218749999997e-05 0.0 2.2961495535714285e-05 0.0 2.296205357142857e-05 1.5 2.2966517857142856e-05 1.5 2.2967075892857142e-05 0.0 2.2979352678571427e-05 0.0 2.2979910714285714e-05 1.5 2.2984374999999998e-05 1.5 2.2984933035714285e-05 0.0 2.2996651785714283e-05 0.0 2.299720982142857e-05 1.5 2.3002790178571427e-05 1.5 2.3003348214285714e-05 0.0 2.301450892857143e-05 0.0 2.3015066964285712e-05 1.5 2.302064732142857e-05 1.5 2.3021205357142856e-05 0.0 2.303236607142857e-05 0.0 2.3032924107142854e-05 1.5 2.303850446428571e-05 1.5 2.30390625e-05 0.0 2.3050223214285713e-05 0.0 2.305078125e-05 1.5 2.3056361607142854e-05 1.5 2.305691964285714e-05 0.0 2.3068080357142856e-05 0.0 2.3068638392857142e-05 1.5 2.307421875e-05 1.5 2.3074776785714283e-05 0.0 2.3085937499999998e-05 0.0 2.3086495535714285e-05 1.5 2.3092075892857142e-05 1.5 2.3092633928571425e-05 0.0 2.310379464285714e-05 0.0 2.3104352678571427e-05 1.5 2.3109933035714284e-05 1.5 2.311049107142857e-05 0.0 2.3121651785714283e-05 0.0 2.312220982142857e-05 1.5 2.3127790178571427e-05 1.5 2.3128348214285713e-05 0.0 2.3139508928571428e-05 0.0 2.314006696428571e-05 1.5 2.314564732142857e-05 1.5 2.3146205357142856e-05 0.0 2.315736607142857e-05 0.0 2.3157924107142854e-05 1.5 2.316350446428571e-05 1.5 2.3164062499999998e-05 0.0 2.3175223214285713e-05 0.0 2.317578125e-05 1.5 2.3181361607142857e-05 1.5 2.318191964285714e-05 0.0 2.3193080357142855e-05 0.0 2.3193638392857142e-05 1.5 2.319921875e-05 1.5 2.3199776785714283e-05 0.0 2.3210937499999998e-05 0.0 2.3211495535714284e-05 1.5 2.321707589285714e-05 1.5 2.321763392857143e-05 0.0 2.322879464285714e-05 0.0 2.3229352678571427e-05 1.5 2.3234933035714284e-05 1.5 2.323549107142857e-05 0.0 2.3246651785714286e-05 0.0 2.324720982142857e-05 1.5 2.3252790178571426e-05 1.5 2.3253348214285713e-05 0.0 2.3264508928571428e-05 0.0 2.326506696428571e-05 1.5 2.327064732142857e-05 1.5 2.3271205357142855e-05 0.0 2.328236607142857e-05 0.0 2.3282924107142857e-05 1.5 2.328850446428571e-05 1.5 2.3289062499999998e-05 0.0 2.3300223214285713e-05 0.0 2.330078125e-05 1.5 2.3306361607142857e-05 1.5 2.330691964285714e-05 0.0 2.3318080357142855e-05 0.0 2.331863839285714e-05 1.5 2.332421875e-05 1.5 2.3324776785714282e-05 0.0 2.3335937499999997e-05 0.0 2.3336495535714284e-05 1.5 2.334207589285714e-05 1.5 2.3342633928571428e-05 0.0 2.335379464285714e-05 0.0 2.3354352678571426e-05 1.5 2.3359933035714284e-05 1.5 2.336049107142857e-05 0.0 2.3371651785714285e-05 0.0 2.337220982142857e-05 1.5 2.3377790178571426e-05 1.5 2.3378348214285713e-05 0.0 2.3389508928571428e-05 0.0 2.3390066964285714e-05 1.5 2.3395647321428568e-05 1.5 2.3396205357142855e-05 0.0 2.340736607142857e-05 0.0 2.3407924107142857e-05 1.5 2.3414062499999997e-05 1.5 2.3414620535714284e-05 0.0 2.3424665178571425e-05 0.0 2.3425223214285712e-05 1.5 2.343191964285714e-05 1.5 2.3432477678571426e-05 0.0 2.344252232142857e-05 0.0 2.3443080357142854e-05 1.5 2.3449776785714285e-05 1.5 2.345033482142857e-05 0.0 2.3460379464285713e-05 0.0 2.3460937499999997e-05 1.5 2.3467633928571428e-05 1.5 2.346819196428571e-05 0.0 2.3478236607142856e-05 0.0 2.3478794642857143e-05 1.5 2.348549107142857e-05 1.5 2.3486049107142857e-05 0.0 2.3496093749999998e-05 0.0 2.3496651785714285e-05 1.5 2.3503348214285712e-05 1.5 2.350390625e-05 0.0 2.351395089285714e-05 0.0 2.3514508928571427e-05 1.5 2.3521205357142855e-05 1.5 2.352176339285714e-05 0.0 2.3531808035714283e-05 0.0 2.353236607142857e-05 1.5 2.3539062499999997e-05 1.5 2.3539620535714284e-05 0.0 2.354966517857143e-05 0.0 2.3550223214285712e-05 1.5 2.3556919642857143e-05 1.5 2.3557477678571426e-05 0.0 2.356752232142857e-05 0.0 2.3568080357142854e-05 1.5 2.3574776785714285e-05 1.5 2.357533482142857e-05 0.0 2.3585379464285713e-05 0.0 2.35859375e-05 1.5 2.3592633928571427e-05 1.5 2.3593191964285714e-05 0.0 2.3603236607142855e-05 0.0 2.3603794642857142e-05 1.5 2.361049107142857e-05 1.5 2.3611049107142856e-05 0.0 2.3621093749999998e-05 0.0 2.3621651785714285e-05 1.5 2.3628348214285712e-05 1.5 2.362890625e-05 0.0 2.363895089285714e-05 0.0 2.3639508928571427e-05 1.5 2.3646205357142854e-05 1.5 2.364676339285714e-05 0.0 2.3656808035714282e-05 0.0 2.365736607142857e-05 1.5 2.3664062499999997e-05 1.5 2.3664620535714283e-05 0.0 2.3674665178571428e-05 0.0 2.367522321428571e-05 1.5 2.3681919642857142e-05 1.5 2.3682477678571426e-05 0.0 2.369252232142857e-05 0.0 2.3693080357142854e-05 1.5 2.3699776785714285e-05 1.5 2.3700334821428568e-05 0.0 2.3710379464285713e-05 0.0 2.37109375e-05 1.5 2.3717633928571427e-05 1.5 2.3718191964285714e-05 0.0 2.3728236607142855e-05 0.0 2.3728794642857142e-05 1.5 2.373549107142857e-05 1.5 2.3736049107142856e-05 0.0 2.3746093749999997e-05 0.0 2.3746651785714284e-05 1.5 2.375334821428571e-05 1.5 2.375390625e-05 0.0 2.3763392857142856e-05 0.0 2.376395089285714e-05 1.5 2.377176339285714e-05 1.5 2.3772321428571428e-05 0.0 2.378125e-05 0.0 2.3781808035714285e-05 1.5 2.3789620535714283e-05 1.5 2.379017857142857e-05 0.0 2.379910714285714e-05 0.0 2.3799665178571428e-05 1.5 2.3807477678571425e-05 1.5 2.3808035714285712e-05 0.0 2.3816964285714283e-05 0.0 2.381752232142857e-05 1.5 2.382533482142857e-05 1.5 2.3825892857142854e-05 0.0 2.3834821428571426e-05 0.0 2.3835379464285712e-05 1.5 2.3843191964285713e-05 1.5 2.3843749999999997e-05 0.0 2.385267857142857e-05 0.0 2.3853236607142855e-05 1.5 2.3861049107142856e-05 1.5 2.3861607142857143e-05 0.0 2.3870535714285714e-05 0.0 2.3871093749999997e-05 1.5 2.3878906249999998e-05 1.5 2.3879464285714285e-05 0.0 2.3888392857142856e-05 0.0 2.3888950892857143e-05 1.5 2.389676339285714e-05 1.5 2.3897321428571427e-05 0.0 2.390625e-05 0.0 2.3906808035714285e-05 1.5 2.3914620535714283e-05 1.5 2.391517857142857e-05 0.0 2.392410714285714e-05 0.0 2.3924665178571427e-05 1.5 2.393247767857143e-05 1.5 2.3933035714285712e-05 0.0 2.3941964285714283e-05 0.0 2.394252232142857e-05 1.5 2.395033482142857e-05 1.5 2.3950892857142854e-05 0.0 2.3959821428571425e-05 0.0 2.3960379464285712e-05 1.5 2.3968191964285713e-05 1.5 2.396875e-05 0.0 2.397767857142857e-05 0.0 2.3978236607142854e-05 1.5 2.3986049107142855e-05 1.5 2.3986607142857142e-05 0.0 2.3995535714285713e-05 0.0 2.3996093749999997e-05 1.5 2.4003906249999998e-05 1.5 2.4004464285714284e-05 0.0 2.4013392857142856e-05 0.0 2.4013950892857142e-05 1.5 2.402176339285714e-05 1.5 2.4022321428571427e-05 0.0 2.4031249999999998e-05 0.0 2.4031808035714285e-05 1.5 2.4039620535714282e-05 1.5 2.404017857142857e-05 0.0 2.404910714285714e-05 0.0 2.4049665178571427e-05 1.5 2.4057477678571428e-05 1.5 2.405803571428571e-05 0.0 2.4066964285714283e-05 0.0 2.406752232142857e-05 1.5 2.407533482142857e-05 1.5 2.4075892857142854e-05 0.0 2.408426339285714e-05 0.0 2.408482142857143e-05 1.5 2.409375e-05 1.5 2.4094308035714283e-05 0.0 2.4102120535714284e-05 0.0 2.410267857142857e-05 1.5 2.4111607142857142e-05 1.5 2.4112165178571425e-05 0.0 2.4119977678571426e-05 0.0 2.4120535714285713e-05 1.5 2.4129464285714284e-05 1.5 2.413002232142857e-05 0.0 2.413783482142857e-05 0.0 2.4138392857142855e-05 1.5 2.4147321428571426e-05 1.5 2.4147879464285713e-05 0.0 2.415569196428571e-05 0.0 2.4156249999999998e-05 1.5 2.416517857142857e-05 1.5 2.4165736607142856e-05 0.0 2.4173549107142857e-05 0.0 2.417410714285714e-05 1.5 2.418303571428571e-05 1.5 2.4183593749999998e-05 0.0 2.419140625e-05 0.0 2.4191964285714286e-05 1.5 2.4200892857142857e-05 1.5 2.420145089285714e-05 0.0 2.420926339285714e-05 0.0 2.4209821428571428e-05 1.5 2.421875e-05 1.5 2.4219308035714283e-05 0.0 2.4227120535714284e-05 0.0 2.422767857142857e-05 1.5 2.423660714285714e-05 1.5 2.4237165178571428e-05 0.0 2.4244977678571426e-05 0.0 2.4245535714285713e-05 1.5 2.4254464285714284e-05 1.5 2.425502232142857e-05 0.0 2.4262834821428568e-05 0.0 2.4263392857142855e-05 1.5 2.4272321428571426e-05 1.5 2.4272879464285713e-05 0.0 2.4280691964285714e-05 0.0 2.4281249999999997e-05 1.5 2.429017857142857e-05 1.5 2.4290736607142855e-05 0.0 2.4298549107142856e-05 0.0 2.429910714285714e-05 1.5 2.4308035714285714e-05 1.5 2.4308593749999998e-05 0.0 2.431640625e-05 0.0 2.4316964285714285e-05 1.5 2.4325892857142856e-05 1.5 2.432645089285714e-05 0.0 2.433426339285714e-05 0.0 2.4334821428571428e-05 1.5 2.434375e-05 1.5 2.4344308035714286e-05 0.0 2.4352120535714283e-05 0.0 2.435267857142857e-05 1.5 2.436160714285714e-05 1.5 2.4362165178571428e-05 0.0 2.4369977678571426e-05 0.0 2.4370535714285712e-05 1.5 2.4379464285714283e-05 1.5 2.438002232142857e-05 0.0 2.438783482142857e-05 0.0 2.4388392857142855e-05 1.5 2.4397321428571426e-05 1.5 2.4397879464285713e-05 0.0 2.4405133928571427e-05 0.0 2.4405691964285714e-05 1.5 2.4415736607142855e-05 1.5 2.441629464285714e-05 0.0 2.442299107142857e-05 0.0 2.4423549107142856e-05 1.5 2.4433593749999997e-05 1.5 2.4434151785714284e-05 0.0 2.444084821428571e-05 0.0 2.4441406249999998e-05 1.5 2.445145089285714e-05 1.5 2.4452008928571426e-05 0.0 2.4458705357142854e-05 0.0 2.445926339285714e-05 1.5 2.4469308035714285e-05 1.5 2.446986607142857e-05 0.0 2.44765625e-05 0.0 2.4477120535714283e-05 1.5 2.4487165178571428e-05 1.5 2.448772321428571e-05 0.0 2.4494419642857142e-05 0.0 2.4494977678571425e-05 1.5 2.450502232142857e-05 1.5 2.4505580357142857e-05 0.0 2.4512276785714284e-05 0.0 2.451283482142857e-05 1.5 2.4522879464285712e-05 1.5 2.45234375e-05 0.0 2.4530133928571426e-05 0.0 2.4530691964285713e-05 1.5 2.4540736607142854e-05 1.5 2.454129464285714e-05 0.0 2.454799107142857e-05 0.0 2.4548549107142856e-05 1.5 2.4558593749999997e-05 1.5 2.4559151785714284e-05 0.0 2.456584821428571e-05 0.0 2.4566406249999998e-05 1.5 2.4576450892857143e-05 1.5 2.4577008928571426e-05 0.0 2.4583705357142857e-05 0.0 2.458426339285714e-05 1.5 2.4594308035714285e-05 1.5 2.4594866071428568e-05 0.0 2.46015625e-05 0.0 2.4602120535714283e-05 1.5 2.4612165178571427e-05 1.5 2.4612723214285714e-05 0.0 2.461941964285714e-05 0.0 2.4619977678571428e-05 1.5 2.463002232142857e-05 1.5 2.4630580357142856e-05 0.0 2.4637276785714284e-05 0.0 2.463783482142857e-05 1.5 2.4647879464285712e-05 1.5 2.46484375e-05 0.0 2.4655133928571426e-05 0.0 2.4655691964285713e-05 1.5 2.4665736607142854e-05 1.5 2.466629464285714e-05 0.0 2.467299107142857e-05 0.0 2.4673549107142855e-05 1.5 2.468359375e-05 1.5 2.4684151785714283e-05 0.0 2.4690848214285714e-05 0.0 2.4691406249999998e-05 1.5 2.4701450892857142e-05 1.5 2.4702008928571426e-05 0.0 2.4708705357142856e-05 0.0 2.470926339285714e-05 1.5 2.4719308035714285e-05 1.5 2.471986607142857e-05 0.0 2.47265625e-05 0.0 2.4727120535714286e-05 1.5 2.4737165178571427e-05 1.5 2.4737723214285714e-05 0.0 2.474441964285714e-05 0.0 2.4744977678571428e-05 1.5 2.4755580357142856e-05 1.5 2.4756138392857143e-05 0.0 2.4761718749999997e-05 0.0 2.4762276785714283e-05 1.5 2.4773437499999998e-05 1.5 2.4773995535714285e-05 0.0 2.4779575892857142e-05 0.0 2.4780133928571426e-05 1.5 2.479129464285714e-05 1.5 2.4791852678571427e-05 0.0 2.4797433035714285e-05 0.0 2.4797991071428568e-05 1.5 2.4809151785714283e-05 1.5 2.480970982142857e-05 0.0 2.4815290178571427e-05 0.0 2.4815848214285714e-05 1.5 2.4827008928571425e-05 1.5 2.4827566964285712e-05 0.0 2.483314732142857e-05 0.0 2.4833705357142856e-05 1.5 2.484486607142857e-05 1.5 2.4845424107142854e-05 0.0 2.485100446428571e-05 0.0 2.48515625e-05 1.5 2.4862723214285713e-05 1.5 2.4863281249999997e-05 0.0 2.4868861607142854e-05 0.0 2.486941964285714e-05 1.5 2.4880580357142856e-05 1.5 2.4881138392857142e-05 0.0 2.488671875e-05 0.0 2.4887276785714283e-05 1.5 2.4898437499999998e-05 1.5 2.4898995535714285e-05 0.0 2.4904575892857142e-05 0.0 2.4905133928571425e-05 1.5 2.491629464285714e-05 1.5 2.4916852678571427e-05 0.0 2.4922433035714284e-05 0.0 2.492299107142857e-05 1.5 2.4934151785714283e-05 1.5 2.493470982142857e-05 0.0 2.4940290178571427e-05 0.0 2.4940848214285713e-05 1.5 2.4952008928571428e-05 1.5 2.495256696428571e-05 0.0 2.495814732142857e-05 0.0 2.4958705357142856e-05 1.5 2.496986607142857e-05 1.5 2.4970424107142854e-05 0.0 2.497600446428571e-05 0.0 2.4976562499999998e-05 1.5 2.4987723214285713e-05 1.5 2.498828125e-05 0.0 2.4993861607142857e-05 0.0 2.499441964285714e-05 1.5 2.5005580357142855e-05 1.5 2.5006138392857142e-05 0.0 2.501171875e-05 0.0 2.5012276785714283e-05 1.5 2.5023437499999998e-05 1.5 2.5023995535714284e-05 0.0 2.502957589285714e-05 0.0 2.503013392857143e-05 1.5 2.504129464285714e-05 1.5 2.5041852678571427e-05 0.0 2.5047433035714284e-05 0.0 2.504799107142857e-05 1.5 2.5059151785714286e-05 1.5 2.505970982142857e-05 0.0 2.5065290178571426e-05 0.0 2.5065848214285713e-05 1.5 2.5077008928571428e-05 1.5 2.507756696428571e-05 0.0 2.508314732142857e-05 0.0 2.5083705357142855e-05 1.5 2.509486607142857e-05 1.5 2.5095424107142857e-05 0.0 2.510100446428571e-05 0.0 2.5101562499999998e-05 1.5 2.5112723214285713e-05 1.5 2.511328125e-05 0.0 2.5118861607142857e-05 0.0 2.511941964285714e-05 1.5 2.5130580357142855e-05 1.5 2.513113839285714e-05 0.0 2.513671875e-05 0.0 2.5137276785714282e-05 1.5 2.5148437499999997e-05 1.5 2.5148995535714284e-05 0.0 2.515457589285714e-05 0.0 2.5155133928571428e-05 1.5 2.5166852678571426e-05 1.5 2.5167410714285713e-05 0.0 2.5171874999999997e-05 0.0 2.5172433035714284e-05 1.5 2.518470982142857e-05 1.5 2.5185267857142855e-05 0.0 2.5189732142857143e-05 0.0 2.5190290178571426e-05 1.5 2.520256696428571e-05 1.5 2.5203124999999998e-05 0.0 2.5207589285714285e-05 0.0 2.520814732142857e-05 1.5 2.5220424107142857e-05 1.5 2.522098214285714e-05 0.0 2.5225446428571427e-05 0.0 2.5226004464285714e-05 1.5 2.523828125e-05 1.5 2.5238839285714282e-05 0.0 2.524330357142857e-05 0.0 2.5243861607142856e-05 1.5 2.525613839285714e-05 1.5 2.5256696428571428e-05 0.0 2.5261160714285712e-05 0.0 2.526171875e-05 1.5 2.5273995535714284e-05 1.5 2.527455357142857e-05 0.0 2.5279017857142854e-05 0.0 2.527957589285714e-05 1.5 2.5291852678571426e-05 1.5 2.5292410714285713e-05 0.0 2.5296874999999997e-05 0.0 2.5297433035714283e-05 1.5 2.5309709821428568e-05 1.5 2.5310267857142855e-05 0.0 2.5314732142857142e-05 0.0 2.5315290178571426e-05 1.5 2.5327566964285714e-05 1.5 2.5328124999999997e-05 0.0 2.5332589285714285e-05 0.0 2.5333147321428568e-05 1.5 2.5345424107142856e-05 1.5 2.534598214285714e-05 0.0 2.5350446428571427e-05 0.0 2.5351004464285714e-05 1.5 2.536328125e-05 1.5 2.5363839285714285e-05 0.0 2.536830357142857e-05 0.0 2.5368861607142856e-05 1.5 2.538113839285714e-05 1.5 2.5381696428571428e-05 0.0 2.538616071428571e-05 0.0 2.538671875e-05 1.5 2.5398995535714283e-05 1.5 2.539955357142857e-05 0.0 2.5404017857142854e-05 0.0 2.540457589285714e-05 1.5 2.5416852678571426e-05 1.5 2.5417410714285712e-05 0.0 2.5421875e-05 0.0 2.5422433035714283e-05 1.5 2.543470982142857e-05 1.5 2.5435267857142855e-05 0.0 2.5439732142857142e-05 0.0 2.5440290178571425e-05 1.5 2.5452566964285714e-05 1.5 2.5453124999999997e-05 0.0 2.5457589285714284e-05 0.0 2.545814732142857e-05 1.5 2.5470424107142856e-05 1.5 2.5470982142857143e-05 0.0 2.5475446428571427e-05 0.0 2.5476004464285713e-05 1.5 2.5488281249999998e-05 1.5 2.5488839285714285e-05 0.0 2.549330357142857e-05 0.0 2.5493861607142856e-05 1.5 2.550613839285714e-05 1.5 2.5506696428571427e-05 0.0 2.551116071428571e-05 0.0 2.5511718749999998e-05 1.5 2.5523995535714283e-05 1.5 2.552455357142857e-05 0.0 2.5529017857142857e-05 0.0 2.552957589285714e-05 1.5 2.5541852678571425e-05 1.5 2.5542410714285712e-05 0.0 2.5546875e-05 0.0 2.5547433035714283e-05 1.5 2.555970982142857e-05 1.5 2.5560267857142854e-05 0.0 2.556473214285714e-05 0.0 2.556529017857143e-05 1.5 2.5577566964285713e-05 1.5 2.5578124999999997e-05 0.0 2.5582589285714284e-05 0.0 2.558314732142857e-05 1.5 2.5595424107142856e-05 1.5 2.5595982142857142e-05 0.0 2.5600446428571426e-05 0.0 2.5601004464285713e-05 1.5 2.5613281249999998e-05 1.5 2.5613839285714285e-05 0.0 2.561830357142857e-05 0.0 2.5618861607142855e-05 1.5 2.563113839285714e-05 1.5 2.5631696428571427e-05 0.0 2.563616071428571e-05 0.0 2.5636718749999998e-05 1.5 2.5648995535714283e-05 1.5 2.564955357142857e-05 0.0 2.5654017857142857e-05 0.0 2.565457589285714e-05 1.5 2.5666852678571428e-05 1.5 2.566741071428571e-05 0.0 2.5671875e-05 0.0 2.5672433035714282e-05 1.5 2.568470982142857e-05 1.5 2.5685267857142854e-05 0.0 2.568973214285714e-05 0.0 2.5690290178571428e-05 1.5 2.5702566964285713e-05 1.5 2.5703125e-05 0.0 2.5707589285714284e-05 0.0 2.570814732142857e-05 1.5 2.5720424107142855e-05 1.5 2.5720982142857142e-05 0.0 2.5725446428571426e-05 0.0 2.5726004464285713e-05 1.5 2.5738281249999998e-05 1.5 2.5738839285714284e-05 0.0 2.5743303571428568e-05 0.0 2.5743861607142855e-05 1.5 2.575613839285714e-05 1.5 2.5756696428571427e-05 0.0 2.5761160714285714e-05 0.0 2.5761718749999997e-05 1.5 2.5773995535714282e-05 1.5 2.577455357142857e-05 0.0 2.5779017857142856e-05 0.0 2.577957589285714e-05 1.5 2.5791852678571428e-05 1.5 2.579241071428571e-05 0.0 2.5796875e-05 0.0 2.5797433035714285e-05 1.5 2.580970982142857e-05 1.5 2.5810267857142857e-05 0.0 2.581473214285714e-05 0.0 2.5815290178571428e-05 1.5 2.5827566964285713e-05 1.5 2.5828125e-05 0.0 2.5832589285714283e-05 0.0 2.583314732142857e-05 1.5 2.5845424107142855e-05 1.5 2.584598214285714e-05 0.0 2.5850446428571426e-05 0.0 2.5851004464285712e-05 1.5 2.5863281249999997e-05 1.5 2.5863839285714284e-05 0.0 2.586830357142857e-05 0.0 2.5868861607142855e-05 1.5 2.588113839285714e-05 1.5 2.5881696428571426e-05 0.0 2.5886160714285714e-05 0.0 2.5886718749999997e-05 1.5 2.5898995535714285e-05 1.5 2.589955357142857e-05 0.0 2.5904017857142856e-05 0.0 2.5904575892857143e-05 1.5 2.5916852678571428e-05 1.5 2.591741071428571e-05 0.0 2.5921874999999998e-05 0.0 2.5922433035714285e-05 1.5 2.593470982142857e-05 1.5 2.5935267857142857e-05 0.0 2.593973214285714e-05 0.0 2.5940290178571427e-05 1.5 2.5952566964285712e-05 1.5 2.5953125e-05 0.0 2.5957589285714283e-05 0.0 2.595814732142857e-05 1.5 2.5970424107142855e-05 1.5 2.597098214285714e-05 0.0 2.5975446428571425e-05 0.0 2.5976004464285712e-05 1.5 2.5988281249999997e-05 1.5 2.5988839285714284e-05 0.0 2.599330357142857e-05 0.0 2.5993861607142854e-05 1.5 2.6006138392857143e-05 1.5 2.6006696428571426e-05 0.0 2.6011160714285713e-05 0.0 2.6011718749999997e-05 1.5 2.6023995535714285e-05 1.5 2.6024553571428568e-05 0.0 2.6029017857142856e-05 0.0 2.6029575892857142e-05 1.5 2.6041852678571427e-05 1.5 2.6042410714285714e-05 0.0 2.6046874999999998e-05 0.0 2.6047433035714285e-05 1.5 2.605970982142857e-05 1.5 2.6060267857142856e-05 0.0 2.606473214285714e-05 0.0 2.6065290178571427e-05 1.5 2.6077566964285712e-05 1.5 2.6078125e-05 0.0 2.6082589285714282e-05 0.0 2.608314732142857e-05 1.5 2.6095424107142854e-05 1.5 2.609598214285714e-05 0.0 2.6100446428571428e-05 0.0 2.610100446428571e-05 1.5 2.6113281249999996e-05 1.5 2.6113839285714283e-05 0.0 2.611830357142857e-05 0.0 2.6118861607142854e-05 1.5 2.6131138392857142e-05 1.5 2.6131696428571426e-05 0.0 2.6136160714285713e-05 0.0 2.613671875e-05 1.5 2.6148995535714285e-05 1.5 2.6149553571428568e-05 0.0 2.6154017857142855e-05 0.0 2.6154575892857142e-05 1.5 2.6166852678571427e-05 1.5 2.6167410714285714e-05 0.0 2.6171874999999997e-05 0.0 2.6172433035714284e-05 1.5 2.618470982142857e-05 1.5 2.6185267857142856e-05 0.0 2.618973214285714e-05 0.0 2.6190290178571427e-05 1.5 2.620256696428571e-05 1.5 2.6203124999999998e-05 0.0 2.6207589285714282e-05 0.0 2.620814732142857e-05 1.5 2.6220424107142854e-05 1.5 2.622098214285714e-05 0.0 2.6225446428571428e-05 0.0 2.622600446428571e-05 1.5 2.623828125e-05 1.5 2.6238839285714283e-05 0.0 2.624330357142857e-05 0.0 2.6243861607142857e-05 1.5 2.6256138392857142e-05 1.5 2.6256696428571425e-05 0.0 2.6261160714285712e-05 0.0 2.626171875e-05 1.5 2.6273995535714284e-05 1.5 2.627455357142857e-05 0.0 2.6279017857142855e-05 0.0 2.627957589285714e-05 1.5 2.6291852678571427e-05 1.5 2.6292410714285713e-05 0.0 2.6296874999999997e-05 0.0 2.6297433035714284e-05 1.5 2.630970982142857e-05 1.5 2.6310267857142856e-05 0.0 2.631473214285714e-05 0.0 2.6315290178571426e-05 1.5 2.632756696428571e-05 1.5 2.6328124999999998e-05 0.0 2.6332589285714285e-05 0.0 2.633314732142857e-05 1.5 2.6345424107142857e-05 1.5 2.634598214285714e-05 0.0 2.6350446428571428e-05 0.0 2.635100446428571e-05 1.5 2.636328125e-05 1.5 2.6363839285714283e-05 0.0 2.636830357142857e-05 0.0 2.6368861607142857e-05 1.5 2.638113839285714e-05 1.5 2.6381696428571428e-05 0.0 2.6386160714285712e-05 0.0 2.638671875e-05 1.5 2.6398995535714284e-05 1.5 2.639955357142857e-05 0.0 2.6404017857142854e-05 0.0 2.640457589285714e-05 1.5 2.6416852678571426e-05 1.5 2.6417410714285713e-05 0.0 2.6421874999999997e-05 0.0 2.6422433035714284e-05 1.5 2.643470982142857e-05 1.5 2.6435267857142855e-05 0.0 2.6439732142857143e-05 0.0 2.6440290178571426e-05 1.5 2.645256696428571e-05 1.5 2.6453124999999998e-05 0.0 2.6457589285714285e-05 0.0 2.6458147321428568e-05 1.5 2.6470424107142857e-05 1.5 2.647098214285714e-05 0.0 2.6475446428571427e-05 0.0 2.6476004464285714e-05 1.5 2.648828125e-05 1.5 2.6488839285714282e-05 0.0 2.649330357142857e-05 0.0 2.6493861607142856e-05 1.5 2.650613839285714e-05 1.5 2.6506696428571428e-05 0.0 2.6511160714285712e-05 0.0 2.651171875e-05 1.5 2.6523995535714283e-05 1.5 2.652455357142857e-05 0.0 2.6529017857142854e-05 0.0 2.652957589285714e-05 1.5 2.6541852678571426e-05 1.5 2.6542410714285713e-05 0.0 2.6546874999999996e-05 0.0 2.6547433035714283e-05 1.5 2.6559709821428568e-05 1.5 2.6560267857142855e-05 0.0 2.6564732142857142e-05 0.0 2.6565290178571426e-05 1.5 2.6577566964285714e-05 1.5 2.6578124999999997e-05 0.0 2.6582589285714284e-05 0.0 2.6583147321428568e-05 1.5 2.6595424107142856e-05 1.5 2.659598214285714e-05 0.0 2.6600446428571427e-05 0.0 2.6601004464285714e-05 1.5 2.661328125e-05 1.5 2.6613839285714285e-05 0.0 2.661830357142857e-05 0.0 2.6618861607142856e-05 1.5 2.663113839285714e-05 1.5 2.6631696428571428e-05 0.0 2.663616071428571e-05 0.0 2.6636718749999998e-05 1.5 2.6648995535714283e-05 1.5 2.664955357142857e-05 0.0 2.6654017857142854e-05 0.0 2.665457589285714e-05 1.5 2.6666852678571425e-05 1.5 2.6667410714285712e-05 0.0 2.6671875e-05 0.0 2.6672433035714283e-05 1.5 2.668470982142857e-05 1.5 2.6685267857142855e-05 0.0 2.6689732142857142e-05 0.0 2.6690290178571425e-05 1.5 2.6702566964285713e-05 1.5 2.6703124999999997e-05 0.0 2.6707589285714284e-05 0.0 2.670814732142857e-05 1.5 2.6720424107142856e-05 1.5 2.6720982142857143e-05 0.0 2.6725446428571426e-05 0.0 2.6726004464285713e-05 1.5 2.6738281249999998e-05 1.5 2.6738839285714285e-05 0.0 2.674330357142857e-05 0.0 2.6743861607142856e-05 1.5 2.675613839285714e-05 1.5 2.6756696428571427e-05 0.0 2.676116071428571e-05 0.0 2.6761718749999998e-05 1.5 2.6773995535714283e-05 1.5 2.677455357142857e-05 0.0 2.6779017857142857e-05 0.0 2.677957589285714e-05 1.5 2.6791852678571425e-05 1.5 2.6792410714285712e-05 0.0 2.6796875e-05 0.0 2.6797433035714283e-05 1.5 2.680970982142857e-05 1.5 2.6810267857142854e-05 0.0 2.681473214285714e-05 0.0 2.6815290178571428e-05 1.5 2.6827566964285713e-05 1.5 2.6828124999999997e-05 0.0 2.6832589285714284e-05 0.0 2.683314732142857e-05 1.5 2.6845424107142855e-05 1.5 2.6845982142857142e-05 0.0 2.6850446428571426e-05 0.0 2.6851004464285713e-05 1.5 2.6863281249999998e-05 1.5 2.6863839285714285e-05 0.0 2.686830357142857e-05 0.0 2.6868861607142855e-05 1.5 2.688113839285714e-05 1.5 2.6881696428571427e-05 0.0 2.688616071428571e-05 0.0 2.6886718749999998e-05 1.5 2.6898995535714282e-05 1.5 2.689955357142857e-05 0.0 2.6904017857142856e-05 0.0 2.690457589285714e-05 1.5 2.6916852678571428e-05 1.5 2.691741071428571e-05 0.0 2.6921875e-05 0.0 2.6922433035714282e-05 1.5 2.693470982142857e-05 1.5 2.6935267857142854e-05 0.0 2.693973214285714e-05 0.0 2.6940290178571428e-05 1.5 2.6952566964285713e-05 1.5 2.6953125e-05 0.0 2.6957589285714283e-05 0.0 2.695814732142857e-05 1.5 2.6970424107142855e-05 1.5 2.6970982142857142e-05 0.0 2.6975446428571426e-05 0.0 2.6976004464285713e-05 1.5 2.6988281249999997e-05 1.5 2.6988839285714284e-05 0.0 2.6993303571428568e-05 0.0 2.6993861607142855e-05 1.5 2.700613839285714e-05 1.5 2.7006696428571427e-05 0.0 2.7011718749999997e-05 0.0 2.7012276785714284e-05 1.5 2.70234375e-05 1.5 2.7023995535714285e-05 0.0 2.702957589285714e-05 0.0 2.7030133928571426e-05 1.5 2.704129464285714e-05 1.5 2.7041852678571428e-05 0.0 2.7047433035714285e-05 0.0 2.704799107142857e-05 1.5 2.7059151785714283e-05 1.5 2.705970982142857e-05 0.0 2.7065290178571428e-05 0.0 2.706584821428571e-05 1.5 2.7077008928571426e-05 1.5 2.7077566964285712e-05 0.0 2.708314732142857e-05 0.0 2.7083705357142857e-05 1.5 2.7094866071428568e-05 1.5 2.7095424107142855e-05 0.0 2.7101004464285712e-05 0.0 2.71015625e-05 1.5 2.7112723214285714e-05 1.5 2.7113281249999997e-05 0.0 2.7118861607142854e-05 0.0 2.711941964285714e-05 1.5 2.7130580357142856e-05 1.5 2.713113839285714e-05 0.0 2.7136718749999997e-05 0.0 2.7137276785714284e-05 1.5 2.71484375e-05 1.5 2.7148995535714285e-05 0.0 2.7154575892857143e-05 0.0 2.7155133928571426e-05 1.5 2.716629464285714e-05 1.5 2.7166852678571427e-05 0.0 2.7172433035714285e-05 0.0 2.7172991071428568e-05 1.5 2.7184151785714283e-05 1.5 2.718470982142857e-05 0.0 2.7190290178571427e-05 0.0 2.7190848214285714e-05 1.5 2.7202008928571425e-05 1.5 2.7202566964285712e-05 0.0 2.720814732142857e-05 0.0 2.7208705357142856e-05 1.5 2.721986607142857e-05 1.5 2.7220424107142854e-05 0.0 2.7226004464285712e-05 0.0 2.72265625e-05 1.5 2.7237723214285713e-05 1.5 2.7238281249999997e-05 0.0 2.7243861607142854e-05 0.0 2.724441964285714e-05 1.5 2.7255580357142856e-05 1.5 2.7256138392857142e-05 0.0 2.7261718749999996e-05 0.0 2.7262276785714283e-05 1.5 2.7273437499999998e-05 1.5 2.7273995535714285e-05 0.0 2.7279575892857142e-05 0.0 2.7280133928571426e-05 1.5 2.729129464285714e-05 1.5 2.7291852678571427e-05 0.0 2.7297433035714284e-05 0.0 2.7297991071428568e-05 1.5 2.7309151785714283e-05 1.5 2.730970982142857e-05 0.0 2.7315290178571427e-05 0.0 2.7315848214285714e-05 1.5 2.7327008928571425e-05 1.5 2.7327566964285712e-05 0.0 2.733314732142857e-05 0.0 2.7333705357142856e-05 1.5 2.734486607142857e-05 1.5 2.7345424107142854e-05 0.0 2.735100446428571e-05 0.0 2.7351562499999998e-05 1.5 2.7362723214285713e-05 1.5 2.7363281249999996e-05 0.0 2.7368861607142854e-05 0.0 2.736941964285714e-05 1.5 2.7380580357142855e-05 1.5 2.7381138392857142e-05 0.0 2.738671875e-05 0.0 2.7387276785714283e-05 1.5 2.7398437499999998e-05 1.5 2.7398995535714284e-05 0.0 2.7404575892857142e-05 0.0 2.7405133928571425e-05 1.5 2.741629464285714e-05 1.5 2.7416852678571427e-05 0.0 2.742299107142857e-05 0.0 2.7423549107142854e-05 1.5 2.743359375e-05 1.5 2.7434151785714282e-05 0.0 2.7440848214285713e-05 0.0 2.7441406249999997e-05 1.5 2.745145089285714e-05 1.5 2.7452008928571428e-05 0.0 2.7458705357142856e-05 0.0 2.7459263392857142e-05 1.5 2.7469308035714284e-05 1.5 2.746986607142857e-05 0.0 2.7476562499999998e-05 0.0 2.7477120535714285e-05 1.5 2.7487165178571426e-05 1.5 2.7487723214285713e-05 0.0 2.749441964285714e-05 0.0 2.7494977678571427e-05 1.5 2.7505022321428568e-05 1.5 2.7505580357142855e-05 0.0 2.7512276785714283e-05 0.0 2.751283482142857e-05 1.5 2.7522879464285714e-05 1.5 2.7523437499999997e-05 0.0 2.7530133928571428e-05 0.0 2.753069196428571e-05 1.5 2.7540736607142856e-05 1.5 2.754129464285714e-05 0.0 2.754799107142857e-05 0.0 2.7548549107142854e-05 1.5 2.755859375e-05 1.5 2.7559151785714285e-05 0.0 2.7565848214285713e-05 0.0 2.756640625e-05 1.5 2.757645089285714e-05 1.5 2.7577008928571428e-05 0.0 2.7583705357142855e-05 0.0 2.7584263392857142e-05 1.5 2.7594308035714283e-05 1.5 2.759486607142857e-05 0.0 2.7601562499999998e-05 0.0 2.7602120535714284e-05 1.5 2.7612165178571426e-05 1.5 2.7612723214285712e-05 0.0 2.761941964285714e-05 0.0 2.7619977678571427e-05 1.5 2.7630022321428568e-05 1.5 2.7630580357142855e-05 0.0 2.7637276785714282e-05 0.0 2.763783482142857e-05 1.5 2.7647879464285714e-05 1.5 2.7648437499999997e-05 0.0 2.7655133928571428e-05 0.0 2.765569196428571e-05 1.5 2.7665736607142856e-05 1.5 2.766629464285714e-05 0.0 2.767299107142857e-05 0.0 2.7673549107142854e-05 1.5 2.7683593749999998e-05 1.5 2.7684151785714285e-05 0.0 2.7690848214285713e-05 0.0 2.769140625e-05 1.5 2.770145089285714e-05 1.5 2.7702008928571427e-05 0.0 2.7708705357142855e-05 0.0 2.770926339285714e-05 1.5 2.7719308035714283e-05 1.5 2.771986607142857e-05 0.0 2.7726562499999997e-05 0.0 2.7727120535714284e-05 1.5 2.7737165178571425e-05 1.5 2.7737723214285712e-05 0.0 2.774441964285714e-05 0.0 2.7744977678571426e-05 1.5 2.775502232142857e-05 1.5 2.7755580357142854e-05 0.0 2.7762276785714285e-05 0.0 2.776283482142857e-05 1.5 2.7772321428571426e-05 1.5 2.7772879464285713e-05 0.0 2.778069196428571e-05 0.0 2.7781249999999998e-05 1.5 2.779017857142857e-05 1.5 2.7790736607142856e-05 0.0 2.7798549107142857e-05 0.0 2.779910714285714e-05 1.5 2.780803571428571e-05 1.5 2.7808593749999998e-05 0.0 2.781640625e-05 0.0 2.7816964285714282e-05 1.5 2.7825892857142853e-05 1.5 2.782645089285714e-05 0.0 2.783426339285714e-05 0.0 2.7834821428571428e-05 1.5 2.784375e-05 1.5 2.7844308035714283e-05 0.0 2.7852120535714284e-05 0.0 2.785267857142857e-05 1.5 2.786160714285714e-05 1.5 2.7862165178571428e-05 0.0 2.7869977678571426e-05 0.0 2.7870535714285713e-05 1.5 2.7879464285714284e-05 1.5 2.788002232142857e-05 0.0 2.7887834821428568e-05 0.0 2.7888392857142855e-05 1.5 2.7897321428571426e-05 1.5 2.7897879464285713e-05 0.0 2.7905691964285714e-05 0.0 2.7906249999999997e-05 1.5 2.791517857142857e-05 1.5 2.7915736607142855e-05 0.0 2.7923549107142856e-05 0.0 2.792410714285714e-05 1.5 2.793303571428571e-05 1.5 2.7933593749999998e-05 0.0 2.794140625e-05 0.0 2.7941964285714285e-05 1.5 2.7950892857142856e-05 1.5 2.795145089285714e-05 0.0 2.795926339285714e-05 0.0 2.7959821428571428e-05 1.5 2.796875e-05 1.5 2.7969308035714282e-05 0.0 2.7977120535714283e-05 0.0 2.797767857142857e-05 1.5 2.798660714285714e-05 1.5 2.7987165178571428e-05 0.0 2.7994977678571426e-05 0.0 2.7995535714285712e-05 1.5 2.8004464285714283e-05 1.5 2.800502232142857e-05 0.0 2.8012834821428568e-05 0.0 2.8013392857142855e-05 1.5 2.8022321428571426e-05 1.5 2.8022879464285713e-05 0.0 2.8030691964285714e-05 0.0 2.8031249999999997e-05 1.5 2.8040178571428568e-05 1.5 2.8040736607142855e-05 0.0 2.8048549107142856e-05 0.0 2.804910714285714e-05 1.5 2.8058035714285714e-05 1.5 2.8058593749999997e-05 0.0 2.8066406249999998e-05 0.0 2.8066964285714285e-05 1.5 2.8075892857142856e-05 1.5 2.807645089285714e-05 0.0 2.808426339285714e-05 0.0 2.8084821428571427e-05 1.5 2.8093191964285712e-05 1.5 2.809375e-05 0.0 2.810267857142857e-05 0.0 2.8103236607142856e-05 1.5 2.8111049107142854e-05 1.5 2.811160714285714e-05 0.0 2.8120535714285712e-05 0.0 2.812109375e-05 1.5 2.8128906249999996e-05 1.5 2.8129464285714283e-05 0.0 2.8138392857142854e-05 0.0 2.813895089285714e-05 1.5 2.8146763392857142e-05 1.5 2.8147321428571425e-05 0.0 2.8156249999999997e-05 0.0 2.8156808035714283e-05 1.5 2.8164620535714284e-05 1.5 2.8165178571428568e-05 0.0 2.8174107142857142e-05 0.0 2.8174665178571426e-05 1.5 2.8182477678571427e-05 1.5 2.8183035714285713e-05 0.0 2.8191964285714285e-05 0.0 2.8192522321428568e-05 1.5 2.820033482142857e-05 1.5 2.8200892857142856e-05 0.0 2.8209821428571427e-05 0.0 2.8210379464285714e-05 1.5 2.821819196428571e-05 1.5 2.8218749999999998e-05 0.0 2.822767857142857e-05 0.0 2.8228236607142856e-05 1.5 2.8236049107142854e-05 1.5 2.823660714285714e-05 0.0 2.824553571428571e-05 0.0 2.824609375e-05 1.5 2.825390625e-05 1.5 2.8254464285714283e-05 0.0 2.8263392857142854e-05 0.0 2.826395089285714e-05 1.5 2.8271763392857142e-05 1.5 2.8272321428571425e-05 0.0 2.828125e-05 0.0 2.8281808035714283e-05 1.5 2.8289620535714284e-05 1.5 2.829017857142857e-05 0.0 2.8299107142857142e-05 0.0 2.8299665178571425e-05 1.5 2.8307477678571426e-05 1.5 2.8308035714285713e-05 0.0 2.8316964285714284e-05 0.0 2.831752232142857e-05 1.5 2.832533482142857e-05 1.5 2.8325892857142855e-05 0.0 2.8334821428571427e-05 0.0 2.8335379464285713e-05 1.5 2.834319196428571e-05 1.5 2.8343749999999998e-05 0.0 2.835267857142857e-05 0.0 2.8353236607142856e-05 1.5 2.8361049107142857e-05 1.5 2.836160714285714e-05 0.0 2.837053571428571e-05 0.0 2.8371093749999998e-05 1.5 2.837890625e-05 1.5 2.8379464285714282e-05 0.0 2.8388392857142854e-05 0.0 2.838895089285714e-05 1.5 2.839676339285714e-05 1.5 2.8397321428571428e-05 0.0 2.840625e-05 0.0 2.8406808035714283e-05 1.5 2.8414062499999997e-05 1.5 2.8414620535714284e-05 0.0 2.8424665178571425e-05 0.0 2.8425223214285712e-05 1.5 2.843191964285714e-05 1.5 2.8432477678571426e-05 0.0 2.844252232142857e-05 0.0 2.8443080357142854e-05 1.5 2.8449776785714285e-05 1.5 2.845033482142857e-05 0.0 2.8460379464285713e-05 0.0 2.8460937499999996e-05 1.5 2.8467633928571427e-05 1.5 2.846819196428571e-05 0.0 2.8478236607142855e-05 0.0 2.8478794642857142e-05 1.5 2.848549107142857e-05 1.5 2.8486049107142856e-05 0.0 2.8496093749999998e-05 0.0 2.8496651785714284e-05 1.5 2.8503348214285712e-05 1.5 2.850390625e-05 0.0 2.851395089285714e-05 0.0 2.8514508928571427e-05 1.5 2.8521205357142854e-05 1.5 2.852176339285714e-05 0.0 2.8531808035714282e-05 0.0 2.853236607142857e-05 1.5 2.8539062499999997e-05 1.5 2.8539620535714283e-05 0.0 2.8549665178571428e-05 0.0 2.855022321428571e-05 1.5 2.8556919642857142e-05 1.5 2.8557477678571426e-05 0.0 2.856752232142857e-05 0.0 2.8568080357142854e-05 1.5 2.8574776785714285e-05 1.5 2.8575334821428568e-05 0.0 2.8585379464285713e-05 0.0 2.85859375e-05 1.5 2.8592633928571427e-05 1.5 2.8593191964285714e-05 0.0 2.8603236607142855e-05 0.0 2.8603794642857142e-05 1.5 2.861049107142857e-05 1.5 2.8611049107142856e-05 0.0 2.8621093749999997e-05 0.0 2.8621651785714284e-05 1.5 2.862834821428571e-05 1.5 2.862890625e-05 0.0 2.863895089285714e-05 0.0 2.8639508928571426e-05 1.5 2.8646205357142854e-05 1.5 2.864676339285714e-05 0.0 2.8656808035714285e-05 0.0 2.865736607142857e-05 1.5 2.86640625e-05 1.5 2.8664620535714283e-05 0.0 2.8674665178571428e-05 0.0 2.867522321428571e-05 1.5 2.8681919642857142e-05 1.5 2.8682477678571425e-05 0.0 2.869252232142857e-05 0.0 2.8693080357142857e-05 1.5 2.8699776785714284e-05 1.5 2.870033482142857e-05 0.0 2.8710379464285712e-05 0.0 2.87109375e-05 1.5 2.8717633928571427e-05 1.5 2.8718191964285713e-05 0.0 2.8728236607142855e-05 0.0 2.872879464285714e-05 1.5 2.873549107142857e-05 1.5 2.8736049107142856e-05 0.0 2.8746093749999997e-05 0.0 2.8746651785714284e-05 1.5 2.875334821428571e-05 1.5 2.8753906249999998e-05 0.0 2.8764508928571426e-05 0.0 2.8765066964285713e-05 1.5 2.877064732142857e-05 1.5 2.8771205357142854e-05 0.0 2.878236607142857e-05 0.0 2.8782924107142855e-05 1.5 2.8788504464285713e-05 1.5 2.87890625e-05 0.0 2.880022321428571e-05 0.0 2.8800781249999997e-05 1.5 2.8806361607142855e-05 1.5 2.880691964285714e-05 0.0 2.8818080357142856e-05 0.0 2.881863839285714e-05 1.5 2.8824218749999997e-05 1.5 2.8824776785714284e-05 0.0 2.88359375e-05 0.0 2.8836495535714282e-05 1.5 2.884207589285714e-05 1.5 2.8842633928571426e-05 0.0 2.885379464285714e-05 0.0 2.8854352678571428e-05 1.5 2.8859933035714285e-05 1.5 2.886049107142857e-05 0.0 2.8871651785714283e-05 0.0 2.887220982142857e-05 1.5 2.8877790178571428e-05 1.5 2.887834821428571e-05 0.0 2.8889508928571426e-05 0.0 2.8890066964285712e-05 1.5 2.889564732142857e-05 1.5 2.8896205357142857e-05 0.0 2.8907366071428568e-05 0.0 2.8907924107142855e-05 1.5 2.8913504464285712e-05 1.5 2.89140625e-05 0.0 2.8925223214285714e-05 0.0 2.8925781249999997e-05 1.5 2.8931361607142854e-05 1.5 2.893191964285714e-05 0.0 2.8943080357142856e-05 0.0 2.894363839285714e-05 1.5 2.8949218749999997e-05 1.5 2.8949776785714284e-05 0.0 2.89609375e-05 0.0 2.8961495535714285e-05 1.5 2.896707589285714e-05 1.5 2.8967633928571426e-05 0.0 2.897879464285714e-05 0.0 2.8979352678571427e-05 1.5 2.8984933035714285e-05 1.5 2.8985491071428568e-05 0.0 2.8996651785714283e-05 0.0 2.899720982142857e-05 1.5 2.9002790178571427e-05 1.5 2.900334821428571e-05 0.0 2.9014508928571425e-05 0.0 2.9015066964285712e-05 1.5 2.902064732142857e-05 1.5 2.9021205357142856e-05 0.0 2.9032366071428568e-05 0.0 2.9032924107142854e-05 1.5 2.9038504464285712e-05 1.5 2.90390625e-05 0.0 2.9050223214285713e-05 0.0 2.9050781249999997e-05 1.5 2.9056361607142854e-05 1.5 2.905691964285714e-05 0.0 2.9068080357142856e-05 0.0 2.9068638392857142e-05 1.5 2.9074218749999996e-05 1.5 2.9074776785714283e-05 0.0 2.9085937499999998e-05 0.0 2.9086495535714285e-05 1.5 2.9092075892857142e-05 1.5 2.9092633928571426e-05 0.0 2.910379464285714e-05 0.0 2.9104352678571427e-05 1.5 2.9109933035714285e-05 1.5 2.9110491071428568e-05 0.0 2.9121651785714283e-05 0.0 2.912220982142857e-05 1.5 2.9127790178571427e-05 1.5 2.9128348214285714e-05 0.0 2.9139508928571425e-05 0.0 2.9140066964285712e-05 1.5 2.914564732142857e-05 1.5 2.9146205357142856e-05 0.0 2.915736607142857e-05 0.0 2.9157924107142854e-05 1.5 2.916350446428571e-05 1.5 2.9164062499999998e-05 0.0 2.9175781249999996e-05 0.0 2.9176339285714283e-05 1.5 2.918080357142857e-05 1.5 2.9181361607142854e-05 0.0 2.9193638392857142e-05 0.0 2.9194196428571425e-05 1.5 2.9198660714285713e-05 1.5 2.919921875e-05 0.0 2.9211495535714284e-05 0.0 2.9212053571428568e-05 1.5 2.9216517857142855e-05 1.5 2.9217075892857142e-05 0.0 2.9229352678571427e-05 0.0 2.9229910714285714e-05 1.5 2.9234374999999997e-05 1.5 2.9234933035714284e-05 0.0 2.924720982142857e-05 0.0 2.9247767857142856e-05 1.5 2.925223214285714e-05 1.5 2.9252790178571426e-05 0.0 2.926506696428571e-05 0.0 2.9265624999999998e-05 1.5 2.9270089285714282e-05 1.5 2.927064732142857e-05 0.0 2.9282924107142854e-05 0.0 2.928348214285714e-05 1.5 2.9287946428571428e-05 1.5 2.928850446428571e-05 0.0 2.930078125e-05 0.0 2.9301339285714283e-05 1.5 2.930580357142857e-05 1.5 2.9306361607142853e-05 0.0 2.9318638392857142e-05 0.0 2.9319196428571425e-05 1.5 2.9323660714285712e-05 1.5 2.932421875e-05 0.0 2.9336495535714284e-05 0.0 2.933705357142857e-05 1.5 2.9341517857142855e-05 1.5 2.934207589285714e-05 0.0 2.9354352678571426e-05 0.0 2.9354910714285713e-05 1.5 2.9359374999999997e-05 1.5 2.9359933035714284e-05 0.0 2.937220982142857e-05 0.0 2.9372767857142855e-05 1.5 2.937723214285714e-05 1.5 2.9377790178571426e-05 0.0 2.939006696428571e-05 0.0 2.9390624999999998e-05 1.5 2.9395089285714285e-05 1.5 2.939564732142857e-05 0.0 2.9407924107142853e-05 0.0 2.940848214285714e-05 1.5 2.9412946428571427e-05 1.5 2.941350446428571e-05 0.0 2.942578125e-05 0.0 2.9426339285714282e-05 1.5 2.943080357142857e-05 1.5 2.9431361607142856e-05 0.0 2.944363839285714e-05 0.0 2.9444196428571425e-05 1.5 2.9448660714285712e-05 1.5 2.944921875e-05 0.0 2.9461495535714284e-05 0.0 2.946205357142857e-05 1.5 2.9466517857142854e-05 1.5 2.946707589285714e-05 0.0 2.9479352678571426e-05 0.0 2.9479910714285713e-05 1.5 2.9484374999999997e-05 1.5 2.9484933035714283e-05 0.0 2.949720982142857e-05 0.0 2.9497767857142855e-05 1.5 2.9502232142857142e-05 1.5 2.9502790178571426e-05 0.0 2.951506696428571e-05 0.0 2.9515624999999997e-05 1.5 2.9520089285714285e-05 1.5 2.9520647321428568e-05 0.0 2.9532924107142856e-05 0.0 2.953348214285714e-05 1.5 2.9537946428571427e-05 1.5 2.9538504464285714e-05 0.0 2.955078125e-05 0.0 2.9551339285714282e-05 1.5 2.955580357142857e-05 1.5 2.9556361607142856e-05 0.0 2.956863839285714e-05 0.0 2.9569196428571428e-05 1.5 2.9573660714285712e-05 1.5 2.957421875e-05 0.0 2.9586495535714283e-05 0.0 2.958705357142857e-05 1.5 2.9591517857142854e-05 1.5 2.959207589285714e-05 0.0 2.9604352678571426e-05 0.0 2.9604910714285712e-05 1.5 2.9609374999999996e-05 1.5 2.9609933035714283e-05 0.0 2.9622209821428568e-05 0.0 2.9622767857142855e-05 1.5 2.9627232142857142e-05 1.5 2.9627790178571425e-05 0.0 2.9640066964285714e-05 0.0 2.9640624999999997e-05 1.5 2.9645089285714284e-05 1.5 2.9645647321428568e-05 0.0 2.9657924107142856e-05 0.0 2.965848214285714e-05 1.5 2.9662946428571427e-05 1.5 2.9663504464285713e-05 0.0 2.967578125e-05 0.0 2.9676339285714285e-05 1.5 2.968080357142857e-05 1.5 2.9681361607142856e-05 0.0 2.969363839285714e-05 0.0 2.9694196428571427e-05 1.5 2.969866071428571e-05 1.5 2.9699218749999998e-05 0.0 2.9711495535714283e-05 0.0 2.971205357142857e-05 1.5 2.9716517857142854e-05 1.5 2.971707589285714e-05 0.0 2.9729352678571425e-05 0.0 2.9729910714285712e-05 1.5 2.9734375e-05 1.5 2.9734933035714283e-05 0.0 2.9747209821428568e-05 0.0 2.9747767857142854e-05 1.5 2.9752232142857142e-05 1.5 2.9752790178571425e-05 0.0 2.9765066964285713e-05 0.0 2.9765624999999997e-05 1.5 2.9770089285714284e-05 1.5 2.977064732142857e-05 0.0 2.9782924107142856e-05 0.0 2.978348214285714e-05 1.5 2.9787946428571426e-05 1.5 2.9788504464285713e-05 0.0 2.9800781249999998e-05 0.0 2.9801339285714285e-05 1.5 2.980580357142857e-05 1.5 2.9806361607142855e-05 0.0 2.981863839285714e-05 0.0 2.9819196428571427e-05 1.5 2.982366071428571e-05 1.5 2.9824218749999998e-05 0.0 2.9836495535714283e-05 0.0 2.983705357142857e-05 1.5 2.9841517857142853e-05 1.5 2.984207589285714e-05 0.0 2.9854352678571425e-05 0.0 2.9854910714285712e-05 1.5 2.9859375e-05 1.5 2.9859933035714282e-05 0.0 2.987220982142857e-05 0.0 2.9872767857142854e-05 1.5 2.987723214285714e-05 1.5 2.9877790178571428e-05 0.0 2.9890066964285713e-05 0.0 2.9890624999999996e-05 1.5 2.9895089285714284e-05 1.5 2.989564732142857e-05 0.0 2.9907924107142855e-05 0.0 2.9908482142857142e-05 1.5 2.9912946428571426e-05 1.5 2.9913504464285713e-05 0.0 2.9925781249999998e-05 0.0 2.9926339285714284e-05 1.5 2.993080357142857e-05 1.5 2.9931361607142855e-05 0.0 2.994363839285714e-05 0.0 2.9944196428571427e-05 1.5 2.994866071428571e-05 1.5 2.9949218749999997e-05 0.0 2.9961495535714282e-05 0.0 2.996205357142857e-05 1.5 2.9966517857142856e-05 1.5 2.996707589285714e-05 0.0 2.9979352678571428e-05 0.0 2.997991071428571e-05 1.5 2.9984375e-05 1.5 2.9984933035714282e-05 0.0 2.999720982142857e-05 0.0 2.9997767857142854e-05 1.5 3.000223214285714e-05 1.5 3.0002790178571428e-05 0.0 3.0015066964285713e-05 0.0 3.0015625e-05 1.5 3.0020089285714283e-05 1.5 3.002064732142857e-05 0.0 3.0032924107142855e-05 0.0 3.0033482142857142e-05 1.5 3.0037946428571426e-05 1.5 3.0038504464285712e-05 0.0 3.0050781249999997e-05 0.0 3.0051339285714284e-05 1.5 3.0055803571428568e-05 1.5 3.0056361607142855e-05 0.0 3.006863839285714e-05 0.0 3.0069196428571426e-05 1.5 3.0073660714285714e-05 1.5 3.0074218749999997e-05 0.0 3.0086495535714282e-05 0.0 3.008705357142857e-05 1.5 3.0091517857142856e-05 1.5 3.009207589285714e-05 0.0 3.0104352678571428e-05 0.0 3.010491071428571e-05 1.5 3.0109375e-05 1.5 3.0109933035714285e-05 0.0 3.012220982142857e-05 0.0 3.0122767857142853e-05 1.5 3.012723214285714e-05 1.5 3.0127790178571427e-05 0.0 3.0140066964285712e-05 0.0 3.0140625e-05 1.5 3.0145089285714283e-05 1.5 3.014564732142857e-05 0.0 3.0157924107142855e-05 0.0 3.015848214285714e-05 1.5 3.0162946428571425e-05 1.5 3.0163504464285712e-05 0.0 3.0175781249999997e-05 0.0 3.0176339285714284e-05 1.5 3.0180803571428568e-05 1.5 3.0181361607142854e-05 0.0 3.019363839285714e-05 0.0 3.0194196428571426e-05 1.5 3.0198660714285713e-05 1.5 3.0199218749999997e-05 0.0 3.0211495535714285e-05 0.0 3.021205357142857e-05 1.5 3.0216517857142856e-05 1.5 3.021707589285714e-05 0.0 3.0229352678571427e-05 0.0 3.022991071428571e-05 1.5 3.0234374999999998e-05 1.5 3.0234933035714285e-05 0.0 3.024720982142857e-05 0.0 3.0247767857142856e-05 1.5 3.025223214285714e-05 1.5 3.0252790178571427e-05 0.0 3.0265066964285712e-05 0.0 3.0265625e-05 1.5 3.0270089285714283e-05 1.5 3.027064732142857e-05 0.0 3.0282924107142854e-05 0.0 3.028348214285714e-05 1.5 3.0287946428571425e-05 1.5 3.0288504464285712e-05 0.0 3.0300781249999997e-05 0.0 3.0301339285714283e-05 1.5 3.030580357142857e-05 1.5 3.0306361607142854e-05 0.0 3.0318638392857142e-05 0.0 3.0319196428571426e-05 1.5 3.0323660714285713e-05 1.5 3.0324218749999996e-05 0.0 3.0336495535714285e-05 0.0 3.0337053571428568e-05 1.5 3.0341517857142855e-05 1.5 3.0342075892857142e-05 0.0 3.0354352678571427e-05 0.0 3.0354910714285714e-05 1.5 3.0359374999999998e-05 1.5 3.0359933035714284e-05 0.0 3.037220982142857e-05 0.0 3.0372767857142856e-05 1.5 3.037723214285714e-05 1.5 3.0377790178571427e-05 0.0 3.039006696428571e-05 0.0 3.0390625e-05 1.5 3.0395089285714282e-05 1.5 3.039564732142857e-05 0.0 3.0407924107142854e-05 0.0 3.040848214285714e-05 1.5 3.0412946428571428e-05 1.5 3.041350446428571e-05 0.0 3.0425781249999996e-05 0.0 3.0426339285714283e-05 1.5 3.043080357142857e-05 1.5 3.0431361607142854e-05 0.0 3.0443638392857142e-05 0.0 3.0444196428571425e-05 1.5 3.0448660714285713e-05 1.5 3.044921875e-05 0.0 3.0461495535714284e-05 0.0 3.0462053571428568e-05 1.5 3.0466517857142855e-05 1.5 3.0467075892857142e-05 0.0 3.0479352678571427e-05 0.0 3.0479910714285713e-05 1.5 3.0484374999999997e-05 1.5 3.0484933035714284e-05 0.0 3.049720982142857e-05 0.0 3.0497767857142856e-05 1.5 3.050223214285714e-05 1.5 3.0502790178571426e-05 0.0 3.051506696428571e-05 0.0 3.0515624999999998e-05 1.5 3.0520089285714285e-05 1.5 3.052064732142857e-05 0.0 3.053292410714286e-05 0.0 3.053348214285714e-05 1.5 3.053794642857143e-05 1.5 3.053850446428571e-05 0.0 3.055078125e-05 0.0 3.055133928571428e-05 1.5 3.055580357142857e-05 1.5 3.055636160714285e-05 0.0 3.056863839285714e-05 0.0 3.0569196428571425e-05 1.5 3.057366071428571e-05 1.5 3.0574218749999996e-05 0.0 3.0586495535714284e-05 0.0 3.058705357142857e-05 1.5 3.0591517857142855e-05 1.5 3.059207589285714e-05 0.0 3.0604352678571426e-05 0.0 3.060491071428571e-05 1.5 3.0609375e-05 1.5 3.060993303571428e-05 0.0 3.062220982142857e-05 0.0 3.062276785714285e-05 1.5 3.062723214285714e-05 1.5 3.062779017857143e-05 0.0 3.064006696428571e-05 0.0 3.0640625e-05 1.5 3.064508928571428e-05 1.5 3.064564732142857e-05 0.0 3.065792410714285e-05 0.0 3.0658482142857143e-05 1.5 3.0662946428571424e-05 1.5 3.0663504464285714e-05 0.0 3.0675781249999996e-05 0.0 3.0676339285714286e-05 1.5 3.0680803571428566e-05 1.5 3.0681361607142856e-05 0.0 3.069363839285714e-05 0.0 3.069419642857143e-05 1.5 3.0698660714285715e-05 1.5 3.069921875e-05 0.0 3.071149553571428e-05 0.0 3.071205357142857e-05 1.5 3.071651785714286e-05 1.5 3.071707589285714e-05 0.0 3.072935267857143e-05 0.0 3.072991071428571e-05 1.5 3.0734375e-05 1.5 3.073493303571428e-05 0.0 3.074720982142857e-05 0.0 3.0747767857142855e-05 1.5 3.075223214285714e-05 1.5 3.0752790178571426e-05 0.0 3.0765066964285714e-05 0.0 3.0765625e-05 1.5 3.0770089285714285e-05 1.5 3.077064732142857e-05 0.0 3.0782924107142856e-05 0.0 3.078348214285714e-05 1.5 3.078794642857143e-05 1.5 3.078850446428571e-05 0.0 3.080078125e-05 0.0 3.080133928571428e-05 1.5 3.080580357142857e-05 1.5 3.080636160714285e-05 0.0 3.081863839285714e-05 0.0 3.0819196428571424e-05 1.5 3.082366071428571e-05 1.5 3.0824218749999995e-05 0.0 3.083649553571428e-05 0.0 3.083705357142857e-05 1.5 3.0841517857142854e-05 1.5 3.084207589285714e-05 0.0 3.0854352678571426e-05 0.0 3.085491071428571e-05 1.5 3.0859374999999996e-05 1.5 3.0859933035714286e-05 0.0 3.087220982142857e-05 0.0 3.087276785714286e-05 1.5 3.087723214285714e-05 1.5 3.087779017857143e-05 0.0 3.089006696428571e-05 0.0 3.0890625e-05 1.5 3.089508928571428e-05 1.5 3.089564732142857e-05 0.0 3.090792410714285e-05 0.0 3.090848214285714e-05 1.5 3.091294642857142e-05 1.5 3.091350446428571e-05 0.0 3.0925781249999995e-05 0.0 3.0926339285714285e-05 1.5 3.093080357142857e-05 1.5 3.0931361607142856e-05 0.0 3.0943638392857144e-05 0.0 3.094419642857143e-05 1.5 3.0948660714285715e-05 1.5 3.094921875e-05 0.0 3.0961495535714286e-05 0.0 3.096205357142857e-05 1.5 3.096651785714286e-05 1.5 3.096707589285714e-05 0.0 3.097935267857143e-05 0.0 3.097991071428571e-05 1.5 3.0984375e-05 1.5 3.098493303571428e-05 0.0 3.099720982142857e-05 0.0 3.0997767857142854e-05 1.5 3.100223214285714e-05 1.5 3.1002790178571425e-05 0.0 3.101506696428571e-05 0.0 3.1015625e-05 1.5 3.102064732142857e-05 1.5 3.102120535714286e-05 0.0 3.103236607142857e-05 0.0 3.1032924107142856e-05 1.5 3.103850446428571e-05 1.5 3.10390625e-05 0.0 3.1050223214285715e-05 0.0 3.105078125e-05 1.5 3.105636160714285e-05 1.5 3.105691964285714e-05 0.0 3.106808035714286e-05 0.0 3.106863839285714e-05 1.5 3.107421875e-05 1.5 3.1074776785714284e-05 0.0 3.10859375e-05 0.0 3.108649553571428e-05 1.5 3.109207589285714e-05 1.5 3.109263392857143e-05 0.0 3.110379464285714e-05 0.0 3.1104352678571425e-05 1.5 3.1109933035714286e-05 1.5 3.111049107142857e-05 0.0 3.1121651785714284e-05 0.0 3.112220982142857e-05 1.5 3.112779017857143e-05 1.5 3.112834821428571e-05 0.0 3.1139508928571426e-05 0.0 3.114006696428571e-05 1.5 3.114564732142857e-05 1.5 3.1146205357142854e-05 0.0 3.115736607142857e-05 0.0 3.115792410714285e-05 1.5 3.116350446428571e-05 1.5 3.1164062499999996e-05 0.0 3.117522321428571e-05 0.0 3.117578125e-05 1.5 3.1181361607142855e-05 1.5 3.118191964285714e-05 0.0 3.119308035714285e-05 0.0 3.119363839285714e-05 1.5 3.119921875e-05 1.5 3.119977678571428e-05 0.0 3.1210937499999995e-05 0.0 3.1211495535714286e-05 1.5 3.121707589285714e-05 1.5 3.121763392857142e-05 0.0 3.122879464285714e-05 0.0 3.122935267857143e-05 1.5 3.123493303571428e-05 1.5 3.123549107142857e-05 0.0 3.124665178571428e-05 0.0 3.124720982142857e-05 1.5 3.1252790178571424e-05 1.5 3.1253348214285714e-05 0.0 3.126450892857143e-05 0.0 3.126506696428571e-05 1.5 3.1270647321428567e-05 1.5 3.127120535714286e-05 0.0 3.128236607142857e-05 0.0 3.1282924107142855e-05 1.5 3.128850446428571e-05 1.5 3.12890625e-05 0.0 3.1300223214285714e-05 0.0 3.130078125e-05 1.5 3.130636160714286e-05 1.5 3.130691964285714e-05 0.0 3.1318080357142856e-05 0.0 3.131863839285714e-05 1.5 3.132421875e-05 1.5 3.1324776785714284e-05 0.0 3.13359375e-05 0.0 3.133649553571428e-05 1.5 3.134207589285714e-05 1.5 3.1342633928571426e-05 0.0 3.135379464285714e-05 0.0 3.1354352678571424e-05 1.5 3.1359933035714285e-05 1.5 3.136049107142857e-05 0.0 3.137165178571428e-05 0.0 3.1372209821428567e-05 1.5 3.137779017857143e-05 1.5 3.137834821428571e-05 0.0 3.1389508928571425e-05 0.0 3.139006696428571e-05 1.5 3.139564732142857e-05 1.5 3.139620535714285e-05 0.0 3.140736607142857e-05 0.0 3.140792410714286e-05 1.5 3.141350446428571e-05 1.5 3.1414062499999995e-05 0.0 3.142522321428571e-05 0.0 3.142578125e-05 1.5 3.1431361607142854e-05 1.5 3.143191964285714e-05 0.0 3.144252232142857e-05 0.0 3.144308035714285e-05 1.5 3.144977678571429e-05 1.5 3.145033482142857e-05 0.0 3.146037946428571e-05 0.0 3.1460937499999995e-05 1.5 3.146763392857143e-05 1.5 3.146819196428571e-05 0.0 3.1478236607142854e-05 0.0 3.1478794642857144e-05 1.5 3.148549107142857e-05 1.5 3.1486049107142855e-05 0.0 3.1496093749999996e-05 0.0 3.1496651785714286e-05 1.5 3.1503348214285714e-05 1.5 3.150390625e-05 0.0 3.151395089285714e-05 0.0 3.151450892857143e-05 1.5 3.1521205357142856e-05 1.5 3.152176339285714e-05 0.0 3.153180803571428e-05 0.0 3.153236607142857e-05 1.5 3.15390625e-05 1.5 3.153962053571428e-05 0.0 3.154966517857142e-05 0.0 3.155022321428571e-05 1.5 3.155691964285714e-05 1.5 3.1557477678571424e-05 0.0 3.156752232142857e-05 0.0 3.1568080357142855e-05 1.5 3.157477678571428e-05 1.5 3.1575334821428566e-05 0.0 3.1585379464285714e-05 0.0 3.15859375e-05 1.5 3.1592633928571425e-05 1.5 3.159319196428571e-05 0.0 3.160323660714286e-05 0.0 3.160379464285714e-05 1.5 3.161049107142857e-05 1.5 3.161104910714286e-05 0.0 3.162109375e-05 0.0 3.162165178571428e-05 1.5 3.162834821428571e-05 1.5 3.162890625e-05 0.0 3.163895089285714e-05 0.0 3.1639508928571425e-05 1.5 3.164620535714285e-05 1.5 3.164676339285714e-05 0.0 3.1656808035714284e-05 0.0 3.165736607142857e-05 1.5 3.1664062499999995e-05 1.5 3.1664620535714285e-05 0.0 3.1674665178571426e-05 0.0 3.167522321428571e-05 1.5 3.1681919642857144e-05 1.5 3.168247767857143e-05 0.0 3.169252232142857e-05 0.0 3.169308035714285e-05 1.5 3.1699776785714286e-05 1.5 3.170033482142857e-05 0.0 3.171037946428571e-05 0.0 3.17109375e-05 1.5 3.171763392857143e-05 1.5 3.171819196428571e-05 0.0 3.172823660714285e-05 0.0 3.172879464285714e-05 1.5 3.173549107142857e-05 1.5 3.1736049107142854e-05 0.0 3.1746093749999995e-05 0.0 3.1746651785714285e-05 1.5 3.175334821428571e-05 1.5 3.1753906249999996e-05 0.0 3.176395089285714e-05 0.0 3.176450892857143e-05 1.5 3.1771205357142855e-05 1.5 3.177176339285714e-05 0.0 3.178125e-05 0.0 3.178180803571429e-05 1.5 3.178962053571428e-05 1.5 3.179017857142857e-05 0.0 3.179910714285714e-05 0.0 3.179966517857143e-05 1.5 3.180747767857142e-05 1.5 3.1808035714285713e-05 0.0 3.181696428571428e-05 0.0 3.181752232142857e-05 1.5 3.182533482142857e-05 1.5 3.1825892857142856e-05 0.0 3.1834821428571424e-05 0.0 3.1835379464285714e-05 1.5 3.1843191964285715e-05 1.5 3.184375e-05 0.0 3.1852678571428566e-05 0.0 3.1853236607142856e-05 1.5 3.186104910714286e-05 1.5 3.186160714285714e-05 0.0 3.1870535714285715e-05 0.0 3.187109375e-05 1.5 3.187890625e-05 1.5 3.187946428571428e-05 0.0 3.188839285714286e-05 0.0 3.188895089285714e-05 1.5 3.189676339285714e-05 1.5 3.1897321428571425e-05 0.0 3.190625e-05 0.0 3.190680803571428e-05 1.5 3.1914620535714284e-05 1.5 3.191517857142857e-05 0.0 3.192410714285714e-05 0.0 3.1924665178571425e-05 1.5 3.1932477678571426e-05 1.5 3.193303571428571e-05 0.0 3.1941964285714284e-05 0.0 3.194252232142857e-05 1.5 3.195033482142857e-05 1.5 3.195089285714285e-05 0.0 3.195982142857143e-05 0.0 3.196037946428571e-05 1.5 3.196819196428571e-05 1.5 3.1968749999999994e-05 0.0 3.197767857142857e-05 0.0 3.197823660714285e-05 1.5 3.198604910714285e-05 1.5 3.1986607142857144e-05 0.0 3.199553571428571e-05 0.0 3.1996093749999995e-05 1.5 3.2003906249999996e-05 1.5 3.2004464285714286e-05 0.0 3.2013392857142854e-05 0.0 3.2013950892857144e-05 1.5 3.202176339285714e-05 1.5 3.202232142857143e-05 0.0 3.2031249999999996e-05 0.0 3.2031808035714286e-05 1.5 3.203962053571428e-05 1.5 3.204017857142857e-05 0.0 3.204910714285714e-05 0.0 3.204966517857143e-05 1.5 3.205747767857143e-05 1.5 3.205803571428571e-05 0.0 3.206696428571428e-05 0.0 3.206752232142857e-05 1.5 3.207533482142857e-05 1.5 3.2075892857142855e-05 0.0 3.208482142857142e-05 0.0 3.208537946428571e-05 1.5 3.2093191964285714e-05 1.5 3.209375e-05 0.0 )"}
C {devices/gnd.sym} 1560 -1540 0 0 {name=l57 lab=GND}
C {lab_pin.sym} 360 -1700 0 0 {name=p1 sig_type=std_logic lab=vinp_I_pwm}
C {lab_pin.sym} 940 -1820 0 0 {name=p12 sig_type=std_logic lab=vinn_I_pwm}
