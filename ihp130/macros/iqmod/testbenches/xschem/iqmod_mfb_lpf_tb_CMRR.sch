** sch_path: ihp130/macros/iqmod/testbenches/xschem/iqmod_mfb_lpf_tb_CMRR.sch
**.subckt iqmod_mfb_lpf_tb_CMRR
C1 voutn_dm GND {Cload} m=1
C2 voutp_dm GND {Cload} m=1
Vcm Vcm GND {Vcm}
E1 vout_dm GND voutp_dm voutn_dm 1
vin vin GND dc 0 ac 1
C3 voutn_cm GND {Cload} m=1
C4 voutp_cm GND {Cload} m=1
E8 vout_cm GND voutp_cm net1 0.5
E10 net1 GND voutn_cm GND -1
VDD VDD GND {VDD}
x1 voutp_dm vinp1 voutn_dm vinn1 VDD GND VDD iqmod_mfb_lpf_pex
x4 voutp_cm vinp2 voutn_cm vinn2 VDD GND VDD iqmod_mfb_lpf_pex
x6 vinp1 vin Vcm GND vinn1 single2dm
x7 vinp2 vin Vcm GND vinn2 single2cm
**** begin user architecture code


.include ../../../netlist/pex/iqmod_mfb_lpf_pex.spice
.param VDD=1.5
.param Vcm=VDD/2
.temp 27
.param Cload=10p
.param vphi=0.5
.param f_min = 10m
.csparam f_min = f_min
.param f_max = 1G
.csparam f_max = f_max
.param fdc = 10
.csparam fdc = fdc
.options savecurrents klu method=gear reltol=1e-3 abstol=1e-12 gmin=1e-12 rshunt=1e12
.control

* save v(vout_dm) v(vout_cm) v(vin)
save all

set wr_vecnames
set wr_singlescale

* User Constants
let f_min = 0.1
let f_max = 1G
let fdc = 1

* Operating Point Analysis
op
remzerovec
write @schname\.raw
set appendwrite

* AC Analysis
ac dec 101 $&const.f_min $&const.f_max
remzerovec
write @schname\.raw

* Plotting Differential Mode Gain
let Adm = v(vout_dm)/v(vin)
let Adm_dB = vdb(Adm)
let Adm_arg = 180/PI*cphase(Adm)
plot Adm_dB Adm_arg ylabel 'Magnitude, Phase'

* Plotting Common Mode Gain
let Acm = v(vout_cm)/v(vin)
let Acm_dB = vdb(Acm)
let Acm_arg = 180/PI*cphase(Acm)
plot Acm_dB Acm_arg ylabel 'Magnitude, Phase'

* Plotting Common Mode Rejection Ratio
* let CMRR = v(vout_dm)/v(vout_cm)
let CMRR = v(Adm)/v(Acm)
let CMRR_dB = vdb(CMRR)
* let CMRR_dB = Adm_dB - Acm_dB
let CMRR_arg = 180/PI*cphase(CMRR)
plot CMRR_dB CMRR_arg ylabel 'Magnitude, Phase'

* Measurements
meas ac CMRRdc_dB find CMRR_dB when frequency = fdc
print CMRRdc_dB

* Write Data
unset appendwrite
set wr_vecnames
set wr_singlescale
wrdata ../plot_simulations/data/iqmod_mfb_lpf_tb_CMRR.txt v(Adm_dB) v(Adm_arg) v(Acm_dB) v(Acm_arg)
+ v(CMRR_dB) v(CMRR_arg)

*quit
.endc



.lib cornerMOSlv.lib mos_tt_mismatch
.lib cornerMOShv.lib mos_tt_mismatch
.lib cornerHBT.lib hbt_typ
.lib cornerRES.lib res_typ
.lib cornerCAP.lib cap_typ
.lib cornerDIO.lib dio_tt


.include [file rootname [file tail [xschem get schname]]].save

**** end user architecture code
**.ends
.GLOBAL GND
.GLOBAL VDD
.end
