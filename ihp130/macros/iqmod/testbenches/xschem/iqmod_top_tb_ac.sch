** sch_path: ihp130/macros/iqmod/testbenches/xschem/iqmod_top_tb_ac.sch
**.subckt iqmod_top_tb_ac
VDD VDD GND {VDD}
Vcm Vcm GND {Vcm}
vin vin GND dc 0 ac 1
E1 vout_I GND voutp_I voutn_I 1
E2 vout_Q GND voutp_Q voutn_Q 1
C1 voutp_Q GND {Cload} m=1
C2 voutn_Q GND {Cload} m=1
C3 voutn_I GND {Cload} m=1
C4 voutp_I GND {Cload} m=1
* noconn #net1
* noconn #net2
* noconn #net3
* noconn #net4
x3 net4 VDD net3 net2 VDD net1 vinp vinn VDD VDD voutp_I vinp vinn VDD VDD voutn_I voutp_Q voutn_Q
+ VDD GND VDD iqmod_top_pex
x6 vinp vin Vcm GND vinn single2dm
**** begin user architecture code


.include ../../../netlist/pex/iqmod_top_pex.spice
.param VDD=1.5
.param Vcm=VDD/2
.temp 27
.param Cload=10p
.options savecurrents klu reltol=1e-3 abstol=1e-12 gmin=1e-12 rshunt=1e12
.control

save all

set wr_vecnames
set wr_singlescale

* User Constants
let f_min = 1
let f_max = 1G
let fdc = 10

* Operating Point Analysis
op
remzerovec
write @schname\.raw
set appendwrite

* AC Analysis
ac dec 101 $&const.f_min $&const.f_max
remzerovec
write @schname\.raw
set appendwrite

* Plotting
let Amag = v(vout_I)/v(vin)
let Amag_dB = vdb(Amag)
let Aarg = 180/PI*cphase(Amag)

plot Amag_dB ylabel 'Magnitude'
plot Aarg ylabel 'Phase'
plot Amag_dB Aarg ylabel 'Magnitude, Phase'

* Measurements
meas ac Adc_cl_dB find Amag_dB when frequency = fdc
print Adc_cl_dB

let Amag_fc = Adc_cl_dB-3
meas ac fcu find frequency when Amag_dB = Amag_fc FALL=1
print fcu

* Write Data
unset appendwrite
set wr_vecnames
set wr_singlescale
wrdata ../plot_simulations/data/iqmod_top_tb_ac.txt v(Amag_dB) v(Aarg)

*quit
.endc



.lib cornerMOSlv.lib mos_tt
.lib cornerMOShv.lib mos_tt
.lib cornerHBT.lib hbt_typ
.lib cornerRES.lib res_typ
.lib cornerCAP.lib cap_typ
.lib cornerDIO.lib dio_tt


.include [file rootname [file tail [xschem get schname]]].save

**** end user architecture code
**.ends
.GLOBAL GND
.GLOBAL VDD
.end
