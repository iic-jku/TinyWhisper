** sch_path: ihp130/macros/iqmod/testbenches/xschem/iqmod_mfb_lpf_ota_core_tb_Zin.sch
**.subckt iqmod_mfb_lpf_ota_core_tb_Zin
VDD VDD GND {VDD}
C1 voutp_dm GND {Cload} m=1
C2 voutn_dm GND {Cload} m=1
C3 voutp_cm GND {Cload} m=1
C4 voutn_cm GND {Cload} m=1
vin_cm vin_cm net1 dc 0 ac 1
Vmeasp vinp net4 0
.save i(vmeasp)
Vmeasn vinn net3 0
.save i(vmeasn)
Vmeas_cm vin_cm net2 0
.save i(vmeas_cm)
Vcm_cm net1 GND {Vcm}
vin_dm vin_dm GND dc 0 ac 1
x4 voutp_dm voutn_dm net3 net4 VDD GND VDD iqmod_mfb_lpf_ota_core_hybrid_bm
x5 voutp_cm voutn_cm net2 net2 VDD GND VDD iqmod_mfb_lpf_ota_core_hybrid_bm
Vcm Vcm GND {Vcm}
x6 vinp vin_dm Vcm GND vinn single2dm
**** begin user architecture code


.include ../../../netlist/pex/iqmod_mfb_lpf_ota_core_hybrid_bm_pex.spice
.param VDD=1.5
.param Vcm=VDD/2
.temp 27
.param Cload=10p
.options savecurrents klu method=gear reltol=1e-4 abstol=1e-15 gmin=1e-15
.control

* save v(vinp) v(vinn) i(Vmeasp) i(Vmeasn) v(vin_cm) i(Vmeas_cm)
save all

set wr_vecnames
set wr_singlescale

* User Constants
let f_min = 0.1
let f_max = 1G
let fdc = 10

* Operating Point Analysis
op
remzerovec
write @schname\.raw
set appendwrite

* AC Analysis
ac dec 101 $&const.f_min $&const.f_max
remzerovec
write @schname\.raw

* Plotting Differential Mode Zin
* let Zin_dm = (v(vinp) - v(vinn)) / (i(Vmeasp) - i(Vmeasn))
* let Zin_dm = (v(vinp) - v(vinn)) / (i(Vmeasp) + i(Vmeasn))
let Zin_dm = (v(vinp) - v(vinn)) / i(Vmeasp)
plot Zin_dm ylabel 'DM Zin'

* Plotting Common Mode Zin
let Zin_cm = v(vin_cm) / i(Vmeas_cm)
plot Zin_cm ylabel 'CM Zin'

* Measurements
meas ac Zindc_dm find Zin_dm when frequency = fdc
print Zindc_dm

meas ac Zindc_cm find Zin_cm when frequency = fdc
print Zindc_cm

* Write Data
unset appendwrite
set wr_vecnames
set wr_singlescale
wrdata ../plot_simulations/data/iqmod_mfb_lpf_ota_core_tb_Zin.txt v(Zin_dm) v(Zin_cm)

*quit
.endc



.lib cornerMOSlv.lib mos_tt
.lib cornerMOShv.lib mos_tt
.lib cornerHBT.lib hbt_typ
.lib cornerRES.lib res_typ
.lib cornerCAP.lib cap_typ
.lib cornerDIO.lib dio_tt


.include [file rootname [file tail [xschem get schname]]].save

**** end user architecture code
**.ends
.GLOBAL GND
.GLOBAL VDD
.end
