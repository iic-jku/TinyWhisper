** sch_path: ihp130/macros/iqmod/testbenches/xschem/iqmod_mixer_se2diff_tb_tran.sch
**.subckt iqmod_mixer_se2diff_tb_tran
VDD VDD GND {VDD}
C1 net1 GND {Cload} m=1
Vloi vin_LO GND pulse(0 {VDD} 0 10p 10p {0.25/flo} {1/flo})
Vin net2 GND {Vcm}
x6 net3 net4 VDD vout_LO GND net1 net2 vout_LO_inv iqmod_mixer_tg
x3 VDD vin_LO vout_LO GND vout_LO_inv iqmod_mixer_se2diff_pex
**** begin user architecture code


.include ../../../netlist/pex/iqmod_mixer_se2diff_pex.spice
.param VDD=1.5
.param Vcm=VDD/2
.temp 27
.param flo=28e6
.csparam flo=flo
.param Rload=1k
.param Cload=10p
.options savecurrents klu method=gear reltol=1e-4 abstol=1e-15 gmin=1e-15
.control
save all

* User Constants
let tstop = 2*1/flo
let tstep = 0.01*1/flo

* Operating Point Analysis
op
remzerovec
write @schname\.raw
set appendwrite

* Transient Analysis
tran $&tstep $&tstop
write @schname\.raw

quit
.endc



.lib cornerMOSlv.lib mos_tt
.lib cornerMOShv.lib mos_tt
.lib cornerHBT.lib hbt_typ
.lib cornerRES.lib res_typ
.lib cornerCAP.lib cap_typ
.lib cornerDIO.lib dio_tt


.include [file rootname [file tail [xschem get schname]]].save

**** end user architecture code
**.ends
.GLOBAL GND
.GLOBAL VDD
.end
