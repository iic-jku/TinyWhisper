** sch_path: ihp130/macros/iqmod/testbenches/xschem/iqmod_spdt_switch_tb_dc_Ron.sch
**.subckt iqmod_spdt_switch_tb_dc_Ron
vds_x1 vin_spdt vout_a_spdt_ca 1mV
vds_x2 vin_spdt vout_b_spdt_cb 1mV
x1 VDD VDD GND vin_spdt net1 vout_a_spdt_ca iqmod_spdt_switch_pex
x2 VDD GND GND vin_spdt vout_b_spdt_cb net2 iqmod_spdt_switch_pex
vin vin_spdt GND {Vcm}
VDD VDD GND {VDD}
**** begin user architecture code


.include ../../../netlist/pex/iqmod_spdt_switch_pex.spice
.param VDD=1.5
.csparam VDD=VDD
.param Vcm=VDD/2
.temp 27
.options savecurrents klu method=gear reltol=1e-4 abstol=1e-15 gmin=1e-15
.control
save all

* Operating Point Analysis
op
remzerovec
write @schname\.raw
set appendwrite

* DC Sweep Analysis
dc vin 0 $&VDD 10m
write @schname\.raw

* On-Resistance v_c to v_a
let r_on_ca = (v(vout_a_spdt_ca)-v(vin_spdt))/I(vds_x1)
plot r_on_ca xlabel 'Vin in V' ylabel 'Ron in Ohm'

* On-Resistance v_c to v_b
let r_on_cb = (v(vout_b_spdt_cb)-v(vin_spdt))/I(vds_x2)
plot r_on_cb xlabel 'Vin in V' ylabel 'Ron in Ohm'

*quit
.endc


.lib cornerMOSlv.lib mos_tt
.lib cornerMOShv.lib mos_tt
.lib cornerHBT.lib hbt_typ
.lib cornerRES.lib res_typ
.lib cornerCAP.lib cap_typ
.lib cornerDIO.lib dio_tt


.include [file rootname [file tail [xschem get schname]]].save

**** end user architecture code
**.ends
.GLOBAL VDD
.GLOBAL GND
.end
