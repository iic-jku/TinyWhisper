C {devices/vsource.sym} 1560 -1610 0 0 {name=vpwm_sine_25 spice_ignore=true hide_texts=true value="dc 0 pwl(0.0 1.5 4.464285714285714e-09 1.5 5.022321428571428e-09 0.0 1.2834821428571427e-08 0.0 1.3392857142857143e-08 1.5 2.232142857142857e-08 1.5 2.2879464285714283e-08 0.0 3.069196428571428e-08 0.0 3.125e-08 1.5 4.0178571428571425e-08 1.5 4.073660714285714e-08 0.0 4.854910714285714e-08 0.0 4.910714285714285e-08 1.5 5.8035714285714284e-08 1.5 5.8593749999999995e-08 0.0 6.640625e-08 0.0 6.696428571428571e-08 1.5 7.589285714285714e-08 1.5 7.645089285714285e-08 0.0 8.426339285714285e-08 0.0 8.482142857142856e-08 1.5 9.374999999999999e-08 1.5 9.430803571428571e-08 0.0 1.021205357142857e-07 0.0 1.0267857142857142e-07 1.5 1.1160714285714285e-07 1.5 1.1216517857142857e-07 0.0 1.1997767857142856e-07 0.0 1.2053571428571428e-07 1.5 1.294642857142857e-07 1.5 1.3002232142857143e-07 0.0 1.378348214285714e-07 0.0 1.3839285714285713e-07 1.5 1.4732142857142856e-07 1.5 1.4787946428571428e-07 0.0 1.5569196428571426e-07 0.0 1.5624999999999999e-07 1.5 1.651785714285714e-07 1.5 1.6573660714285714e-07 0.0 1.7354910714285714e-07 0.0 1.7410714285714284e-07 1.5 1.8303571428571427e-07 1.5 1.8359375e-07 0.0 1.9140625e-07 0.0 1.919642857142857e-07 1.5 2.0089285714285712e-07 1.5 2.0145089285714284e-07 0.0 2.0926339285714285e-07 0.0 2.0982142857142854e-07 1.5 2.1875e-07 1.5 2.193080357142857e-07 0.0 2.271205357142857e-07 0.0 2.2767857142857142e-07 1.5 2.3660714285714285e-07 1.5 2.3716517857142855e-07 0.0 2.4497767857142855e-07 0.0 2.4553571428571425e-07 1.5 2.544642857142857e-07 1.5 2.550223214285714e-07 0.0 2.628348214285714e-07 0.0 2.633928571428571e-07 1.5 2.7232142857142853e-07 1.5 2.728794642857143e-07 0.0 2.8069196428571426e-07 0.0 2.8124999999999995e-07 1.5 2.9017857142857143e-07 1.5 2.9073660714285713e-07 0.0 2.985491071428571e-07 0.0 2.9910714285714286e-07 1.5 3.080357142857143e-07 1.5 3.0859375e-07 0.0 3.1640624999999996e-07 0.0 3.169642857142857e-07 1.5 3.2589285714285714e-07 1.5 3.2645089285714284e-07 0.0 3.342633928571428e-07 0.0 3.3482142857142856e-07 1.5 3.4375e-07 1.5 3.443080357142857e-07 0.0 3.5212053571428567e-07 0.0 3.526785714285714e-07 1.5 3.6160714285714284e-07 1.5 3.6216517857142854e-07 0.0 3.699776785714285e-07 0.0 3.7053571428571427e-07 1.5 3.794642857142857e-07 1.5 3.800223214285714e-07 0.0 3.878348214285714e-07 0.0 3.883928571428571e-07 1.5 3.9732142857142855e-07 1.5 3.9787946428571425e-07 0.0 4.056919642857143e-07 0.0 4.0625e-07 1.5 4.151785714285714e-07 1.5 4.157366071428571e-07 0.0 4.2354910714285713e-07 0.0 4.2410714285714283e-07 1.5 4.3303571428571425e-07 1.5 4.3359374999999995e-07 0.0 4.4140625e-07 0.0 4.419642857142857e-07 1.5 4.508928571428571e-07 1.5 4.514508928571428e-07 0.0 4.5926339285714284e-07 0.0 4.5982142857142853e-07 1.5 4.6874999999999996e-07 1.5 4.6930803571428566e-07 0.0 4.771205357142856e-07 0.0 4.776785714285714e-07 1.5 4.866071428571428e-07 1.5 4.871651785714285e-07 0.0 4.949776785714285e-07 0.0 4.955357142857143e-07 1.5 5.044642857142857e-07 1.5 5.050223214285714e-07 0.0 5.128348214285713e-07 0.0 5.133928571428571e-07 1.5 5.223214285714285e-07 1.5 5.228794642857142e-07 0.0 5.306919642857143e-07 0.0 5.3125e-07 1.5 5.401785714285714e-07 1.5 5.407366071428571e-07 0.0 5.485491071428572e-07 0.0 5.491071428571428e-07 1.5 5.580357142857142e-07 1.5 5.585937499999999e-07 0.0 5.6640625e-07 0.0 5.669642857142857e-07 1.5 5.758928571428571e-07 1.5 5.764508928571428e-07 0.0 5.842633928571429e-07 0.0 5.848214285714286e-07 1.5 5.937499999999999e-07 1.5 5.943080357142856e-07 0.0 6.021205357142857e-07 0.0 6.026785714285714e-07 1.5 6.116071428571428e-07 1.5 6.121651785714285e-07 0.0 6.199776785714286e-07 0.0 6.205357142857143e-07 1.5 6.294642857142856e-07 1.5 6.300223214285714e-07 0.0 6.378348214285714e-07 0.0 6.383928571428571e-07 1.5 6.473214285714285e-07 1.5 6.478794642857143e-07 0.0 6.556919642857143e-07 0.0 6.5625e-07 1.5 6.651785714285713e-07 1.5 6.657366071428571e-07 0.0 6.729910714285714e-07 0.0 6.735491071428571e-07 1.5 6.8359375e-07 1.5 6.841517857142857e-07 0.0 6.908482142857143e-07 0.0 6.9140625e-07 1.5 7.014508928571428e-07 1.5 7.020089285714285e-07 0.0 7.087053571428571e-07 0.0 7.092633928571428e-07 1.5 7.193080357142857e-07 1.5 7.198660714285714e-07 0.0 7.265625e-07 0.0 7.271205357142857e-07 1.5 7.371651785714286e-07 1.5 7.377232142857142e-07 0.0 7.444196428571428e-07 0.0 7.449776785714285e-07 1.5 7.550223214285714e-07 1.5 7.555803571428571e-07 0.0 7.622767857142857e-07 0.0 7.628348214285714e-07 1.5 7.728794642857143e-07 1.5 7.734375e-07 0.0 7.801339285714285e-07 0.0 7.806919642857142e-07 1.5 7.907366071428571e-07 1.5 7.912946428571428e-07 0.0 7.979910714285714e-07 0.0 7.985491071428571e-07 1.5 8.0859375e-07 1.5 8.091517857142857e-07 0.0 8.158482142857142e-07 0.0 8.164062499999999e-07 1.5 8.264508928571428e-07 1.5 8.270089285714285e-07 0.0 8.337053571428571e-07 0.0 8.342633928571428e-07 1.5 8.443080357142857e-07 1.5 8.448660714285714e-07 0.0 8.515624999999999e-07 0.0 8.521205357142856e-07 1.5 8.621651785714285e-07 1.5 8.627232142857142e-07 0.0 8.694196428571428e-07 0.0 8.699776785714285e-07 1.5 8.800223214285714e-07 1.5 8.805803571428571e-07 0.0 8.872767857142857e-07 0.0 8.878348214285713e-07 1.5 8.978794642857142e-07 1.5 8.984374999999999e-07 0.0 9.051339285714285e-07 0.0 9.056919642857142e-07 1.5 9.157366071428571e-07 1.5 9.162946428571428e-07 0.0 9.229910714285714e-07 0.0 9.235491071428571e-07 1.5 9.335937499999999e-07 1.5 9.341517857142856e-07 0.0 9.408482142857142e-07 0.0 9.414062499999999e-07 1.5 9.514508928571428e-07 1.5 9.520089285714285e-07 0.0 9.58705357142857e-07 0.0 9.592633928571428e-07 1.5 9.693080357142857e-07 1.5 9.698660714285714e-07 0.0 9.765625e-07 0.0 9.771205357142857e-07 1.5 9.871651785714285e-07 1.5 9.877232142857142e-07 0.0 9.944196428571428e-07 0.0 9.949776785714285e-07 1.5 1.0050223214285714e-06 1.5 1.0055803571428571e-06 0.0 1.0122767857142857e-06 0.0 1.0128348214285714e-06 1.5 1.0228794642857142e-06 1.5 1.0234374999999999e-06 0.0 1.0301339285714285e-06 0.0 1.0306919642857142e-06 1.5 1.0407366071428572e-06 1.5 1.0412946428571428e-06 0.0 1.0479910714285714e-06 0.0 1.0485491071428571e-06 1.5 1.05859375e-06 1.5 1.0591517857142856e-06 0.0 1.0658482142857142e-06 0.0 1.0664062499999999e-06 1.5 1.0764508928571429e-06 1.5 1.0770089285714286e-06 0.0 1.0837053571428571e-06 0.0 1.0842633928571428e-06 1.5 1.0943080357142856e-06 1.5 1.0948660714285713e-06 0.0 1.1015624999999999e-06 0.0 1.1021205357142856e-06 1.5 1.1121651785714286e-06 1.5 1.1127232142857143e-06 0.0 1.1194196428571428e-06 0.0 1.1199776785714285e-06 1.5 1.1300223214285713e-06 1.5 1.130580357142857e-06 0.0 1.1372767857142856e-06 0.0 1.1378348214285713e-06 1.5 1.1478794642857143e-06 1.5 1.1484375e-06 0.0 1.1551339285714285e-06 0.0 1.1556919642857142e-06 1.5 1.165736607142857e-06 1.5 1.1662946428571427e-06 0.0 1.1729910714285713e-06 0.0 1.173549107142857e-06 1.5 1.18359375e-06 1.5 1.1841517857142857e-06 0.0 1.1908482142857143e-06 0.0 1.19140625e-06 1.5 1.2014508928571427e-06 1.5 1.2020089285714284e-06 0.0 1.208705357142857e-06 0.0 1.2092633928571427e-06 1.5 1.2193080357142857e-06 1.5 1.2198660714285714e-06 0.0 1.2265625e-06 0.0 1.2271205357142857e-06 1.5 1.2371651785714284e-06 1.5 1.2377232142857141e-06 0.0 1.2444196428571427e-06 0.0 1.2449776785714284e-06 1.5 1.2550223214285714e-06 1.5 1.255580357142857e-06 0.0 1.2622767857142857e-06 0.0 1.2628348214285714e-06 1.5 1.2728794642857141e-06 1.5 1.2734374999999998e-06 0.0 1.2801339285714284e-06 0.0 1.280691964285714e-06 1.5 1.290736607142857e-06 1.5 1.2912946428571428e-06 0.0 1.2979910714285714e-06 0.0 1.298549107142857e-06 1.5 1.3085937499999998e-06 1.5 1.3091517857142855e-06 0.0 1.3158482142857141e-06 0.0 1.3164062499999998e-06 1.5 1.3264508928571428e-06 1.5 1.3270089285714285e-06 0.0 1.333705357142857e-06 0.0 1.3342633928571428e-06 1.5 1.3443080357142855e-06 1.5 1.3448660714285712e-06 0.0 1.3515624999999998e-06 0.0 1.3521205357142855e-06 1.5 1.3621651785714285e-06 1.5 1.3627232142857142e-06 0.0 1.3694196428571428e-06 0.0 1.3699776785714285e-06 1.5 1.3800223214285712e-06 1.5 1.380580357142857e-06 0.0 1.3872767857142855e-06 0.0 1.3878348214285714e-06 1.5 1.3978794642857142e-06 1.5 1.3984375e-06 0.0 1.4051339285714285e-06 0.0 1.4056919642857142e-06 1.5 1.415736607142857e-06 1.5 1.4162946428571429e-06 0.0 1.4229910714285712e-06 0.0 1.4235491071428571e-06 1.5 1.43359375e-06 1.5 1.4341517857142856e-06 0.0 1.4408482142857142e-06 0.0 1.4414062499999999e-06 1.5 1.4514508928571427e-06 1.5 1.4520089285714286e-06 0.0 1.458705357142857e-06 0.0 1.4592633928571428e-06 1.5 1.4693080357142856e-06 1.5 1.4698660714285713e-06 0.0 1.4765624999999999e-06 0.0 1.4771205357142856e-06 1.5 1.4871651785714286e-06 1.5 1.4877232142857143e-06 0.0 1.4944196428571429e-06 0.0 1.4949776785714285e-06 1.5 1.5050223214285713e-06 1.5 1.505580357142857e-06 0.0 1.5122767857142856e-06 0.0 1.5128348214285713e-06 1.5 1.5228794642857143e-06 1.5 1.5234375e-06 0.0 1.5301339285714286e-06 0.0 1.5306919642857143e-06 1.5 1.540736607142857e-06 1.5 1.5412946428571427e-06 0.0 1.5479910714285713e-06 0.0 1.548549107142857e-06 1.5 1.55859375e-06 1.5 1.5591517857142857e-06 0.0 1.5658482142857143e-06 0.0 1.56640625e-06 1.5 1.5764508928571427e-06 1.5 1.5770089285714284e-06 0.0 1.583705357142857e-06 0.0 1.5842633928571427e-06 1.5 1.5943080357142857e-06 1.5 1.5948660714285714e-06 0.0 1.6015625e-06 0.0 1.6021205357142857e-06 1.5 1.6121651785714284e-06 1.5 1.6127232142857141e-06 0.0 1.6194196428571427e-06 0.0 1.6199776785714284e-06 1.5 1.6300223214285714e-06 1.5 1.630580357142857e-06 0.0 1.6372767857142857e-06 0.0 1.6378348214285714e-06 1.5 1.6478794642857141e-06 1.5 1.6484374999999998e-06 0.0 1.6551339285714284e-06 0.0 1.6556919642857141e-06 1.5 1.665736607142857e-06 1.5 1.6662946428571428e-06 0.0 1.6729910714285714e-06 0.0 1.673549107142857e-06 1.5 1.6835937499999998e-06 1.5 1.6841517857142855e-06 0.0 1.6908482142857141e-06 0.0 1.6914062499999998e-06 1.5 1.7014508928571428e-06 1.5 1.7020089285714285e-06 0.0 1.708705357142857e-06 0.0 1.7092633928571428e-06 1.5 1.7193080357142855e-06 1.5 1.7198660714285712e-06 0.0 1.7265624999999998e-06 0.0 1.7271205357142855e-06 1.5 1.7371651785714285e-06 1.5 1.7377232142857142e-06 0.0 1.7444196428571428e-06 0.0 1.7449776785714285e-06 1.5 1.7550223214285713e-06 1.5 1.755580357142857e-06 0.0 1.7622767857142855e-06 0.0 1.7628348214285712e-06 1.5 1.7728794642857142e-06 1.5 1.7734375e-06 0.0 1.7801339285714285e-06 0.0 1.7806919642857142e-06 1.5 1.790736607142857e-06 1.5 1.7912946428571427e-06 0.0 1.7979910714285712e-06 0.0 1.798549107142857e-06 1.5 1.80859375e-06 1.5 1.8091517857142856e-06 0.0 1.8158482142857142e-06 0.0 1.8164062499999999e-06 1.5 1.8264508928571427e-06 1.5 1.8270089285714284e-06 0.0 1.833705357142857e-06 0.0 1.8342633928571426e-06 1.5 1.8443080357142856e-06 1.5 1.8448660714285713e-06 0.0 1.8515625e-06 0.0 1.8521205357142856e-06 1.5 1.8621651785714284e-06 1.5 1.862723214285714e-06 0.0 1.8694196428571426e-06 0.0 1.8699776785714283e-06 1.5 1.8800223214285713e-06 1.5 1.880580357142857e-06 0.0 1.8872767857142856e-06 0.0 1.8878348214285713e-06 1.5 1.897879464285714e-06 1.5 1.8984374999999998e-06 0.0 1.9051339285714284e-06 0.0 1.905691964285714e-06 1.5 1.915736607142857e-06 1.5 1.9162946428571427e-06 0.0 1.922991071428571e-06 0.0 1.923549107142857e-06 1.5 1.93359375e-06 1.5 1.9341517857142855e-06 0.0 1.9408482142857143e-06 0.0 1.9414062499999998e-06 1.5 1.9514508928571427e-06 1.5 1.9520089285714282e-06 0.0 1.958705357142857e-06 0.0 1.959263392857143e-06 1.5 1.9693080357142855e-06 1.5 1.9698660714285714e-06 0.0 1.9765624999999998e-06 0.0 1.9771205357142857e-06 1.5 1.9871651785714282e-06 1.5 1.987723214285714e-06 0.0 1.9944196428571425e-06 0.0 1.9949776785714284e-06 1.5 2.0050223214285714e-06 1.5 2.005580357142857e-06 0.0 2.0122767857142857e-06 0.0 2.012834821428571e-06 1.5 2.022879464285714e-06 1.5 2.0234375e-06 0.0 2.0301339285714284e-06 0.0 2.0306919642857143e-06 1.5 2.040736607142857e-06 1.5 2.041294642857143e-06 0.0 2.047991071428571e-06 0.0 2.048549107142857e-06 1.5 2.05859375e-06 1.5 2.0591517857142855e-06 0.0 2.0658482142857143e-06 0.0 2.06640625e-06 1.5 2.076450892857143e-06 1.5 2.0770089285714283e-06 0.0 2.083705357142857e-06 0.0 2.0842633928571426e-06 1.5 2.0943080357142856e-06 1.5 2.0948660714285715e-06 0.0 2.1015625e-06 0.0 2.1021205357142857e-06 1.5 2.1121651785714283e-06 1.5 2.1127232142857142e-06 0.0 2.1194196428571426e-06 0.0 2.1199776785714285e-06 1.5 2.1300223214285715e-06 1.5 2.130580357142857e-06 0.0 2.1372767857142858e-06 0.0 2.1378348214285712e-06 1.5 2.1478794642857142e-06 1.5 2.1484374999999997e-06 0.0 2.1551339285714285e-06 0.0 2.155691964285714e-06 1.5 2.165736607142857e-06 1.5 2.166294642857143e-06 0.0 2.1729910714285712e-06 0.0 2.173549107142857e-06 1.5 2.1835937499999997e-06 1.5 2.1841517857142856e-06 0.0 2.190848214285714e-06 0.0 2.19140625e-06 1.5 2.201450892857143e-06 1.5 2.2020089285714284e-06 0.0 2.208705357142857e-06 0.0 2.2092633928571426e-06 1.5 2.2193080357142856e-06 1.5 2.219866071428571e-06 0.0 2.2265625e-06 0.0 2.2271205357142854e-06 1.5 2.2371651785714284e-06 1.5 2.2377232142857143e-06 0.0 2.2444196428571427e-06 0.0 2.2449776785714286e-06 1.5 2.255022321428571e-06 1.5 2.255580357142857e-06 0.0 2.2622767857142854e-06 0.0 2.2628348214285713e-06 1.5 2.2728794642857143e-06 1.5 2.2734374999999998e-06 0.0 2.2801339285714286e-06 0.0 2.280691964285714e-06 1.5 2.290736607142857e-06 1.5 2.2912946428571425e-06 0.0 2.2979910714285713e-06 0.0 2.298549107142857e-06 1.5 2.3085937499999998e-06 1.5 2.3091517857142857e-06 0.0 2.315848214285714e-06 0.0 2.31640625e-06 1.5 2.3264508928571425e-06 1.5 2.3270089285714284e-06 0.0 2.333705357142857e-06 0.0 2.3342633928571427e-06 1.5 2.3443080357142857e-06 1.5 2.344866071428571e-06 0.0 2.3515625e-06 0.0 2.3521205357142855e-06 1.5 2.3621651785714285e-06 1.5 2.362723214285714e-06 0.0 2.3694196428571427e-06 0.0 2.3699776785714282e-06 1.5 2.380022321428571e-06 1.5 2.380580357142857e-06 0.0 2.3872767857142855e-06 0.0 2.3878348214285714e-06 1.5 2.397879464285714e-06 1.5 2.3984375e-06 0.0 2.4051339285714282e-06 0.0 2.405691964285714e-06 1.5 2.415736607142857e-06 1.5 2.4162946428571426e-06 0.0 2.4229910714285714e-06 0.0 2.423549107142857e-06 1.5 2.43359375e-06 1.5 2.4341517857142853e-06 0.0 2.440848214285714e-06 0.0 2.4414062499999996e-06 1.5 2.4514508928571426e-06 1.5 2.4520089285714285e-06 0.0 2.458705357142857e-06 0.0 2.459263392857143e-06 1.5 2.4693080357142854e-06 1.5 2.4698660714285713e-06 0.0 2.4765624999999996e-06 0.0 2.4771205357142855e-06 1.5 2.4871651785714285e-06 1.5 2.487723214285714e-06 0.0 2.494419642857143e-06 0.0 2.4949776785714283e-06 1.5 2.5050223214285713e-06 1.5 2.5055803571428568e-06 0.0 2.5122767857142856e-06 0.0 2.512834821428571e-06 1.5 2.522879464285714e-06 1.5 2.5234375e-06 0.0 2.5301339285714283e-06 0.0 2.530691964285714e-06 1.5 2.5407366071428568e-06 1.5 2.5412946428571427e-06 0.0 2.547991071428571e-06 0.0 2.548549107142857e-06 1.5 2.55859375e-06 1.5 2.5591517857142854e-06 0.0 2.5658482142857142e-06 0.0 2.5664062499999997e-06 1.5 2.5764508928571427e-06 1.5 2.5770089285714286e-06 0.0 2.583705357142857e-06 0.0 2.584263392857143e-06 1.5 2.5943080357142854e-06 1.5 2.5948660714285713e-06 0.0 2.6015624999999997e-06 0.0 2.6021205357142856e-06 1.5 2.612165178571428e-06 1.5 2.612723214285714e-06 0.0 2.619419642857143e-06 0.0 2.6199776785714284e-06 1.5 2.6300223214285713e-06 1.5 2.630580357142857e-06 0.0 2.6372767857142856e-06 0.0 2.637834821428571e-06 1.5 2.647879464285714e-06 1.5 2.6484375e-06 0.0 2.6551339285714284e-06 0.0 2.6556919642857143e-06 1.5 2.665736607142857e-06 1.5 2.6662946428571427e-06 0.0 2.672991071428571e-06 0.0 2.673549107142857e-06 1.5 2.68359375e-06 1.5 2.6841517857142855e-06 0.0 2.6908482142857143e-06 0.0 2.6914062499999998e-06 1.5 2.7014508928571428e-06 1.5 2.7020089285714282e-06 0.0 2.708705357142857e-06 0.0 2.7092633928571425e-06 1.5 2.7193080357142855e-06 1.5 2.7198660714285714e-06 0.0 2.7265624999999998e-06 0.0 2.7271205357142857e-06 1.5 2.7371651785714282e-06 1.5 2.737723214285714e-06 0.0 2.7444196428571425e-06 0.0 2.7449776785714284e-06 1.5 2.7550223214285714e-06 1.5 2.755580357142857e-06 0.0 2.7622767857142857e-06 0.0 2.762834821428571e-06 1.5 2.772879464285714e-06 1.5 2.7734374999999997e-06 0.0 2.7801339285714284e-06 0.0 2.780691964285714e-06 1.5 2.790736607142857e-06 1.5 2.791294642857143e-06 0.0 2.797991071428571e-06 0.0 2.798549107142857e-06 1.5 2.8085937499999997e-06 1.5 2.8091517857142856e-06 0.0 2.815848214285714e-06 0.0 2.81640625e-06 1.5 2.826450892857143e-06 1.5 2.8270089285714283e-06 0.0 2.833705357142857e-06 0.0 2.8342633928571426e-06 1.5 2.8443080357142856e-06 1.5 2.844866071428571e-06 0.0 2.8515625e-06 0.0 2.8521205357142853e-06 1.5 2.8621651785714283e-06 1.5 2.8627232142857142e-06 0.0 2.8694196428571426e-06 0.0 2.8699776785714285e-06 1.5 2.880022321428571e-06 1.5 2.880580357142857e-06 0.0 2.8872767857142853e-06 0.0 2.8878348214285713e-06 1.5 2.8978794642857142e-06 1.5 2.8984374999999997e-06 0.0 2.9051339285714285e-06 0.0 2.905691964285714e-06 1.5 2.915736607142857e-06 1.5 2.9162946428571425e-06 0.0 2.9229910714285713e-06 0.0 2.9235491071428568e-06 1.5 2.9335937499999997e-06 1.5 2.9341517857142856e-06 0.0 2.940848214285714e-06 0.0 2.94140625e-06 1.5 2.9514508928571425e-06 1.5 2.9520089285714284e-06 0.0 2.9587053571428568e-06 0.0 2.9592633928571427e-06 1.5 2.9693080357142856e-06 1.5 2.969866071428571e-06 0.0 2.9765625e-06 0.0 2.9771205357142854e-06 1.5 2.9871651785714284e-06 1.5 2.987723214285714e-06 0.0 2.9944196428571427e-06 0.0 2.994977678571428e-06 1.5 3.005022321428571e-06 1.5 3.005580357142857e-06 0.0 3.0122767857142854e-06 0.0 3.0128348214285713e-06 1.5 3.022879464285714e-06 1.5 3.0234375e-06 0.0 3.030133928571428e-06 0.0 3.030691964285714e-06 1.5 3.040736607142857e-06 1.5 3.0412946428571425e-06 0.0 3.0479910714285713e-06 0.0 3.048549107142857e-06 1.5 3.05859375e-06 1.5 3.0591517857142853e-06 0.0 3.065848214285714e-06 0.0 3.0664062499999996e-06 1.5 3.0764508928571426e-06 1.5 3.0770089285714285e-06 0.0 3.083705357142857e-06 0.0 3.0842633928571427e-06 1.5 3.0943080357142853e-06 1.5 3.094866071428571e-06 0.0 3.1015624999999996e-06 0.0 3.1021205357142855e-06 1.5 3.1121651785714285e-06 1.5 3.112723214285714e-06 0.0 3.1194196428571428e-06 0.0 3.1199776785714282e-06 1.5 3.1300223214285712e-06 1.5 3.130580357142857e-06 0.0 3.1372767857142855e-06 0.0 3.1378348214285714e-06 1.5 3.147879464285714e-06 1.5 3.1484375e-06 0.0 3.1551339285714282e-06 0.0 3.155691964285714e-06 1.5 3.1657366071428567e-06 1.5 3.1662946428571426e-06 0.0 3.172991071428571e-06 0.0 3.173549107142857e-06 1.5 3.18359375e-06 1.5 3.1841517857142854e-06 0.0 3.190848214285714e-06 0.0 3.1914062499999996e-06 1.5 3.2014508928571426e-06 1.5 3.2020089285714285e-06 0.0 3.208705357142857e-06 0.0 3.209263392857143e-06 1.5 3.2193080357142854e-06 1.5 3.2198660714285713e-06 0.0 3.2265624999999997e-06 0.0 3.2271205357142856e-06 1.5 3.2371651785714285e-06 1.5 3.237723214285714e-06 0.0 3.244419642857143e-06 0.0 3.2449776785714283e-06 1.5 3.2550223214285713e-06 1.5 3.2555803571428568e-06 0.0 3.2622767857142856e-06 0.0 3.262834821428571e-06 1.5 3.272879464285714e-06 1.5 3.2734375e-06 0.0 3.2801339285714283e-06 0.0 3.2806919642857142e-06 1.5 3.2907366071428568e-06 1.5 3.2912946428571427e-06 0.0 3.297991071428571e-06 0.0 3.298549107142857e-06 1.5 3.30859375e-06 1.5 3.3091517857142854e-06 0.0 3.3158482142857142e-06 0.0 3.3164062499999997e-06 1.5 3.3264508928571427e-06 1.5 3.327008928571428e-06 0.0 3.333705357142857e-06 0.0 3.3342633928571425e-06 1.5 3.34375e-06 1.5 3.3443080357142854e-06 0.0 3.3521205357142856e-06 0.0 3.352678571428571e-06 1.5 3.3616071428571427e-06 1.5 3.362165178571428e-06 0.0 3.3699776785714284e-06 0.0 3.370535714285714e-06 1.5 3.3794642857142855e-06 1.5 3.3800223214285714e-06 0.0 3.387834821428571e-06 0.0 3.388392857142857e-06 1.5 3.397321428571428e-06 1.5 3.397879464285714e-06 0.0 3.405691964285714e-06 0.0 3.4062499999999998e-06 1.5 3.4151785714285714e-06 1.5 3.415736607142857e-06 0.0 3.423549107142857e-06 0.0 3.4241071428571425e-06 1.5 3.433035714285714e-06 1.5 3.4335937499999996e-06 0.0 3.44140625e-06 0.0 3.4419642857142853e-06 1.5 3.450892857142857e-06 1.5 3.4514508928571428e-06 0.0 3.4592633928571425e-06 0.0 3.4598214285714284e-06 1.5 3.4687499999999996e-06 1.5 3.4693080357142855e-06 0.0 3.4771205357142853e-06 0.0 3.477678571428571e-06 1.5 3.4866071428571428e-06 1.5 3.4871651785714283e-06 0.0 3.4949776785714285e-06 0.0 3.495535714285714e-06 1.5 3.5044642857142855e-06 1.5 3.505022321428571e-06 0.0 3.512834821428571e-06 0.0 3.5133928571428567e-06 1.5 3.5223214285714283e-06 1.5 3.522879464285714e-06 0.0 3.530691964285714e-06 0.0 3.53125e-06 1.5 3.540178571428571e-06 1.5 3.540736607142857e-06 0.0 3.5485491071428567e-06 0.0 3.5491071428571426e-06 1.5 3.558035714285714e-06 1.5 3.5585937499999997e-06 0.0 3.56640625e-06 0.0 3.5669642857142854e-06 1.5 3.575892857142857e-06 1.5 3.5764508928571424e-06 0.0 3.5842633928571426e-06 0.0 3.5848214285714285e-06 1.5 3.5937499999999997e-06 1.5 3.5943080357142856e-06 0.0 3.6021205357142854e-06 0.0 3.6026785714285713e-06 1.5 3.6116071428571424e-06 1.5 3.6121651785714283e-06 0.0 3.619977678571428e-06 0.0 3.620535714285714e-06 1.5 3.6294642857142856e-06 1.5 3.630022321428571e-06 0.0 3.6378348214285713e-06 0.0 3.6383928571428568e-06 1.5 3.6473214285714283e-06 1.5 3.647879464285714e-06 0.0 3.655691964285714e-06 0.0 3.65625e-06 1.5 3.665178571428571e-06 1.5 3.665736607142857e-06 0.0 3.6735491071428568e-06 0.0 3.6741071428571427e-06 1.5 3.683035714285714e-06 1.5 3.6835937499999998e-06 0.0 3.69140625e-06 0.0 3.6919642857142854e-06 1.5 3.700892857142857e-06 1.5 3.7014508928571425e-06 0.0 3.7092633928571427e-06 0.0 3.709821428571428e-06 1.5 3.7187499999999998e-06 1.5 3.7193080357142852e-06 0.0 3.7271205357142854e-06 0.0 3.7276785714285713e-06 1.5 3.7366071428571425e-06 1.5 3.7371651785714284e-06 0.0 3.744977678571428e-06 0.0 3.745535714285714e-06 1.5 3.7544642857142853e-06 1.5 3.755022321428571e-06 0.0 3.7628348214285714e-06 0.0 3.763392857142857e-06 1.5 3.7723214285714284e-06 1.5 3.772879464285714e-06 0.0 3.780691964285714e-06 0.0 3.7812499999999996e-06 1.5 3.790178571428571e-06 1.5 3.790736607142857e-06 0.0 3.798549107142857e-06 0.0 3.7991071428571428e-06 1.5 3.808035714285714e-06 1.5 3.80859375e-06 0.0 3.81640625e-06 0.0 3.816964285714285e-06 1.5 3.825892857142857e-06 1.5 3.826450892857143e-06 0.0 3.834263392857142e-06 0.0 3.834821428571428e-06 1.5 3.843749999999999e-06 1.5 3.844308035714285e-06 0.0 3.8521205357142855e-06 0.0 3.852678571428571e-06 1.5 3.861607142857143e-06 1.5 3.8621651785714285e-06 0.0 3.869977678571429e-06 0.0 3.870535714285714e-06 1.5 3.879464285714286e-06 1.5 3.880022321428571e-06 0.0 3.887834821428571e-06 0.0 3.888392857142857e-06 1.5 3.897321428571428e-06 1.5 3.897879464285714e-06 0.0 3.905691964285714e-06 0.0 3.90625e-06 1.5 3.915178571428571e-06 1.5 3.915736607142857e-06 0.0 3.9235491071428565e-06 0.0 3.924107142857142e-06 1.5 3.933035714285714e-06 1.5 3.9335937499999995e-06 0.0 3.94140625e-06 0.0 3.9419642857142856e-06 1.5 3.950892857142857e-06 1.5 3.951450892857143e-06 0.0 3.959263392857143e-06 0.0 3.959821428571428e-06 1.5 3.96875e-06 1.5 3.969308035714286e-06 0.0 3.977120535714285e-06 0.0 3.977678571428571e-06 1.5 3.986607142857142e-06 1.5 3.987165178571428e-06 0.0 3.994977678571428e-06 0.0 3.995535714285714e-06 1.5 4.004464285714285e-06 1.5 4.005022321428571e-06 0.0 4.0133928571428566e-06 0.0 4.0139508928571425e-06 1.5 4.021763392857143e-06 1.5 4.0223214285714286e-06 0.0 4.03125e-06 0.0 4.031808035714286e-06 1.5 4.039620535714286e-06 1.5 4.040178571428571e-06 0.0 4.049107142857143e-06 0.0 4.049665178571428e-06 1.5 4.057477678571428e-06 1.5 4.058035714285714e-06 0.0 4.066964285714285e-06 0.0 4.067522321428571e-06 1.5 4.075334821428571e-06 1.5 4.075892857142857e-06 0.0 4.084821428571428e-06 0.0 4.085379464285714e-06 1.5 4.093191964285714e-06 1.5 4.0937499999999996e-06 0.0 4.102678571428571e-06 0.0 4.103236607142857e-06 1.5 4.111049107142857e-06 1.5 4.111607142857143e-06 0.0 4.120535714285714e-06 0.0 4.12109375e-06 1.5 4.12890625e-06 1.5 4.129464285714285e-06 0.0 4.138392857142857e-06 0.0 4.138950892857143e-06 1.5 4.146763392857142e-06 1.5 4.147321428571428e-06 0.0 4.156249999999999e-06 0.0 4.156808035714285e-06 1.5 4.1646205357142855e-06 1.5 4.165178571428571e-06 0.0 4.1741071428571426e-06 0.0 4.1746651785714285e-06 1.5 4.182477678571429e-06 1.5 4.183035714285714e-06 0.0 4.191964285714286e-06 0.0 4.192522321428571e-06 1.5 4.200334821428571e-06 1.5 4.200892857142857e-06 0.0 4.209821428571428e-06 0.0 4.210379464285714e-06 1.5 4.218191964285714e-06 1.5 4.21875e-06 0.0 4.227678571428571e-06 0.0 4.228236607142857e-06 1.5 4.2360491071428565e-06 1.5 4.236607142857142e-06 0.0 4.245535714285714e-06 0.0 4.2460937499999994e-06 1.5 4.25390625e-06 1.5 4.2544642857142855e-06 0.0 4.263392857142857e-06 0.0 4.263950892857143e-06 1.5 4.271763392857143e-06 1.5 4.272321428571428e-06 0.0 4.28125e-06 0.0 4.281808035714286e-06 1.5 4.289620535714285e-06 1.5 4.290178571428571e-06 0.0 4.299107142857142e-06 0.0 4.299665178571428e-06 1.5 4.307477678571428e-06 1.5 4.308035714285714e-06 0.0 4.316964285714285e-06 0.0 4.317522321428571e-06 1.5 4.3253348214285715e-06 1.5 4.3258928571428565e-06 0.0 4.3348214285714285e-06 0.0 4.335379464285714e-06 1.5 4.343191964285714e-06 1.5 4.34375e-06 0.0 4.352678571428571e-06 0.0 4.353236607142857e-06 1.5 4.361049107142857e-06 1.5 4.361607142857143e-06 0.0 4.370535714285714e-06 0.0 4.37109375e-06 1.5 4.378906249999999e-06 1.5 4.379464285714285e-06 0.0 4.388392857142857e-06 0.0 4.388950892857142e-06 1.5 4.3967633928571425e-06 1.5 4.397321428571428e-06 0.0 4.4062499999999995e-06 0.0 4.4068080357142854e-06 1.5 4.414620535714286e-06 1.5 4.415178571428571e-06 0.0 4.424107142857143e-06 0.0 4.424665178571429e-06 1.5 4.432477678571428e-06 1.5 4.433035714285714e-06 0.0 4.441964285714285e-06 0.0 4.442522321428571e-06 1.5 4.450334821428571e-06 1.5 4.450892857142857e-06 0.0 4.459821428571428e-06 0.0 4.460379464285714e-06 1.5 4.468191964285714e-06 1.5 4.468749999999999e-06 0.0 4.477678571428571e-06 0.0 4.4782366071428564e-06 1.5 4.486049107142857e-06 1.5 4.4866071428571425e-06 0.0 4.495535714285714e-06 0.0 4.49609375e-06 1.5 4.50390625e-06 1.5 4.504464285714286e-06 0.0 4.513392857142857e-06 0.0 4.513950892857143e-06 1.5 4.521763392857143e-06 1.5 4.522321428571428e-06 0.0 4.53125e-06 0.0 4.531808035714285e-06 1.5 4.539620535714285e-06 1.5 4.540178571428571e-06 0.0 4.549107142857142e-06 0.0 4.549665178571428e-06 1.5 4.5574776785714284e-06 1.5 4.558035714285714e-06 0.0 4.5669642857142855e-06 0.0 4.5675223214285714e-06 1.5 4.575334821428571e-06 1.5 4.575892857142857e-06 0.0 4.584821428571428e-06 0.0 4.585379464285714e-06 1.5 4.593191964285714e-06 1.5 4.59375e-06 0.0 4.602678571428571e-06 0.0 4.603236607142857e-06 1.5 4.611049107142857e-06 1.5 4.611607142857142e-06 0.0 4.620535714285714e-06 0.0 4.621093749999999e-06 1.5 4.6289062499999994e-06 1.5 4.629464285714285e-06 0.0 4.6383928571428565e-06 0.0 4.638950892857142e-06 1.5 4.646763392857143e-06 1.5 4.6473214285714285e-06 0.0 4.65625e-06 0.0 4.656808035714286e-06 1.5 4.664620535714286e-06 1.5 4.665178571428571e-06 0.0 4.674107142857143e-06 0.0 4.674665178571428e-06 1.5 4.681919642857142e-06 1.5 4.682477678571428e-06 0.0 4.692522321428571e-06 0.0 4.693080357142857e-06 1.5 4.699776785714285e-06 1.5 4.700334821428571e-06 0.0 4.710379464285714e-06 0.0 4.710937499999999e-06 1.5 4.7176339285714285e-06 1.5 4.718191964285714e-06 0.0 4.7282366071428566e-06 0.0 4.7287946428571425e-06 1.5 4.735491071428571e-06 1.5 4.736049107142857e-06 0.0 4.74609375e-06 0.0 4.746651785714286e-06 1.5 4.753348214285714e-06 1.5 4.75390625e-06 0.0 4.763950892857143e-06 0.0 4.764508928571428e-06 1.5 4.771205357142857e-06 1.5 4.771763392857142e-06 0.0 4.781808035714285e-06 0.0 4.782366071428571e-06 1.5 4.7890624999999995e-06 1.5 4.7896205357142854e-06 0.0 4.799665178571428e-06 0.0 4.800223214285714e-06 1.5 4.806919642857143e-06 1.5 4.807477678571429e-06 0.0 4.817522321428571e-06 0.0 4.818080357142857e-06 1.5 4.824776785714285e-06 1.5 4.825334821428571e-06 0.0 4.835379464285714e-06 0.0 4.8359375e-06 1.5 4.842633928571428e-06 1.5 4.843191964285714e-06 0.0 4.853236607142857e-06 0.0 4.853794642857142e-06 1.5 4.860491071428571e-06 1.5 4.861049107142856e-06 0.0 4.871093749999999e-06 0.0 4.871651785714285e-06 1.5 4.878348214285714e-06 1.5 4.87890625e-06 0.0 4.8889508928571426e-06 0.0 4.8895089285714285e-06 1.5 4.896205357142857e-06 1.5 4.896763392857143e-06 0.0 4.906808035714286e-06 0.0 4.907366071428571e-06 1.5 4.9140625e-06 1.5 4.914620535714285e-06 0.0 4.924665178571428e-06 0.0 4.925223214285714e-06 1.5 4.931919642857142e-06 1.5 4.932477678571428e-06 0.0 4.942522321428571e-06 0.0 4.943080357142857e-06 1.5 4.9497767857142855e-06 1.5 4.950334821428571e-06 0.0 4.9603794642857136e-06 0.0 4.9609374999999995e-06 1.5 4.967633928571428e-06 1.5 4.968191964285714e-06 0.0 4.978236607142857e-06 0.0 4.978794642857143e-06 1.5 4.985491071428571e-06 1.5 4.986049107142857e-06 0.0 4.99609375e-06 0.0 4.996651785714285e-06 1.5 5.003348214285714e-06 1.5 5.003906249999999e-06 0.0 5.013950892857142e-06 0.0 5.014508928571428e-06 1.5 5.0212053571428565e-06 1.5 5.021763392857142e-06 0.0 5.031808035714285e-06 0.0 5.032366071428571e-06 1.5 5.0390625e-06 1.5 5.0396205357142856e-06 0.0 5.0496651785714286e-06 0.0 5.050223214285714e-06 1.5 5.056919642857143e-06 1.5 5.057477678571428e-06 0.0 5.067522321428571e-06 0.0 5.068080357142857e-06 1.5 5.074776785714285e-06 1.5 5.075334821428571e-06 0.0 5.085379464285714e-06 0.0 5.0859375e-06 1.5 5.092633928571428e-06 1.5 5.093191964285714e-06 0.0 5.103236607142856e-06 0.0 5.103794642857142e-06 1.5 5.110491071428571e-06 1.5 5.1110491071428566e-06 0.0 5.1210937499999995e-06 0.0 5.1216517857142855e-06 1.5 5.128348214285714e-06 1.5 5.12890625e-06 0.0 5.138950892857143e-06 0.0 5.139508928571429e-06 1.5 5.146205357142857e-06 1.5 5.146763392857143e-06 0.0 5.156808035714285e-06 0.0 5.157366071428571e-06 1.5 5.164062499999999e-06 1.5 5.164620535714285e-06 0.0 5.174665178571428e-06 0.0 5.175223214285714e-06 1.5 5.1819196428571425e-06 1.5 5.182477678571428e-06 0.0 5.192522321428571e-06 0.0 5.1930803571428564e-06 1.5 5.199776785714286e-06 1.5 5.200334821428571e-06 0.0 5.210379464285714e-06 0.0 5.2109375e-06 1.5 5.217633928571428e-06 1.5 5.218191964285714e-06 0.0 5.228236607142857e-06 0.0 5.228794642857143e-06 1.5 5.235491071428571e-06 1.5 5.236049107142857e-06 0.0 5.24609375e-06 0.0 5.246651785714285e-06 1.5 5.253348214285714e-06 1.5 5.253906249999999e-06 0.0 5.263950892857142e-06 0.0 5.264508928571428e-06 1.5 5.271205357142857e-06 1.5 5.2717633928571426e-06 0.0 5.2818080357142855e-06 0.0 5.2823660714285714e-06 1.5 5.2890625e-06 1.5 5.289620535714286e-06 0.0 5.299665178571428e-06 0.0 5.300223214285714e-06 1.5 5.306919642857142e-06 1.5 5.307477678571428e-06 0.0 5.317522321428571e-06 0.0 5.318080357142857e-06 1.5 5.324776785714285e-06 1.5 5.325334821428571e-06 0.0 5.335379464285714e-06 0.0 5.335937499999999e-06 1.5 5.3426339285714285e-06 1.5 5.3431919642857135e-06 0.0 5.3532366071428565e-06 0.0 5.3537946428571424e-06 1.5 5.360491071428571e-06 1.5 5.361049107142857e-06 0.0 5.37109375e-06 0.0 5.371651785714286e-06 1.5 5.378348214285714e-06 1.5 5.37890625e-06 0.0 5.388950892857143e-06 0.0 5.389508928571428e-06 1.5 5.396205357142857e-06 1.5 5.396763392857142e-06 0.0 5.406808035714285e-06 0.0 5.407366071428571e-06 1.5 5.4140624999999995e-06 1.5 5.414620535714285e-06 0.0 5.424665178571428e-06 0.0 5.425223214285714e-06 1.5 5.431919642857143e-06 1.5 5.4324776785714285e-06 0.0 5.442522321428571e-06 0.0 5.443080357142857e-06 1.5 5.449776785714285e-06 1.5 5.450334821428571e-06 0.0 5.460379464285714e-06 0.0 5.4609375e-06 1.5 5.467633928571428e-06 1.5 5.468191964285714e-06 0.0 5.478236607142857e-06 0.0 5.478794642857142e-06 1.5 5.485491071428571e-06 1.5 5.486049107142856e-06 0.0 5.496093749999999e-06 0.0 5.496651785714285e-06 1.5 5.503348214285714e-06 1.5 5.5039062499999995e-06 0.0 5.5139508928571425e-06 0.0 5.514508928571428e-06 1.5 5.521205357142857e-06 1.5 5.521763392857143e-06 0.0 5.531808035714286e-06 0.0 5.532366071428571e-06 1.5 5.5390625e-06 1.5 5.539620535714285e-06 0.0 5.549665178571428e-06 0.0 5.550223214285714e-06 1.5 5.556919642857142e-06 1.5 5.557477678571428e-06 0.0 5.567522321428571e-06 0.0 5.568080357142857e-06 1.5 5.5747767857142855e-06 1.5 5.575334821428571e-06 0.0 5.5853794642857135e-06 0.0 5.585937499999999e-06 1.5 5.592633928571428e-06 1.5 5.593191964285714e-06 0.0 5.603236607142857e-06 0.0 5.6037946428571426e-06 1.5 5.610491071428571e-06 1.5 5.611049107142857e-06 0.0 5.62109375e-06 0.0 5.621651785714285e-06 1.5 5.628348214285714e-06 1.5 5.628906249999999e-06 0.0 5.638950892857142e-06 0.0 5.639508928571428e-06 1.5 5.6462053571428564e-06 1.5 5.646763392857142e-06 0.0 5.656808035714285e-06 0.0 5.657366071428571e-06 1.5 5.6640625e-06 1.5 5.6646205357142855e-06 0.0 5.6746651785714285e-06 0.0 5.6752232142857136e-06 1.5 5.681919642857143e-06 1.5 5.682477678571428e-06 0.0 5.692522321428571e-06 0.0 5.693080357142857e-06 1.5 5.699776785714285e-06 1.5 5.700334821428571e-06 0.0 5.710379464285714e-06 0.0 5.7109375e-06 1.5 5.717633928571428e-06 1.5 5.718191964285714e-06 0.0 5.728236607142856e-06 0.0 5.728794642857142e-06 1.5 5.735491071428571e-06 1.5 5.7360491071428565e-06 0.0 5.7460937499999995e-06 0.0 5.746651785714285e-06 1.5 5.753348214285714e-06 1.5 5.75390625e-06 0.0 5.763950892857143e-06 0.0 5.7645089285714286e-06 1.5 5.771205357142857e-06 1.5 5.771763392857143e-06 0.0 5.781808035714285e-06 0.0 5.782366071428571e-06 1.5 5.789062499999999e-06 1.5 5.789620535714285e-06 0.0 5.799665178571428e-06 0.0 5.800223214285714e-06 1.5 5.8069196428571424e-06 1.5 5.807477678571428e-06 0.0 5.817522321428571e-06 0.0 5.818080357142856e-06 1.5 5.824776785714286e-06 1.5 5.825334821428571e-06 0.0 5.835379464285714e-06 0.0 5.8359374999999996e-06 1.5 5.842633928571428e-06 1.5 5.843191964285714e-06 0.0 5.853236607142857e-06 0.0 5.853794642857143e-06 1.5 5.860491071428571e-06 1.5 5.861049107142857e-06 0.0 5.87109375e-06 0.0 5.871651785714285e-06 1.5 5.878348214285714e-06 1.5 5.878906249999999e-06 0.0 5.888950892857142e-06 0.0 5.889508928571428e-06 1.5 5.896205357142857e-06 1.5 5.8967633928571425e-06 0.0 5.9068080357142855e-06 0.0 5.907366071428571e-06 1.5 5.9140625e-06 1.5 5.914620535714286e-06 0.0 5.924665178571428e-06 0.0 5.925223214285714e-06 1.5 5.931919642857142e-06 1.5 5.932477678571428e-06 0.0 5.942522321428571e-06 0.0 5.943080357142857e-06 1.5 5.949776785714285e-06 1.5 5.950334821428571e-06 0.0 5.960379464285714e-06 0.0 5.960937499999999e-06 1.5 5.967633928571428e-06 1.5 5.9681919642857135e-06 0.0 5.9782366071428565e-06 0.0 5.978794642857142e-06 1.5 5.985491071428571e-06 1.5 5.986049107142857e-06 0.0 5.99609375e-06 0.0 5.9966517857142855e-06 1.5 6.003348214285714e-06 1.5 6.00390625e-06 0.0 6.013950892857143e-06 0.0 6.014508928571428e-06 1.5 6.021205357142857e-06 1.5 6.021763392857142e-06 0.0 6.031808035714285e-06 0.0 6.032366071428571e-06 1.5 6.039062499999999e-06 1.5 6.039620535714285e-06 0.0 6.049665178571428e-06 0.0 6.050223214285714e-06 1.5 6.056919642857143e-06 1.5 6.0574776785714285e-06 0.0 6.067522321428571e-06 0.0 6.0680803571428565e-06 1.5 6.074776785714285e-06 1.5 6.075334821428571e-06 0.0 6.085379464285714e-06 0.0 6.0859375e-06 1.5 6.092633928571428e-06 1.5 6.093191964285714e-06 0.0 6.103236607142857e-06 0.0 6.103794642857142e-06 1.5 6.110491071428571e-06 1.5 6.111049107142856e-06 0.0 6.121093749999999e-06 0.0 6.121651785714285e-06 1.5 6.1283482142857136e-06 1.5 6.1289062499999995e-06 0.0 6.1389508928571425e-06 0.0 6.139508928571428e-06 1.5 6.146205357142857e-06 1.5 6.146763392857143e-06 0.0 6.156808035714286e-06 0.0 6.157366071428571e-06 1.5 6.1640625e-06 1.5 6.164620535714285e-06 0.0 6.174665178571428e-06 0.0 6.175223214285714e-06 1.5 6.181919642857142e-06 1.5 6.182477678571428e-06 0.0 6.192522321428571e-06 0.0 6.193080357142857e-06 1.5 6.199776785714285e-06 1.5 6.200334821428571e-06 0.0 6.2103794642857134e-06 0.0 6.210937499999999e-06 1.5 6.217633928571428e-06 1.5 6.218191964285714e-06 0.0 6.228236607142857e-06 0.0 6.2287946428571425e-06 1.5 6.235491071428571e-06 1.5 6.236049107142857e-06 0.0 6.24609375e-06 0.0 6.246651785714285e-06 1.5 6.253348214285714e-06 1.5 6.25390625e-06 0.0 6.263950892857142e-06 0.0 6.264508928571428e-06 1.5 6.271205357142856e-06 1.5 6.271763392857142e-06 0.0 6.281808035714285e-06 0.0 6.282366071428571e-06 1.5 6.2890624999999996e-06 1.5 6.2896205357142855e-06 0.0 6.2996651785714284e-06 0.0 6.3002232142857135e-06 1.5 6.306919642857143e-06 1.5 6.307477678571428e-06 0.0 6.317522321428571e-06 0.0 6.318080357142857e-06 1.5 6.324776785714285e-06 1.5 6.325334821428571e-06 0.0 6.335379464285714e-06 0.0 6.3359375e-06 1.5 6.342633928571428e-06 1.5 6.343191964285714e-06 0.0 6.353236607142857e-06 0.0 6.353794642857142e-06 1.5 6.360491071428571e-06 1.5 6.3610491071428565e-06 0.0 6.3710937499999994e-06 0.0 6.371651785714285e-06 1.5 6.378348214285714e-06 1.5 6.37890625e-06 0.0 6.388950892857143e-06 0.0 6.3895089285714285e-06 1.5 6.396205357142857e-06 1.5 6.396763392857143e-06 0.0 6.406808035714285e-06 0.0 6.407366071428571e-06 1.5 6.414062499999999e-06 1.5 6.414620535714285e-06 0.0 6.424665178571428e-06 0.0 6.425223214285714e-06 1.5 6.431919642857142e-06 1.5 6.432477678571428e-06 0.0 6.442522321428571e-06 0.0 6.443080357142856e-06 1.5 6.4497767857142855e-06 1.5 6.450334821428571e-06 0.0 6.460379464285714e-06 0.0 6.4609374999999995e-06 1.5 6.467633928571428e-06 1.5 6.468191964285714e-06 0.0 6.478236607142857e-06 0.0 6.478794642857143e-06 1.5 6.485491071428571e-06 1.5 6.486049107142857e-06 0.0 6.49609375e-06 0.0 6.496651785714285e-06 1.5 6.503348214285714e-06 1.5 6.503906249999999e-06 0.0 6.513950892857142e-06 0.0 6.514508928571428e-06 1.5 6.5212053571428565e-06 1.5 6.5217633928571424e-06 0.0 6.531808035714285e-06 0.0 6.532366071428571e-06 1.5 6.5390625e-06 1.5 6.539620535714286e-06 0.0 6.549665178571428e-06 0.0 6.550223214285714e-06 1.5 6.556919642857142e-06 1.5 6.557477678571428e-06 0.0 6.567522321428571e-06 0.0 6.568080357142857e-06 1.5 6.574776785714285e-06 1.5 6.575334821428571e-06 0.0 6.585379464285714e-06 0.0 6.585937499999999e-06 1.5 6.592633928571428e-06 1.5 6.5931919642857134e-06 0.0 6.603236607142856e-06 0.0 6.603794642857142e-06 1.5 6.610491071428571e-06 1.5 6.611049107142857e-06 0.0 6.62109375e-06 0.0 6.6216517857142855e-06 1.5 6.628348214285714e-06 1.5 6.62890625e-06 0.0 6.638950892857143e-06 0.0 6.639508928571428e-06 1.5 6.646205357142857e-06 1.5 6.646763392857142e-06 0.0 6.656808035714285e-06 0.0 6.657366071428571e-06 1.5 6.664062499999999e-06 1.5 6.664620535714285e-06 0.0 6.674665178571428e-06 0.0 6.675223214285714e-06 1.5 6.6819196428571425e-06 1.5 6.6824776785714284e-06 0.0 6.6925223214285706e-06 0.0 6.6930803571428565e-06 1.5 6.699776785714285e-06 1.5 6.700334821428571e-06 0.0 6.710379464285714e-06 0.0 6.7109375e-06 1.5 6.717633928571428e-06 1.5 6.718191964285714e-06 0.0 6.728236607142857e-06 0.0 6.728794642857142e-06 1.5 6.735491071428571e-06 1.5 6.736049107142856e-06 0.0 6.746093749999999e-06 0.0 6.746651785714285e-06 1.5 6.7533482142857135e-06 1.5 6.753906249999999e-06 0.0 6.763950892857142e-06 0.0 6.764508928571428e-06 1.5 6.771205357142857e-06 1.5 6.771763392857143e-06 0.0 6.7818080357142856e-06 0.0 6.782366071428571e-06 1.5 6.7890625e-06 1.5 6.789620535714285e-06 0.0 6.799665178571428e-06 0.0 6.800223214285714e-06 1.5 6.806919642857142e-06 1.5 6.807477678571428e-06 0.0 6.817522321428571e-06 0.0 6.818080357142857e-06 1.5 6.824776785714285e-06 1.5 6.825334821428571e-06 0.0 6.835379464285713e-06 0.0 6.835937499999999e-06 1.5 6.842633928571428e-06 1.5 6.8431919642857136e-06 0.0 6.8532366071428566e-06 0.0 6.8537946428571425e-06 1.5 6.860491071428571e-06 1.5 6.861049107142857e-06 0.0 6.87109375e-06 0.0 6.871651785714286e-06 1.5 6.878348214285714e-06 1.5 6.87890625e-06 0.0 6.888950892857142e-06 0.0 6.889508928571428e-06 1.5 6.896205357142856e-06 1.5 6.896763392857142e-06 0.0 6.906808035714285e-06 0.0 6.907366071428571e-06 1.5 6.9140624999999995e-06 1.5 6.914620535714285e-06 0.0 6.924665178571428e-06 0.0 6.9252232142857135e-06 1.5 6.931919642857143e-06 1.5 6.932477678571428e-06 0.0 6.942522321428571e-06 0.0 6.943080357142857e-06 1.5 6.949776785714285e-06 1.5 6.950334821428571e-06 0.0 6.960379464285714e-06 0.0 6.9609375e-06 1.5 6.967633928571428e-06 1.5 6.968191964285714e-06 0.0 6.978236607142857e-06 0.0 6.978794642857142e-06 1.5 6.985491071428571e-06 1.5 6.986049107142856e-06 0.0 6.996093749999999e-06 0.0 6.996651785714285e-06 1.5 7.003348214285714e-06 1.5 7.0039062499999996e-06 0.0 7.0139508928571425e-06 0.0 7.0145089285714285e-06 1.5 7.021205357142857e-06 1.5 7.021763392857143e-06 0.0 7.031808035714285e-06 0.0 7.032366071428571e-06 1.5 7.039062499999999e-06 1.5 7.039620535714285e-06 0.0 7.049665178571428e-06 0.0 7.050223214285714e-06 1.5 7.056919642857142e-06 1.5 7.057477678571428e-06 0.0 7.067522321428571e-06 0.0 7.068080357142856e-06 1.5 7.0747767857142855e-06 1.5 7.0753348214285706e-06 0.0 7.0853794642857135e-06 0.0 7.0859374999999994e-06 1.5 7.092633928571428e-06 1.5 7.093191964285714e-06 0.0 7.103236607142857e-06 0.0 7.103794642857143e-06 1.5 7.110491071428571e-06 1.5 7.111049107142857e-06 0.0 7.12109375e-06 0.0 7.121651785714285e-06 1.5 7.128348214285714e-06 1.5 7.128906249999999e-06 0.0 7.138950892857142e-06 0.0 7.139508928571428e-06 1.5 7.1462053571428565e-06 1.5 7.146763392857142e-06 0.0 7.156808035714285e-06 0.0 7.157366071428571e-06 1.5 7.1640625e-06 1.5 7.1646205357142856e-06 0.0 7.174665178571428e-06 0.0 7.175223214285714e-06 1.5 7.181919642857142e-06 1.5 7.182477678571428e-06 0.0 7.192522321428571e-06 0.0 7.193080357142857e-06 1.5 7.199776785714285e-06 1.5 7.200334821428571e-06 0.0 7.210379464285714e-06 0.0 7.210937499999999e-06 1.5 7.217633928571428e-06 1.5 7.218191964285713e-06 0.0 7.228236607142856e-06 0.0 7.228794642857142e-06 1.5 7.235491071428571e-06 1.5 7.2360491071428565e-06 0.0 7.2460937499999995e-06 0.0 7.2466517857142854e-06 1.5 7.253348214285714e-06 1.5 7.25390625e-06 0.0 7.263950892857143e-06 0.0 7.264508928571428e-06 1.5 7.271205357142857e-06 1.5 7.271763392857142e-06 0.0 7.281808035714285e-06 0.0 7.282366071428571e-06 1.5 7.289062499999999e-06 1.5 7.289620535714285e-06 0.0 7.299665178571428e-06 0.0 7.300223214285714e-06 1.5 7.3069196428571425e-06 1.5 7.307477678571428e-06 0.0 7.3175223214285705e-06 0.0 7.318080357142856e-06 1.5 7.324776785714285e-06 1.5 7.325334821428571e-06 0.0 7.335379464285714e-06 0.0 7.3359375e-06 1.5 7.342633928571428e-06 1.5 7.343191964285714e-06 0.0 7.353236607142857e-06 0.0 7.353794642857142e-06 1.5 7.361049107142856e-06 1.5 7.361607142857142e-06 0.0 7.370535714285714e-06 0.0 7.371093749999999e-06 1.5 7.378906249999999e-06 1.5 7.379464285714285e-06 0.0 7.3883928571428564e-06 0.0 7.388950892857142e-06 1.5 7.3967633928571425e-06 1.5 7.3973214285714284e-06 0.0 7.40625e-06 0.0 7.4068080357142855e-06 1.5 7.414620535714285e-06 1.5 7.415178571428571e-06 0.0 7.424107142857142e-06 0.0 7.424665178571428e-06 1.5 7.432477678571428e-06 1.5 7.433035714285714e-06 0.0 7.441964285714285e-06 0.0 7.442522321428571e-06 1.5 7.450334821428571e-06 1.5 7.450892857142856e-06 0.0 7.459821428571428e-06 0.0 7.460379464285713e-06 1.5 7.4681919642857135e-06 1.5 7.4687499999999994e-06 0.0 7.477678571428571e-06 0.0 7.4782366071428565e-06 1.5 7.486049107142857e-06 1.5 7.486607142857143e-06 0.0 7.495535714285714e-06 0.0 7.49609375e-06 1.5 7.50390625e-06 1.5 7.504464285714285e-06 0.0 7.513392857142857e-06 0.0 7.513950892857142e-06 1.5 7.521763392857142e-06 1.5 7.522321428571428e-06 0.0 7.531249999999999e-06 0.0 7.531808035714285e-06 1.5 7.539620535714285e-06 1.5 7.540178571428571e-06 0.0 7.5491071428571424e-06 0.0 7.549665178571428e-06 1.5 7.557477678571428e-06 1.5 7.558035714285714e-06 0.0 7.566964285714285e-06 0.0 7.567522321428571e-06 1.5 7.575334821428571e-06 1.5 7.575892857142857e-06 0.0 7.584821428571428e-06 0.0 7.585379464285714e-06 1.5 7.593191964285714e-06 1.5 7.593749999999999e-06 0.0 7.602678571428571e-06 0.0 7.603236607142857e-06 1.5 7.611049107142856e-06 1.5 7.611607142857142e-06 0.0 7.620535714285713e-06 0.0 7.621093749999999e-06 1.5 7.6289062499999995e-06 1.5 7.629464285714285e-06 0.0 7.638392857142857e-06 0.0 7.638950892857142e-06 1.5 7.646763392857142e-06 1.5 7.647321428571429e-06 0.0 7.65625e-06 0.0 7.656808035714285e-06 1.5 7.664620535714286e-06 1.5 7.665178571428571e-06 0.0 7.674107142857142e-06 0.0 7.674665178571429e-06 1.5 7.682477678571428e-06 1.5 7.683035714285713e-06 0.0 7.691964285714284e-06 0.0 7.692522321428571e-06 1.5 7.70033482142857e-06 1.5 7.700892857142857e-06 0.0 7.709821428571428e-06 0.0 7.710379464285713e-06 1.5 7.718191964285715e-06 1.5 7.71875e-06 0.0 7.72767857142857e-06 0.0 7.728236607142856e-06 1.5 7.736049107142857e-06 1.5 7.736607142857142e-06 0.0 7.745535714285713e-06 0.0 7.74609375e-06 1.5 7.75390625e-06 1.5 7.754464285714286e-06 0.0 7.763392857142857e-06 0.0 7.763950892857142e-06 1.5 7.771763392857141e-06 1.5 7.772321428571428e-06 0.0 7.78125e-06 0.0 7.781808035714284e-06 1.5 7.789620535714286e-06 1.5 7.79017857142857e-06 0.0 7.799107142857142e-06 0.0 7.799665178571428e-06 1.5 7.807477678571428e-06 1.5 7.808035714285713e-06 0.0 7.816964285714286e-06 0.0 7.81752232142857e-06 1.5 7.82533482142857e-06 1.5 7.825892857142857e-06 0.0 7.834821428571428e-06 0.0 7.835379464285713e-06 1.5 7.843191964285714e-06 1.5 7.84375e-06 0.0 7.85267857142857e-06 0.0 7.853236607142857e-06 1.5 7.861049107142856e-06 1.5 7.861607142857142e-06 0.0 7.870535714285714e-06 0.0 7.87109375e-06 1.5 7.878906249999999e-06 1.5 7.879464285714286e-06 0.0 7.888392857142857e-06 0.0 7.888950892857142e-06 1.5 7.896763392857143e-06 1.5 7.897321428571428e-06 0.0 7.906249999999999e-06 0.0 7.906808035714286e-06 1.5 7.914620535714285e-06 1.5 7.91517857142857e-06 0.0 7.924107142857143e-06 0.0 7.924665178571428e-06 1.5 7.932477678571427e-06 1.5 7.933035714285714e-06 0.0 7.941964285714285e-06 0.0 7.94252232142857e-06 1.5 7.950334821428571e-06 1.5 7.950892857142857e-06 0.0 7.959821428571428e-06 0.0 7.960379464285714e-06 1.5 7.968191964285714e-06 1.5 7.968749999999999e-06 0.0 7.97767857142857e-06 0.0 7.978236607142857e-06 1.5 7.986049107142856e-06 1.5 7.986607142857143e-06 0.0 7.995535714285714e-06 0.0 7.996093749999999e-06 1.5 8.00390625e-06 1.5 8.004464285714285e-06 0.0 8.013392857142856e-06 0.0 8.013950892857141e-06 1.5 8.021763392857142e-06 1.5 8.022321428571428e-06 0.0 8.030691964285714e-06 0.0 8.031249999999999e-06 1.5 8.040178571428572e-06 1.5 8.040736607142857e-06 0.0 8.048549107142856e-06 0.0 8.049107142857143e-06 1.5 8.058035714285714e-06 1.5 8.058593749999999e-06 0.0 8.06640625e-06 0.0 8.066964285714285e-06 1.5 8.075892857142856e-06 1.5 8.076450892857143e-06 0.0 8.084263392857142e-06 0.0 8.084821428571427e-06 1.5 8.09375e-06 1.5 8.094308035714285e-06 0.0 8.102120535714285e-06 0.0 8.102678571428571e-06 1.5 8.111607142857143e-06 1.5 8.112165178571428e-06 0.0 8.119977678571429e-06 0.0 8.120535714285714e-06 1.5 8.129464285714285e-06 1.5 8.130022321428572e-06 0.0 8.137834821428571e-06 0.0 8.138392857142856e-06 1.5 8.147321428571427e-06 1.5 8.147879464285714e-06 0.0 8.155691964285713e-06 0.0 8.15625e-06 1.5 8.165178571428571e-06 1.5 8.165736607142856e-06 0.0 8.173549107142857e-06 0.0 8.174107142857142e-06 1.5 8.183035714285714e-06 1.5 8.183593749999999e-06 0.0 8.19140625e-06 0.0 8.191964285714285e-06 1.5 8.200892857142856e-06 1.5 8.201450892857143e-06 0.0 8.209263392857142e-06 0.0 8.209821428571429e-06 1.5 8.21875e-06 1.5 8.219308035714285e-06 0.0 8.227120535714284e-06 0.0 8.227678571428571e-06 1.5 8.236607142857142e-06 1.5 8.237165178571427e-06 0.0 8.244977678571428e-06 0.0 8.245535714285713e-06 1.5 8.254464285714285e-06 1.5 8.255022321428571e-06 0.0 8.26283482142857e-06 0.0 8.263392857142857e-06 1.5 8.272321428571429e-06 1.5 8.272879464285714e-06 0.0 8.280691964285713e-06 0.0 8.28125e-06 1.5 8.290178571428571e-06 1.5 8.290736607142856e-06 0.0 8.298549107142857e-06 0.0 8.299107142857142e-06 1.5 8.308035714285713e-06 1.5 8.30859375e-06 0.0 8.31640625e-06 0.0 8.316964285714284e-06 1.5 8.325892857142857e-06 1.5 8.326450892857142e-06 0.0 8.334263392857142e-06 0.0 8.334821428571428e-06 1.5 8.34375e-06 1.5 8.344308035714285e-06 0.0 8.352120535714286e-06 0.0 8.35267857142857e-06 1.5 8.361607142857142e-06 1.5 8.362165178571429e-06 0.0 8.369977678571428e-06 0.0 8.370535714285713e-06 1.5 8.379464285714286e-06 1.5 8.380022321428571e-06 0.0 8.38783482142857e-06 0.0 8.388392857142857e-06 1.5 8.397321428571428e-06 1.5 8.397879464285713e-06 0.0 8.405691964285714e-06 0.0 8.40625e-06 1.5 8.41517857142857e-06 1.5 8.415736607142857e-06 0.0 8.423549107142857e-06 0.0 8.424107142857142e-06 1.5 8.433035714285715e-06 1.5 8.43359375e-06 0.0 8.441406249999999e-06 0.0 8.441964285714286e-06 1.5 8.450892857142857e-06 1.5 8.451450892857142e-06 0.0 8.459263392857143e-06 0.0 8.459821428571428e-06 1.5 8.46875e-06 1.5 8.469308035714286e-06 0.0 8.477120535714285e-06 0.0 8.47767857142857e-06 1.5 8.486607142857141e-06 1.5 8.487165178571428e-06 0.0 8.494977678571428e-06 0.0 8.495535714285714e-06 1.5 8.504464285714286e-06 1.5 8.50502232142857e-06 0.0 8.512834821428572e-06 0.0 8.513392857142857e-06 1.5 8.522321428571428e-06 1.5 8.522879464285713e-06 0.0 8.530691964285714e-06 0.0 8.531249999999999e-06 1.5 8.54017857142857e-06 1.5 8.540736607142857e-06 0.0 8.548549107142856e-06 0.0 8.549107142857143e-06 1.5 8.558035714285714e-06 1.5 8.55859375e-06 0.0 8.566406249999999e-06 0.0 8.566964285714285e-06 1.5 8.575892857142857e-06 1.5 8.576450892857142e-06 0.0 8.584263392857143e-06 0.0 8.584821428571428e-06 1.5 8.593749999999999e-06 1.5 8.594308035714286e-06 0.0 8.602120535714285e-06 0.0 8.60267857142857e-06 1.5 8.611607142857143e-06 1.5 8.612165178571428e-06 0.0 8.619977678571427e-06 0.0 8.620535714285714e-06 1.5 8.629464285714285e-06 1.5 8.63002232142857e-06 0.0 8.637834821428571e-06 0.0 8.638392857142856e-06 1.5 8.647321428571427e-06 1.5 8.647879464285714e-06 0.0 8.655691964285714e-06 0.0 8.656249999999999e-06 1.5 8.665178571428572e-06 1.5 8.665736607142857e-06 0.0 8.673549107142856e-06 0.0 8.674107142857143e-06 1.5 8.683035714285714e-06 1.5 8.683593749999999e-06 0.0 8.69140625e-06 0.0 8.691964285714285e-06 1.5 8.701450892857143e-06 1.5 8.702008928571428e-06 0.0 8.708705357142857e-06 0.0 8.709263392857142e-06 1.5 8.719308035714285e-06 1.5 8.71986607142857e-06 0.0 8.7265625e-06 0.0 8.727120535714285e-06 1.5 8.737165178571428e-06 1.5 8.737723214285714e-06 0.0 8.744419642857142e-06 0.0 8.744977678571429e-06 1.5 8.755022321428572e-06 1.5 8.755580357142857e-06 0.0 8.762276785714286e-06 0.0 8.762834821428571e-06 1.5 8.772879464285714e-06 1.5 8.773437499999999e-06 0.0 8.780133928571428e-06 0.0 8.780691964285713e-06 1.5 8.790736607142856e-06 1.5 8.791294642857143e-06 0.0 8.79799107142857e-06 0.0 8.798549107142857e-06 1.5 8.808593749999999e-06 1.5 8.809151785714285e-06 0.0 8.815848214285713e-06 0.0 8.81640625e-06 1.5 8.826450892857143e-06 1.5 8.827008928571428e-06 0.0 8.833705357142857e-06 0.0 8.834263392857142e-06 1.5 8.844308035714285e-06 1.5 8.844866071428572e-06 0.0 8.8515625e-06 0.0 8.852120535714286e-06 1.5 8.862165178571427e-06 1.5 8.862723214285714e-06 0.0 8.869419642857141e-06 0.0 8.869977678571428e-06 1.5 8.880022321428571e-06 1.5 8.880580357142856e-06 0.0 8.887276785714286e-06 0.0 8.88783482142857e-06 1.5 8.897879464285714e-06 1.5 8.898437499999999e-06 0.0 8.905133928571428e-06 0.0 8.905691964285713e-06 1.5 8.915736607142856e-06 1.5 8.916294642857143e-06 0.0 8.92299107142857e-06 0.0 8.923549107142857e-06 1.5 8.93359375e-06 1.5 8.934151785714285e-06 0.0 8.940848214285714e-06 0.0 8.94140625e-06 1.5 8.951450892857142e-06 1.5 8.952008928571427e-06 0.0 8.958705357142856e-06 0.0 8.959263392857142e-06 1.5 8.969308035714285e-06 1.5 8.969866071428571e-06 0.0 8.976562499999999e-06 0.0 8.977120535714286e-06 1.5 8.987165178571429e-06 1.5 8.987723214285714e-06 0.0 8.994419642857143e-06 0.0 8.994977678571428e-06 1.5 9.005022321428571e-06 1.5 9.005580357142856e-06 0.0 9.012276785714285e-06 0.0 9.01283482142857e-06 1.5 9.022879464285713e-06 1.5 9.0234375e-06 0.0 9.030133928571427e-06 0.0 9.030691964285714e-06 1.5 9.040736607142857e-06 1.5 9.041294642857142e-06 0.0 9.047991071428571e-06 0.0 9.048549107142857e-06 1.5 9.05859375e-06 1.5 9.059151785714285e-06 0.0 9.065848214285714e-06 0.0 9.066406249999999e-06 1.5 9.076450892857142e-06 1.5 9.077008928571429e-06 0.0 9.083705357142856e-06 0.0 9.084263392857143e-06 1.5 9.094308035714286e-06 1.5 9.094866071428571e-06 0.0 9.1015625e-06 0.0 9.102120535714285e-06 1.5 9.112165178571428e-06 1.5 9.112723214285713e-06 0.0 9.119419642857142e-06 0.0 9.119977678571428e-06 1.5 9.13002232142857e-06 1.5 9.130580357142857e-06 0.0 9.137276785714285e-06 0.0 9.137834821428572e-06 1.5 9.147879464285713e-06 1.5 9.1484375e-06 0.0 9.155133928571427e-06 0.0 9.155691964285714e-06 1.5 9.165736607142857e-06 1.5 9.166294642857142e-06 0.0 9.172991071428571e-06 0.0 9.173549107142856e-06 1.5 9.18359375e-06 1.5 9.184151785714284e-06 0.0 9.190848214285713e-06 0.0 9.191406249999999e-06 1.5 9.201450892857142e-06 1.5 9.202008928571428e-06 0.0 9.208705357142856e-06 0.0 9.209263392857143e-06 1.5 9.219308035714286e-06 1.5 9.21986607142857e-06 0.0 9.2265625e-06 0.0 9.227120535714285e-06 1.5 9.237165178571428e-06 1.5 9.237723214285713e-06 0.0 9.244419642857142e-06 0.0 9.244977678571427e-06 1.5 9.25502232142857e-06 1.5 9.255580357142857e-06 0.0 9.262276785714284e-06 0.0 9.262834821428571e-06 1.5 9.272879464285714e-06 1.5 9.2734375e-06 0.0 9.280133928571428e-06 0.0 9.280691964285714e-06 1.5 9.290736607142857e-06 1.5 9.291294642857142e-06 0.0 9.29799107142857e-06 0.0 9.298549107142856e-06 1.5 9.308593749999999e-06 1.5 9.309151785714286e-06 0.0 9.315848214285713e-06 0.0 9.31640625e-06 1.5 9.326450892857143e-06 1.5 9.327008928571428e-06 0.0 9.333705357142857e-06 0.0 9.334263392857142e-06 1.5 9.344308035714285e-06 1.5 9.34486607142857e-06 0.0 9.3515625e-06 0.0 9.352120535714285e-06 1.5 9.362165178571427e-06 1.5 9.362723214285714e-06 0.0 9.369419642857142e-06 0.0 9.369977678571429e-06 1.5 9.380022321428572e-06 1.5 9.380580357142857e-06 0.0 9.387276785714286e-06 0.0 9.387834821428571e-06 1.5 9.397879464285714e-06 1.5 9.398437499999999e-06 0.0 9.405133928571428e-06 0.0 9.405691964285713e-06 1.5 9.415736607142856e-06 1.5 9.416294642857143e-06 0.0 9.42299107142857e-06 0.0 9.423549107142857e-06 1.5 9.433593749999998e-06 1.5 9.434151785714285e-06 0.0 9.440848214285713e-06 0.0 9.44140625e-06 1.5 9.451450892857143e-06 1.5 9.452008928571428e-06 0.0 9.458705357142857e-06 0.0 9.459263392857142e-06 1.5 9.469308035714285e-06 1.5 9.469866071428572e-06 0.0 9.476562499999999e-06 0.0 9.477120535714286e-06 1.5 9.487165178571427e-06 1.5 9.487723214285714e-06 0.0 9.494419642857141e-06 0.0 9.494977678571428e-06 1.5 9.505022321428571e-06 1.5 9.505580357142856e-06 0.0 9.512276785714285e-06 0.0 9.51283482142857e-06 1.5 9.522879464285713e-06 1.5 9.523437499999999e-06 0.0 9.530133928571428e-06 0.0 9.530691964285713e-06 1.5 9.540736607142856e-06 1.5 9.541294642857143e-06 0.0 9.54799107142857e-06 0.0 9.548549107142857e-06 1.5 9.55859375e-06 1.5 9.559151785714285e-06 0.0 9.565848214285714e-06 0.0 9.56640625e-06 1.5 9.576450892857142e-06 1.5 9.577008928571427e-06 0.0 9.583705357142856e-06 0.0 9.584263392857141e-06 1.5 9.594308035714284e-06 1.5 9.594866071428571e-06 0.0 9.601562499999999e-06 0.0 9.602120535714286e-06 1.5 9.612165178571428e-06 1.5 9.612723214285714e-06 0.0 9.619419642857143e-06 0.0 9.619977678571428e-06 1.5 9.63002232142857e-06 1.5 9.630580357142856e-06 0.0 9.637276785714285e-06 0.0 9.63783482142857e-06 1.5 9.647879464285713e-06 1.5 9.6484375e-06 0.0 9.655133928571427e-06 0.0 9.655691964285714e-06 1.5 9.665736607142857e-06 1.5 9.666294642857142e-06 0.0 9.672991071428571e-06 0.0 9.673549107142856e-06 1.5 9.68359375e-06 1.5 9.684151785714285e-06 0.0 9.690848214285714e-06 0.0 9.691406249999999e-06 1.5 9.701450892857142e-06 1.5 9.702008928571429e-06 0.0 9.708705357142856e-06 0.0 9.709263392857143e-06 1.5 9.719308035714286e-06 1.5 9.719866071428571e-06 0.0 9.7265625e-06 0.0 9.727120535714285e-06 1.5 9.737165178571428e-06 1.5 9.737723214285713e-06 0.0 9.744419642857142e-06 0.0 9.744977678571427e-06 1.5 9.75502232142857e-06 1.5 9.755580357142857e-06 0.0 9.762276785714285e-06 0.0 9.762834821428572e-06 1.5 9.772879464285713e-06 1.5 9.7734375e-06 0.0 9.780133928571427e-06 0.0 9.780691964285714e-06 1.5 9.790736607142857e-06 1.5 9.791294642857142e-06 0.0 9.797991071428571e-06 0.0 9.798549107142856e-06 1.5 9.808593749999999e-06 1.5 9.809151785714284e-06 0.0 9.815848214285713e-06 0.0 9.816406249999998e-06 1.5 9.826450892857141e-06 1.5 9.827008928571428e-06 0.0 9.833705357142856e-06 0.0 9.834263392857142e-06 1.5 9.844308035714285e-06 1.5 9.84486607142857e-06 0.0 9.8515625e-06 0.0 9.852120535714285e-06 1.5 9.862165178571428e-06 1.5 9.862723214285713e-06 0.0 9.869419642857142e-06 0.0 9.869977678571427e-06 1.5 9.88002232142857e-06 1.5 9.880580357142857e-06 0.0 9.887276785714284e-06 0.0 9.887834821428571e-06 1.5 9.897879464285714e-06 1.5 9.8984375e-06 0.0 9.905133928571428e-06 0.0 9.905691964285713e-06 1.5 9.915736607142856e-06 1.5 9.916294642857142e-06 0.0 9.92299107142857e-06 0.0 9.923549107142856e-06 1.5 9.933593749999999e-06 1.5 9.934151785714286e-06 0.0 9.940848214285713e-06 0.0 9.94140625e-06 1.5 9.951450892857143e-06 1.5 9.952008928571428e-06 0.0 9.958705357142857e-06 0.0 9.959263392857142e-06 1.5 9.969308035714285e-06 1.5 9.96986607142857e-06 0.0 9.9765625e-06 0.0 9.977120535714284e-06 1.5 9.987165178571427e-06 1.5 9.987723214285714e-06 0.0 9.994419642857142e-06 0.0 9.994977678571428e-06 1.5 1.0005022321428571e-05 1.5 1.0005580357142857e-05 0.0 1.0012276785714286e-05 0.0 1.001283482142857e-05 1.5 1.0022879464285714e-05 1.5 1.0023437499999999e-05 0.0 1.0030133928571428e-05 0.0 1.0030691964285713e-05 1.5 1.0040736607142856e-05 1.5 1.0041294642857143e-05 0.0 1.004799107142857e-05 0.0 1.0048549107142857e-05 1.5 1.005859375e-05 1.5 1.0059151785714285e-05 0.0 1.0065848214285714e-05 0.0 1.006640625e-05 1.5 1.0076450892857142e-05 1.5 1.0077008928571428e-05 0.0 1.0083705357142857e-05 0.0 1.0084263392857142e-05 1.5 1.0094308035714285e-05 1.5 1.0094866071428572e-05 0.0 1.0101562499999999e-05 0.0 1.0102120535714286e-05 1.5 1.0112165178571427e-05 1.5 1.0112723214285714e-05 0.0 1.0119419642857141e-05 0.0 1.0119977678571428e-05 1.5 1.0130022321428571e-05 1.5 1.0130580357142856e-05 0.0 1.0137276785714285e-05 0.0 1.013783482142857e-05 1.5 1.0147879464285713e-05 1.5 1.0148437499999998e-05 0.0 1.0155133928571428e-05 0.0 1.0155691964285713e-05 1.5 1.0165736607142856e-05 1.5 1.0166294642857143e-05 0.0 1.017299107142857e-05 0.0 1.0173549107142857e-05 1.5 1.018359375e-05 1.5 1.0184151785714285e-05 0.0 1.0190848214285714e-05 0.0 1.0191406249999999e-05 1.5 1.0201450892857142e-05 1.5 1.0202008928571427e-05 0.0 1.0208705357142856e-05 0.0 1.0209263392857141e-05 1.5 1.0219308035714284e-05 1.5 1.0219866071428571e-05 0.0 1.0226562499999999e-05 0.0 1.0227120535714285e-05 1.5 1.0237165178571428e-05 1.5 1.0237723214285714e-05 0.0 1.0244419642857143e-05 0.0 1.0244977678571428e-05 1.5 1.025502232142857e-05 1.5 1.0255580357142856e-05 0.0 1.0262276785714285e-05 0.0 1.026283482142857e-05 1.5 1.0272879464285713e-05 1.5 1.02734375e-05 0.0 1.0280133928571427e-05 0.0 1.0280691964285714e-05 1.5 1.0290736607142857e-05 1.5 1.0291294642857142e-05 0.0 1.0297991071428571e-05 0.0 1.0298549107142856e-05 1.5 1.030859375e-05 1.5 1.0309151785714284e-05 0.0 1.0315848214285714e-05 0.0 1.0316406249999999e-05 1.5 1.0326450892857142e-05 1.5 1.0327008928571429e-05 0.0 1.0333705357142856e-05 0.0 1.0334263392857143e-05 1.5 1.0344308035714286e-05 1.5 1.034486607142857e-05 0.0 1.03515625e-05 0.0 1.0352120535714285e-05 1.5 1.0362165178571428e-05 1.5 1.0362723214285713e-05 0.0 1.0369419642857142e-05 0.0 1.0369977678571427e-05 1.5 1.038002232142857e-05 1.5 1.0380580357142857e-05 0.0 1.0387276785714285e-05 0.0 1.0387834821428571e-05 1.5 1.0397879464285713e-05 1.5 1.03984375e-05 0.0 1.0405133928571427e-05 0.0 1.0405691964285714e-05 1.5 1.0415736607142857e-05 1.5 1.0416294642857142e-05 0.0 1.0422991071428571e-05 0.0 1.0423549107142856e-05 1.5 1.0433593749999999e-05 1.5 1.0434151785714284e-05 0.0 1.0440848214285713e-05 0.0 1.0441406249999998e-05 1.5 1.0451450892857141e-05 1.5 1.0452008928571428e-05 0.0 1.0458705357142856e-05 0.0 1.0459263392857142e-05 1.5 1.0469308035714285e-05 1.5 1.046986607142857e-05 0.0 1.04765625e-05 0.0 1.0477120535714285e-05 1.5 1.0487165178571428e-05 1.5 1.0487723214285713e-05 0.0 1.0494419642857142e-05 0.0 1.0494977678571427e-05 1.5 1.050502232142857e-05 1.5 1.0505580357142857e-05 0.0 1.0512276785714284e-05 0.0 1.0512834821428571e-05 1.5 1.0522879464285714e-05 1.5 1.0523437499999999e-05 0.0 1.0530133928571428e-05 0.0 1.0530691964285713e-05 1.5 1.0540736607142856e-05 1.5 1.0541294642857141e-05 0.0 1.054799107142857e-05 0.0 1.0548549107142856e-05 1.5 1.0558593749999999e-05 1.5 1.0559151785714285e-05 0.0 1.0565848214285713e-05 0.0 1.056640625e-05 1.5 1.0576450892857143e-05 1.5 1.0577008928571428e-05 0.0 1.0583705357142857e-05 0.0 1.0584263392857142e-05 1.5 1.0594308035714285e-05 1.5 1.059486607142857e-05 0.0 1.06015625e-05 0.0 1.0602120535714284e-05 1.5 1.0612165178571427e-05 1.5 1.0612723214285714e-05 0.0 1.0619419642857142e-05 0.0 1.0619977678571428e-05 1.5 1.0630022321428571e-05 1.5 1.0630580357142856e-05 0.0 1.0637276785714286e-05 0.0 1.063783482142857e-05 1.5 1.0647879464285714e-05 1.5 1.0648437499999999e-05 0.0 1.0655133928571428e-05 0.0 1.0655691964285713e-05 1.5 1.0665736607142856e-05 1.5 1.0666294642857143e-05 0.0 1.067299107142857e-05 0.0 1.0673549107142857e-05 1.5 1.068359375e-05 1.5 1.0684151785714285e-05 0.0 1.0690848214285714e-05 0.0 1.069140625e-05 1.5 1.0701450892857142e-05 1.5 1.0702008928571427e-05 0.0 1.0708705357142857e-05 0.0 1.0709263392857142e-05 1.5 1.0719308035714285e-05 1.5 1.0719866071428571e-05 0.0 1.0726562499999999e-05 0.0 1.0727120535714286e-05 1.5 1.0737165178571427e-05 1.5 1.0737723214285714e-05 0.0 1.0744419642857141e-05 0.0 1.0744977678571428e-05 1.5 1.0755022321428571e-05 1.5 1.0755580357142856e-05 0.0 1.0762276785714285e-05 0.0 1.076283482142857e-05 1.5 1.0772879464285713e-05 1.5 1.0773437499999998e-05 0.0 1.0780133928571428e-05 0.0 1.0780691964285713e-05 1.5 1.0790736607142856e-05 1.5 1.0791294642857142e-05 0.0 1.079799107142857e-05 0.0 1.0798549107142857e-05 1.5 1.080859375e-05 1.5 1.0809151785714285e-05 0.0 1.0815848214285714e-05 0.0 1.0816406249999999e-05 1.5 1.0826450892857142e-05 1.5 1.0827008928571427e-05 0.0 1.0833705357142856e-05 0.0 1.0834263392857141e-05 1.5 1.0844308035714284e-05 1.5 1.0844866071428571e-05 0.0 1.0851562499999999e-05 0.0 1.0852120535714285e-05 1.5 1.0862165178571428e-05 1.5 1.0862723214285713e-05 0.0 1.0869419642857143e-05 0.0 1.0869977678571428e-05 1.5 1.088002232142857e-05 1.5 1.0880580357142856e-05 0.0 1.0887276785714285e-05 0.0 1.088783482142857e-05 1.5 1.0897879464285713e-05 1.5 1.08984375e-05 0.0 1.0905133928571427e-05 0.0 1.0905691964285714e-05 1.5 1.0915736607142857e-05 1.5 1.0916294642857142e-05 0.0 1.0922991071428571e-05 0.0 1.0923549107142856e-05 1.5 1.093359375e-05 1.5 1.0934151785714284e-05 0.0 1.0940848214285714e-05 0.0 1.0941406249999999e-05 1.5 1.0951450892857142e-05 1.5 1.0952008928571428e-05 0.0 1.0958705357142856e-05 0.0 1.0959263392857143e-05 1.5 1.0969308035714286e-05 1.5 1.096986607142857e-05 0.0 1.09765625e-05 0.0 1.0977120535714285e-05 1.5 1.0987165178571428e-05 1.5 1.0987723214285713e-05 0.0 1.0994419642857142e-05 0.0 1.0994977678571427e-05 1.5 1.100502232142857e-05 1.5 1.1005580357142857e-05 0.0 1.1012276785714285e-05 0.0 1.1012834821428571e-05 1.5 1.1022879464285713e-05 1.5 1.10234375e-05 0.0 1.1030133928571427e-05 0.0 1.1030691964285714e-05 1.5 1.1040736607142857e-05 1.5 1.1041294642857142e-05 0.0 1.1047991071428571e-05 0.0 1.1048549107142856e-05 1.5 1.1058593749999999e-05 1.5 1.1059151785714284e-05 0.0 1.1065848214285713e-05 0.0 1.1066406249999998e-05 1.5 1.1076450892857141e-05 1.5 1.1077008928571428e-05 0.0 1.1083705357142856e-05 0.0 1.1084263392857142e-05 1.5 1.1094308035714285e-05 1.5 1.109486607142857e-05 0.0 1.11015625e-05 0.0 1.1102120535714285e-05 1.5 1.1112165178571428e-05 1.5 1.1112723214285713e-05 0.0 1.1119419642857142e-05 0.0 1.1119977678571427e-05 1.5 1.113002232142857e-05 1.5 1.1130580357142857e-05 0.0 1.1137276785714284e-05 0.0 1.1137834821428571e-05 1.5 1.1147879464285714e-05 1.5 1.1148437499999999e-05 0.0 1.1155133928571428e-05 0.0 1.1155691964285713e-05 1.5 1.1165736607142856e-05 1.5 1.1166294642857141e-05 0.0 1.117299107142857e-05 0.0 1.1173549107142856e-05 1.5 1.1183593749999999e-05 1.5 1.1184151785714285e-05 0.0 1.1190848214285713e-05 0.0 1.119140625e-05 1.5 1.1201450892857143e-05 1.5 1.1202008928571428e-05 0.0 1.1208705357142857e-05 0.0 1.1209263392857142e-05 1.5 1.1219308035714285e-05 1.5 1.121986607142857e-05 0.0 1.12265625e-05 0.0 1.1227120535714284e-05 1.5 1.1237165178571427e-05 1.5 1.1237723214285714e-05 0.0 1.1244419642857142e-05 0.0 1.1244977678571428e-05 1.5 1.1255022321428571e-05 1.5 1.1255580357142856e-05 0.0 1.1262276785714286e-05 0.0 1.126283482142857e-05 1.5 1.1272879464285714e-05 1.5 1.1273437499999999e-05 0.0 1.1280133928571428e-05 0.0 1.1280691964285713e-05 1.5 1.1290736607142856e-05 1.5 1.1291294642857143e-05 0.0 1.129799107142857e-05 0.0 1.1298549107142857e-05 1.5 1.130859375e-05 1.5 1.1309151785714285e-05 0.0 1.1315848214285714e-05 0.0 1.131640625e-05 1.5 1.1326450892857142e-05 1.5 1.1327008928571427e-05 0.0 1.1333705357142857e-05 0.0 1.1334263392857142e-05 1.5 1.1344308035714285e-05 1.5 1.1344866071428571e-05 0.0 1.1351562499999999e-05 0.0 1.1352120535714286e-05 1.5 1.1362165178571427e-05 1.5 1.1362723214285714e-05 0.0 1.1369977678571428e-05 0.0 1.1370535714285713e-05 1.5 1.1379464285714284e-05 1.5 1.1380022321428571e-05 0.0 1.138783482142857e-05 0.0 1.1388392857142857e-05 1.5 1.1397321428571428e-05 1.5 1.1397879464285713e-05 0.0 1.1405691964285713e-05 0.0 1.140625e-05 1.5 1.141517857142857e-05 1.5 1.1415736607142856e-05 0.0 1.1423549107142857e-05 0.0 1.1424107142857142e-05 1.5 1.1433035714285713e-05 1.5 1.143359375e-05 0.0 1.1441406249999999e-05 0.0 1.1441964285714284e-05 1.5 1.1450892857142857e-05 1.5 1.1451450892857142e-05 0.0 1.1459263392857141e-05 0.0 1.1459821428571428e-05 1.5 1.146875e-05 1.5 1.1469308035714284e-05 0.0 1.1477120535714285e-05 0.0 1.147767857142857e-05 1.5 1.1486607142857142e-05 1.5 1.1487165178571428e-05 0.0 1.1494977678571428e-05 0.0 1.1495535714285713e-05 1.5 1.1504464285714286e-05 1.5 1.150502232142857e-05 0.0 1.151283482142857e-05 0.0 1.1513392857142857e-05 1.5 1.1522321428571428e-05 1.5 1.1522879464285713e-05 0.0 1.1530691964285714e-05 0.0 1.1531249999999999e-05 1.5 1.154017857142857e-05 1.5 1.1540736607142857e-05 0.0 1.1548549107142856e-05 0.0 1.1549107142857141e-05 1.5 1.1558035714285714e-05 1.5 1.155859375e-05 0.0 1.1566406249999999e-05 0.0 1.1566964285714285e-05 1.5 1.1575892857142857e-05 1.5 1.1576450892857142e-05 0.0 1.1584263392857143e-05 0.0 1.1584821428571428e-05 1.5 1.1593749999999999e-05 1.5 1.1594308035714286e-05 0.0 1.1602120535714285e-05 0.0 1.160267857142857e-05 1.5 1.1611607142857141e-05 1.5 1.1612165178571428e-05 0.0 1.1619977678571427e-05 0.0 1.1620535714285714e-05 1.5 1.1629464285714285e-05 1.5 1.163002232142857e-05 0.0 1.1637834821428571e-05 0.0 1.1638392857142856e-05 1.5 1.1647321428571428e-05 1.5 1.1647879464285713e-05 0.0 1.1655691964285714e-05 0.0 1.1656249999999999e-05 1.5 1.166517857142857e-05 1.5 1.1665736607142857e-05 0.0 1.1673549107142856e-05 0.0 1.1674107142857143e-05 1.5 1.1683035714285714e-05 1.5 1.1683593749999999e-05 0.0 1.169140625e-05 0.0 1.1691964285714285e-05 1.5 1.1700892857142856e-05 1.5 1.1701450892857141e-05 0.0 1.1709263392857142e-05 0.0 1.1709821428571427e-05 1.5 1.1718749999999999e-05 1.5 1.1719308035714285e-05 0.0 1.1727120535714285e-05 0.0 1.1727678571428571e-05 1.5 1.1736607142857143e-05 1.5 1.1737165178571428e-05 0.0 1.1744977678571427e-05 0.0 1.1745535714285714e-05 1.5 1.1754464285714285e-05 1.5 1.175502232142857e-05 0.0 1.1762834821428571e-05 0.0 1.1763392857142856e-05 1.5 1.1772321428571427e-05 1.5 1.1772879464285714e-05 0.0 1.1780691964285713e-05 0.0 1.1781249999999998e-05 1.5 1.1790178571428571e-05 1.5 1.1790736607142856e-05 0.0 1.1798549107142856e-05 0.0 1.1799107142857142e-05 1.5 1.1808035714285714e-05 1.5 1.1808593749999999e-05 0.0 1.181640625e-05 0.0 1.1816964285714285e-05 1.5 1.1825892857142856e-05 1.5 1.1826450892857143e-05 0.0 1.1834263392857142e-05 0.0 1.1834821428571427e-05 1.5 1.184375e-05 1.5 1.1844308035714285e-05 0.0 1.1852120535714284e-05 0.0 1.1852678571428571e-05 1.5 1.1861607142857142e-05 1.5 1.1862165178571427e-05 0.0 1.1869977678571428e-05 0.0 1.1870535714285713e-05 1.5 1.1879464285714285e-05 1.5 1.1880022321428571e-05 0.0 1.188783482142857e-05 0.0 1.1888392857142856e-05 1.5 1.1897321428571429e-05 1.5 1.1897879464285714e-05 0.0 1.1905691964285713e-05 0.0 1.190625e-05 1.5 1.1915178571428571e-05 1.5 1.1915736607142856e-05 0.0 1.1923549107142857e-05 0.0 1.1924107142857142e-05 1.5 1.1933035714285713e-05 1.5 1.193359375e-05 0.0 1.194140625e-05 0.0 1.1941964285714284e-05 1.5 1.1950892857142856e-05 1.5 1.1951450892857142e-05 0.0 1.1959263392857142e-05 0.0 1.1959821428571428e-05 1.5 1.196875e-05 1.5 1.1969308035714285e-05 0.0 1.1977120535714286e-05 0.0 1.197767857142857e-05 1.5 1.1986607142857142e-05 1.5 1.1987165178571427e-05 0.0 1.1994977678571428e-05 0.0 1.1995535714285713e-05 1.5 1.2004464285714284e-05 1.5 1.2005022321428571e-05 0.0 1.201283482142857e-05 0.0 1.2013392857142857e-05 1.5 1.2022321428571428e-05 1.5 1.2022879464285713e-05 0.0 1.2030691964285713e-05 0.0 1.203125e-05 1.5 1.2039620535714285e-05 1.5 1.204017857142857e-05 0.0 1.2049107142857142e-05 0.0 1.2049665178571428e-05 1.5 1.2057477678571428e-05 1.5 1.2058035714285713e-05 0.0 1.2066964285714284e-05 0.0 1.206752232142857e-05 1.5 1.207533482142857e-05 1.5 1.2075892857142857e-05 0.0 1.2084821428571428e-05 0.0 1.2085379464285713e-05 1.5 1.2093191964285714e-05 1.5 1.209375e-05 0.0 1.210267857142857e-05 0.0 1.2103236607142857e-05 1.5 1.2111049107142856e-05 1.5 1.2111607142857142e-05 0.0 1.2120535714285713e-05 0.0 1.212109375e-05 1.5 1.2128906249999999e-05 1.5 1.2129464285714286e-05 0.0 1.2138392857142857e-05 0.0 1.2138950892857142e-05 1.5 1.2146763392857143e-05 1.5 1.2147321428571428e-05 0.0 1.2156249999999999e-05 0.0 1.2156808035714284e-05 1.5 1.2164620535714285e-05 1.5 1.216517857142857e-05 0.0 1.2174107142857141e-05 0.0 1.2174665178571428e-05 1.5 1.2182477678571427e-05 1.5 1.2183035714285714e-05 0.0 1.2191964285714285e-05 0.0 1.219252232142857e-05 1.5 1.220033482142857e-05 1.5 1.2200892857142857e-05 0.0 1.2209821428571428e-05 0.0 1.2210379464285713e-05 1.5 1.2218191964285714e-05 1.5 1.2218749999999999e-05 0.0 1.222767857142857e-05 0.0 1.2228236607142857e-05 1.5 1.2236049107142856e-05 1.5 1.2236607142857141e-05 0.0 1.2245535714285714e-05 0.0 1.2246093749999999e-05 1.5 1.2253906249999998e-05 1.5 1.2254464285714285e-05 0.0 1.2263392857142856e-05 0.0 1.2263950892857141e-05 1.5 1.2271763392857142e-05 1.5 1.2272321428571428e-05 0.0 1.2281249999999999e-05 0.0 1.2281808035714285e-05 1.5 1.2289620535714285e-05 1.5 1.229017857142857e-05 0.0 1.2299107142857143e-05 0.0 1.2299665178571428e-05 1.5 1.2307477678571427e-05 1.5 1.2308035714285714e-05 0.0 1.2316964285714285e-05 0.0 1.231752232142857e-05 1.5 1.2325334821428571e-05 1.5 1.2325892857142856e-05 0.0 1.2334821428571427e-05 0.0 1.2335379464285714e-05 1.5 1.2343191964285713e-05 1.5 1.2343749999999998e-05 0.0 1.2352678571428571e-05 0.0 1.2353236607142856e-05 1.5 1.2361049107142856e-05 1.5 1.2361607142857143e-05 0.0 1.2370535714285714e-05 0.0 1.2371093749999999e-05 1.5 1.237890625e-05 1.5 1.2379464285714285e-05 0.0 1.2388392857142856e-05 0.0 1.2388950892857143e-05 1.5 1.2396763392857142e-05 1.5 1.2397321428571427e-05 0.0 1.2406249999999998e-05 0.0 1.2406808035714285e-05 1.5 1.2414620535714284e-05 1.5 1.2415178571428571e-05 0.0 1.2424107142857142e-05 0.0 1.2424665178571427e-05 1.5 1.2432477678571428e-05 1.5 1.2433035714285713e-05 0.0 1.2441964285714285e-05 0.0 1.244252232142857e-05 1.5 1.245033482142857e-05 1.5 1.2450892857142856e-05 0.0 1.2459821428571427e-05 0.0 1.2460379464285714e-05 1.5 1.2468191964285713e-05 1.5 1.246875e-05 0.0 1.2477678571428571e-05 0.0 1.2478236607142856e-05 1.5 1.2486049107142855e-05 1.5 1.2486607142857142e-05 0.0 1.2495535714285713e-05 0.0 1.2496093749999998e-05 1.5 1.250390625e-05 1.5 1.2504464285714284e-05 0.0 1.2513392857142856e-05 0.0 1.2513950892857142e-05 1.5 1.2521763392857142e-05 1.5 1.2522321428571429e-05 0.0 1.253125e-05 0.0 1.2531808035714285e-05 1.5 1.2539620535714284e-05 1.5 1.254017857142857e-05 0.0 1.2549107142857142e-05 0.0 1.2549665178571427e-05 1.5 1.2557477678571428e-05 1.5 1.2558035714285713e-05 0.0 1.2566964285714284e-05 0.0 1.2567522321428571e-05 1.5 1.257533482142857e-05 1.5 1.2575892857142855e-05 0.0 1.2584821428571428e-05 0.0 1.2585379464285713e-05 1.5 1.2593191964285713e-05 1.5 1.259375e-05 0.0 1.260267857142857e-05 0.0 1.2603236607142856e-05 1.5 1.2611049107142857e-05 1.5 1.2611607142857142e-05 0.0 1.2620535714285713e-05 0.0 1.262109375e-05 1.5 1.2628906249999999e-05 1.5 1.2629464285714284e-05 0.0 1.2638392857142857e-05 0.0 1.2638950892857142e-05 1.5 1.2646763392857141e-05 1.5 1.2647321428571428e-05 0.0 1.265625e-05 0.0 1.2656808035714284e-05 1.5 1.2664620535714285e-05 1.5 1.266517857142857e-05 0.0 1.2674107142857142e-05 0.0 1.2674665178571428e-05 1.5 1.2682477678571428e-05 1.5 1.2683035714285713e-05 0.0 1.2691964285714284e-05 0.0 1.269252232142857e-05 1.5 1.270033482142857e-05 1.5 1.2700892857142857e-05 0.0 1.2710379464285713e-05 0.0 1.27109375e-05 1.5 1.2717633928571427e-05 1.5 1.2718191964285714e-05 0.0 1.2728236607142857e-05 0.0 1.2728794642857142e-05 1.5 1.2735491071428571e-05 1.5 1.2736049107142856e-05 0.0 1.274609375e-05 0.0 1.2746651785714284e-05 1.5 1.2753348214285714e-05 1.5 1.2753906249999999e-05 0.0 1.2763950892857142e-05 0.0 1.2764508928571428e-05 1.5 1.2771205357142856e-05 1.5 1.2771763392857143e-05 0.0 1.2781808035714284e-05 0.0 1.278236607142857e-05 1.5 1.2789062499999998e-05 1.5 1.2789620535714285e-05 0.0 1.2799665178571428e-05 0.0 1.2800223214285713e-05 1.5 1.2806919642857142e-05 1.5 1.2807477678571427e-05 0.0 1.281752232142857e-05 0.0 1.2818080357142855e-05 1.5 1.2824776785714285e-05 1.5 1.282533482142857e-05 0.0 1.2835379464285713e-05 0.0 1.28359375e-05 1.5 1.2842633928571427e-05 1.5 1.2843191964285714e-05 0.0 1.2853236607142857e-05 0.0 1.2853794642857142e-05 1.5 1.2860491071428571e-05 1.5 1.2861049107142856e-05 0.0 1.2871093749999999e-05 0.0 1.2871651785714284e-05 1.5 1.2878348214285713e-05 1.5 1.2878906249999998e-05 0.0 1.2888950892857141e-05 0.0 1.2889508928571428e-05 1.5 1.2896205357142856e-05 1.5 1.2896763392857142e-05 0.0 1.2906808035714285e-05 0.0 1.290736607142857e-05 1.5 1.29140625e-05 1.5 1.2914620535714285e-05 0.0 1.2924665178571428e-05 0.0 1.2925223214285713e-05 1.5 1.2931919642857142e-05 1.5 1.2932477678571427e-05 0.0 1.294252232142857e-05 0.0 1.2943080357142857e-05 1.5 1.2949776785714284e-05 1.5 1.2950334821428571e-05 0.0 1.2960379464285714e-05 0.0 1.2960937499999999e-05 1.5 1.2967633928571428e-05 1.5 1.2968191964285713e-05 0.0 1.2978236607142856e-05 0.0 1.2978794642857141e-05 1.5 1.298549107142857e-05 1.5 1.2986049107142856e-05 0.0 1.2996093749999999e-05 0.0 1.2996651785714285e-05 1.5 1.3003348214285713e-05 1.5 1.300390625e-05 0.0 1.3013950892857143e-05 0.0 1.3014508928571428e-05 1.5 1.3021205357142857e-05 1.5 1.3021763392857142e-05 0.0 1.3031808035714285e-05 0.0 1.303236607142857e-05 1.5 1.30390625e-05 1.5 1.3039620535714284e-05 0.0 1.3049665178571427e-05 0.0 1.3050223214285714e-05 1.5 1.3056919642857142e-05 1.5 1.3057477678571428e-05 0.0 1.306752232142857e-05 0.0 1.3068080357142856e-05 1.5 1.3074776785714284e-05 1.5 1.307533482142857e-05 0.0 1.3085379464285714e-05 0.0 1.3085937499999999e-05 1.5 1.3092633928571428e-05 1.5 1.3093191964285713e-05 0.0 1.3103236607142856e-05 0.0 1.3103794642857141e-05 1.5 1.311049107142857e-05 1.5 1.3111049107142857e-05 0.0 1.3121093749999998e-05 0.0 1.3121651785714285e-05 1.5 1.3128348214285713e-05 1.5 1.312890625e-05 0.0 1.3138950892857142e-05 0.0 1.3139508928571427e-05 1.5 1.3146205357142857e-05 1.5 1.3146763392857142e-05 0.0 1.3156808035714285e-05 0.0 1.315736607142857e-05 1.5 1.3164062499999999e-05 1.5 1.3164620535714284e-05 0.0 1.3174665178571427e-05 0.0 1.3175223214285714e-05 1.5 1.3181919642857141e-05 1.5 1.3182477678571428e-05 0.0 1.3192522321428571e-05 0.0 1.3193080357142856e-05 1.5 1.3199776785714285e-05 1.5 1.320033482142857e-05 0.0 1.3210379464285713e-05 0.0 1.3210937499999998e-05 1.5 1.3217633928571428e-05 1.5 1.3218191964285713e-05 0.0 1.3228236607142856e-05 0.0 1.3228794642857142e-05 1.5 1.323549107142857e-05 1.5 1.3236049107142857e-05 0.0 1.324609375e-05 0.0 1.3246651785714285e-05 1.5 1.3253348214285714e-05 1.5 1.3253906249999999e-05 0.0 1.3263950892857142e-05 0.0 1.3264508928571427e-05 1.5 1.3271205357142856e-05 1.5 1.3271763392857141e-05 0.0 1.3281808035714284e-05 0.0 1.3282366071428571e-05 1.5 1.3289062499999999e-05 1.5 1.3289620535714285e-05 0.0 1.3299665178571428e-05 0.0 1.3300223214285713e-05 1.5 1.3306919642857143e-05 1.5 1.3307477678571428e-05 0.0 1.331752232142857e-05 0.0 1.3318080357142856e-05 1.5 1.3324776785714285e-05 1.5 1.332533482142857e-05 0.0 1.3335379464285713e-05 0.0 1.33359375e-05 1.5 1.3342633928571427e-05 1.5 1.3343191964285714e-05 0.0 1.3353236607142857e-05 0.0 1.3353794642857142e-05 1.5 1.3360491071428571e-05 1.5 1.3361049107142856e-05 0.0 1.337109375e-05 0.0 1.3371651785714284e-05 1.5 1.3378348214285714e-05 1.5 1.3378906249999999e-05 0.0 1.3388950892857142e-05 0.0 1.3389508928571428e-05 1.5 1.3396205357142856e-05 1.5 1.3396763392857143e-05 0.0 1.3406808035714284e-05 0.0 1.340736607142857e-05 1.5 1.3414062499999998e-05 1.5 1.3414620535714285e-05 0.0 1.3424665178571428e-05 0.0 1.3425223214285713e-05 1.5 1.3431919642857142e-05 1.5 1.3432477678571427e-05 0.0 1.344252232142857e-05 0.0 1.3443080357142855e-05 1.5 1.3449776785714285e-05 1.5 1.345033482142857e-05 0.0 1.3460379464285713e-05 0.0 1.34609375e-05 1.5 1.3467633928571427e-05 1.5 1.3468191964285714e-05 0.0 1.3478236607142857e-05 0.0 1.3478794642857142e-05 1.5 1.3485491071428571e-05 1.5 1.3486049107142856e-05 0.0 1.3496093749999999e-05 0.0 1.3496651785714284e-05 1.5 1.3503348214285713e-05 1.5 1.3503906249999998e-05 0.0 1.3513950892857141e-05 0.0 1.3514508928571428e-05 1.5 1.3521205357142856e-05 1.5 1.3521763392857142e-05 0.0 1.3531808035714285e-05 0.0 1.353236607142857e-05 1.5 1.35390625e-05 1.5 1.3539620535714285e-05 0.0 1.3549665178571428e-05 0.0 1.3550223214285713e-05 1.5 1.3556919642857142e-05 1.5 1.3557477678571427e-05 0.0 1.356752232142857e-05 0.0 1.3568080357142857e-05 1.5 1.3574776785714284e-05 1.5 1.3575334821428571e-05 0.0 1.3585379464285714e-05 0.0 1.3585937499999999e-05 1.5 1.3592633928571428e-05 1.5 1.3593191964285713e-05 0.0 1.3603236607142856e-05 0.0 1.3603794642857141e-05 1.5 1.361049107142857e-05 1.5 1.3611049107142856e-05 0.0 1.3621093749999999e-05 0.0 1.3621651785714285e-05 1.5 1.3628348214285713e-05 1.5 1.362890625e-05 0.0 1.3638950892857143e-05 0.0 1.3639508928571428e-05 1.5 1.3646205357142857e-05 1.5 1.3646763392857142e-05 0.0 1.3656808035714285e-05 0.0 1.365736607142857e-05 1.5 1.36640625e-05 1.5 1.3664620535714284e-05 0.0 1.3674665178571427e-05 0.0 1.3675223214285714e-05 1.5 1.3681919642857142e-05 1.5 1.3682477678571428e-05 0.0 1.369252232142857e-05 0.0 1.3693080357142856e-05 1.5 1.3699776785714284e-05 1.5 1.370033482142857e-05 0.0 1.3710379464285714e-05 0.0 1.3710937499999999e-05 1.5 1.3717633928571428e-05 1.5 1.3718191964285713e-05 0.0 1.3728236607142856e-05 0.0 1.3728794642857143e-05 1.5 1.373549107142857e-05 1.5 1.3736049107142857e-05 0.0 1.3746093749999998e-05 0.0 1.3746651785714285e-05 1.5 1.3753348214285713e-05 1.5 1.375390625e-05 0.0 1.3763950892857142e-05 0.0 1.3764508928571427e-05 1.5 1.3771205357142857e-05 1.5 1.3771763392857142e-05 0.0 1.3781808035714285e-05 0.0 1.378236607142857e-05 1.5 1.3789062499999999e-05 1.5 1.3789620535714284e-05 0.0 1.3799665178571427e-05 0.0 1.3800223214285714e-05 1.5 1.3806919642857141e-05 1.5 1.3807477678571428e-05 0.0 1.3817522321428571e-05 0.0 1.3818080357142856e-05 1.5 1.3824776785714285e-05 1.5 1.382533482142857e-05 0.0 1.3835379464285713e-05 0.0 1.3835937499999998e-05 1.5 1.3842633928571428e-05 1.5 1.3843191964285713e-05 0.0 1.3853236607142856e-05 0.0 1.3853794642857142e-05 1.5 1.386049107142857e-05 1.5 1.3861049107142857e-05 0.0 1.387109375e-05 0.0 1.3871651785714285e-05 1.5 1.3878348214285714e-05 1.5 1.3878906249999999e-05 0.0 1.3888950892857142e-05 0.0 1.3889508928571427e-05 1.5 1.3896205357142856e-05 1.5 1.3896763392857141e-05 0.0 1.3906808035714284e-05 0.0 1.3907366071428571e-05 1.5 1.3914062499999999e-05 1.5 1.3914620535714285e-05 0.0 1.3924665178571428e-05 0.0 1.3925223214285713e-05 1.5 1.3931919642857143e-05 1.5 1.3932477678571428e-05 0.0 1.394252232142857e-05 0.0 1.3943080357142856e-05 1.5 1.3949776785714285e-05 1.5 1.395033482142857e-05 0.0 1.3960379464285713e-05 0.0 1.39609375e-05 1.5 1.3967633928571427e-05 1.5 1.3968191964285714e-05 0.0 1.3978236607142857e-05 0.0 1.3978794642857142e-05 1.5 1.3985491071428571e-05 1.5 1.3986049107142856e-05 0.0 1.399609375e-05 0.0 1.3996651785714284e-05 1.5 1.4003348214285714e-05 1.5 1.4003906249999999e-05 0.0 1.4013950892857142e-05 0.0 1.4014508928571428e-05 1.5 1.4021205357142856e-05 1.5 1.4021763392857143e-05 0.0 1.4031808035714284e-05 0.0 1.403236607142857e-05 1.5 1.4039062499999998e-05 1.5 1.4039620535714285e-05 0.0 1.4049665178571428e-05 0.0 1.4050223214285713e-05 1.5 1.4056919642857142e-05 1.5 1.4057477678571427e-05 0.0 1.406752232142857e-05 0.0 1.4068080357142855e-05 1.5 1.4074776785714285e-05 1.5 1.407533482142857e-05 0.0 1.4085379464285713e-05 0.0 1.40859375e-05 1.5 1.4092633928571427e-05 1.5 1.4093191964285714e-05 0.0 1.4103236607142857e-05 0.0 1.4103794642857142e-05 1.5 1.4110491071428571e-05 1.5 1.4111049107142856e-05 0.0 1.4121093749999999e-05 0.0 1.4121651785714284e-05 1.5 1.4128348214285713e-05 1.5 1.4128906249999998e-05 0.0 1.4138950892857141e-05 0.0 1.4139508928571428e-05 1.5 1.4146205357142856e-05 1.5 1.4146763392857142e-05 0.0 1.4156808035714285e-05 0.0 1.415736607142857e-05 1.5 1.41640625e-05 1.5 1.4164620535714285e-05 0.0 1.4174665178571428e-05 0.0 1.4175223214285713e-05 1.5 1.4181919642857142e-05 1.5 1.4182477678571427e-05 0.0 1.419252232142857e-05 0.0 1.4193080357142857e-05 1.5 1.4199776785714284e-05 1.5 1.4200334821428571e-05 0.0 1.4210379464285714e-05 0.0 1.4210937499999999e-05 1.5 1.4217633928571428e-05 1.5 1.4218191964285713e-05 0.0 1.4228236607142856e-05 0.0 1.4228794642857141e-05 1.5 1.423549107142857e-05 1.5 1.4236049107142856e-05 0.0 1.4246093749999999e-05 0.0 1.4246651785714285e-05 1.5 1.4253348214285713e-05 1.5 1.425390625e-05 0.0 1.4263950892857143e-05 0.0 1.4264508928571428e-05 1.5 1.4271205357142857e-05 1.5 1.4271763392857142e-05 0.0 1.4281808035714285e-05 0.0 1.428236607142857e-05 1.5 1.42890625e-05 1.5 1.4289620535714284e-05 0.0 1.4299665178571427e-05 0.0 1.4300223214285714e-05 1.5 1.4306919642857142e-05 1.5 1.4307477678571428e-05 0.0 1.431752232142857e-05 0.0 1.4318080357142856e-05 1.5 1.4324776785714286e-05 1.5 1.432533482142857e-05 0.0 1.4335379464285714e-05 0.0 1.4335937499999999e-05 1.5 1.4342633928571428e-05 1.5 1.4343191964285713e-05 0.0 1.4353236607142856e-05 0.0 1.4353794642857143e-05 1.5 1.436049107142857e-05 1.5 1.4361049107142857e-05 0.0 1.4371093749999998e-05 0.0 1.4371651785714285e-05 1.5 1.4378348214285713e-05 1.5 1.437890625e-05 0.0 1.4388950892857142e-05 0.0 1.4389508928571427e-05 1.5 1.4396205357142857e-05 1.5 1.4396763392857142e-05 0.0 1.4406808035714285e-05 0.0 1.440736607142857e-05 1.5 1.4414062499999999e-05 1.5 1.4414620535714284e-05 0.0 1.4424665178571427e-05 0.0 1.4425223214285714e-05 1.5 1.4431919642857141e-05 1.5 1.4432477678571428e-05 0.0 1.4442522321428571e-05 0.0 1.4443080357142856e-05 1.5 1.4449776785714285e-05 1.5 1.445033482142857e-05 0.0 1.4460379464285713e-05 0.0 1.4460937499999998e-05 1.5 1.4467633928571428e-05 1.5 1.4468191964285713e-05 0.0 1.4478236607142856e-05 0.0 1.4478794642857142e-05 1.5 1.448549107142857e-05 1.5 1.4486049107142857e-05 0.0 1.449609375e-05 0.0 1.4496651785714285e-05 1.5 1.4503348214285714e-05 1.5 1.4503906249999999e-05 0.0 1.4513950892857142e-05 0.0 1.4514508928571427e-05 1.5 1.4521205357142856e-05 1.5 1.4521763392857141e-05 0.0 1.4531808035714284e-05 0.0 1.4532366071428571e-05 1.5 1.4539062499999998e-05 1.5 1.4539620535714285e-05 0.0 1.4549665178571428e-05 0.0 1.4550223214285713e-05 1.5 1.4556919642857143e-05 1.5 1.4557477678571428e-05 0.0 1.456752232142857e-05 0.0 1.4568080357142856e-05 1.5 1.4574776785714285e-05 1.5 1.457533482142857e-05 0.0 1.4585379464285713e-05 0.0 1.45859375e-05 1.5 1.4592633928571427e-05 1.5 1.4593191964285714e-05 0.0 1.4603236607142857e-05 0.0 1.4603794642857142e-05 1.5 1.4610491071428571e-05 1.5 1.4611049107142856e-05 0.0 1.462109375e-05 0.0 1.4621651785714284e-05 1.5 1.4628348214285713e-05 1.5 1.4628906249999999e-05 0.0 1.4638950892857142e-05 0.0 1.4639508928571428e-05 1.5 1.4646205357142856e-05 1.5 1.4646763392857143e-05 0.0 1.4656808035714284e-05 0.0 1.465736607142857e-05 1.5 1.4664062499999998e-05 1.5 1.4664620535714285e-05 0.0 1.4674665178571428e-05 0.0 1.4675223214285713e-05 1.5 1.4681919642857142e-05 1.5 1.4682477678571427e-05 0.0 1.469252232142857e-05 0.0 1.4693080357142855e-05 1.5 1.4699776785714284e-05 1.5 1.470033482142857e-05 0.0 1.4710379464285713e-05 0.0 1.47109375e-05 1.5 1.4717633928571427e-05 1.5 1.4718191964285714e-05 0.0 1.4728236607142857e-05 0.0 1.4728794642857142e-05 1.5 1.473549107142857e-05 1.5 1.4736049107142856e-05 0.0 1.4746093749999999e-05 0.0 1.4746651785714284e-05 1.5 1.4753348214285713e-05 1.5 1.4753906249999998e-05 0.0 1.4763950892857141e-05 0.0 1.4764508928571428e-05 1.5 1.4771205357142855e-05 1.5 1.4771763392857142e-05 0.0 1.4781808035714285e-05 0.0 1.478236607142857e-05 1.5 1.47890625e-05 1.5 1.4789620535714285e-05 0.0 1.4799665178571428e-05 0.0 1.4800223214285713e-05 1.5 1.4806919642857142e-05 1.5 1.4807477678571427e-05 0.0 1.481752232142857e-05 0.0 1.4818080357142857e-05 1.5 1.4824776785714284e-05 1.5 1.4825334821428571e-05 0.0 1.4835379464285714e-05 0.0 1.4835937499999999e-05 1.5 1.4842633928571428e-05 1.5 1.4843191964285713e-05 0.0 1.4853236607142856e-05 0.0 1.4853794642857141e-05 1.5 1.486049107142857e-05 1.5 1.4861049107142856e-05 0.0 1.4871093749999999e-05 0.0 1.4871651785714285e-05 1.5 1.4878348214285713e-05 1.5 1.487890625e-05 0.0 1.4888950892857143e-05 0.0 1.4889508928571428e-05 1.5 1.4896205357142857e-05 1.5 1.4896763392857142e-05 0.0 1.4906808035714285e-05 0.0 1.490736607142857e-05 1.5 1.4914062499999999e-05 1.5 1.4914620535714284e-05 0.0 1.4924665178571427e-05 0.0 1.4925223214285714e-05 1.5 1.4931919642857141e-05 1.5 1.4932477678571428e-05 0.0 1.4942522321428571e-05 0.0 1.4943080357142856e-05 1.5 1.4949776785714285e-05 1.5 1.495033482142857e-05 0.0 1.4960379464285714e-05 0.0 1.4960937499999999e-05 1.5 1.4967633928571428e-05 1.5 1.4968191964285713e-05 0.0 1.4978236607142856e-05 0.0 1.4978794642857143e-05 1.5 1.498549107142857e-05 1.5 1.4986049107142857e-05 0.0 1.4996093749999998e-05 0.0 1.4996651785714285e-05 1.5 1.5003348214285712e-05 1.5 1.500390625e-05 0.0 1.5013950892857142e-05 0.0 1.5014508928571427e-05 1.5 1.5021205357142856e-05 1.5 1.5021763392857142e-05 0.0 1.5031808035714285e-05 0.0 1.503236607142857e-05 1.5 1.5039062499999999e-05 1.5 1.5039620535714284e-05 0.0 1.5049665178571427e-05 0.0 1.5050223214285714e-05 1.5 1.5056919642857141e-05 1.5 1.5057477678571428e-05 0.0 1.5067522321428571e-05 0.0 1.5068080357142856e-05 1.5 1.5074776785714285e-05 1.5 1.507533482142857e-05 0.0 1.5085379464285713e-05 0.0 1.5085937499999998e-05 1.5 1.5092633928571427e-05 1.5 1.5093191964285713e-05 0.0 1.5103236607142855e-05 0.0 1.5103794642857142e-05 1.5 1.511049107142857e-05 1.5 1.5111049107142857e-05 0.0 1.512109375e-05 0.0 1.5121651785714285e-05 1.5 1.5128348214285714e-05 1.5 1.5128906249999999e-05 0.0 1.5138950892857142e-05 0.0 1.5139508928571427e-05 1.5 1.5146205357142856e-05 1.5 1.5146763392857141e-05 0.0 1.5156808035714284e-05 0.0 1.5157366071428571e-05 1.5 1.5164062499999998e-05 1.5 1.5164620535714285e-05 0.0 1.5174665178571428e-05 0.0 1.5175223214285713e-05 1.5 1.5181919642857142e-05 1.5 1.5182477678571428e-05 0.0 1.519252232142857e-05 0.0 1.5193080357142856e-05 1.5 1.5199776785714285e-05 1.5 1.520033482142857e-05 0.0 1.5210379464285713e-05 0.0 1.52109375e-05 1.5 1.5217633928571427e-05 1.5 1.5218191964285714e-05 0.0 1.5228236607142857e-05 0.0 1.5228794642857142e-05 1.5 1.5235491071428571e-05 1.5 1.5236049107142856e-05 0.0 1.524609375e-05 0.0 1.5246651785714284e-05 1.5 1.5253348214285713e-05 1.5 1.5253906249999999e-05 0.0 1.5263950892857143e-05 0.0 1.5264508928571427e-05 1.5 1.5271205357142857e-05 1.5 1.527176339285714e-05 0.0 1.5281808035714286e-05 0.0 1.528236607142857e-05 1.5 1.52890625e-05 1.5 1.5289620535714283e-05 0.0 1.5299665178571428e-05 0.0 1.5300223214285715e-05 1.5 1.5306919642857142e-05 1.5 1.530747767857143e-05 0.0 1.531752232142857e-05 0.0 1.5318080357142857e-05 1.5 1.5324776785714284e-05 1.5 1.532533482142857e-05 0.0 1.5335379464285712e-05 0.0 1.53359375e-05 1.5 1.5342633928571427e-05 1.5 1.5343191964285714e-05 0.0 1.5353236607142855e-05 0.0 1.535379464285714e-05 1.5 1.536049107142857e-05 1.5 1.5361049107142856e-05 0.0 1.537109375e-05 0.0 1.5371651785714284e-05 1.5 1.5378348214285715e-05 1.5 1.5378906249999998e-05 0.0 1.5388392857142856e-05 0.0 1.5388950892857143e-05 1.5 1.539676339285714e-05 1.5 1.5397321428571427e-05 0.0 1.540625e-05 0.0 1.5406808035714285e-05 1.5 1.5414620535714286e-05 1.5 1.541517857142857e-05 0.0 1.542410714285714e-05 0.0 1.5424665178571427e-05 1.5 1.543247767857143e-05 1.5 1.5433035714285712e-05 0.0 1.5441964285714283e-05 0.0 1.544252232142857e-05 1.5 1.545033482142857e-05 1.5 1.5450892857142858e-05 0.0 1.545982142857143e-05 0.0 1.5460379464285712e-05 1.5 1.5468191964285713e-05 1.5 1.546875e-05 0.0 1.547767857142857e-05 0.0 1.5478236607142854e-05 1.5 1.5486049107142855e-05 1.5 1.5486607142857142e-05 0.0 1.5495535714285713e-05 0.0 1.549609375e-05 1.5 1.5503906249999998e-05 1.5 1.5504464285714285e-05 0.0 1.5513392857142856e-05 0.0 1.5513950892857142e-05 1.5 1.552176339285714e-05 1.5 1.5522321428571427e-05 0.0 1.5531249999999998e-05 0.0 1.5531808035714285e-05 1.5 1.5539620535714286e-05 1.5 1.554017857142857e-05 0.0 1.554910714285714e-05 0.0 1.5549665178571427e-05 1.5 1.5557477678571428e-05 1.5 1.555803571428571e-05 0.0 1.5566964285714286e-05 0.0 1.556752232142857e-05 1.5 1.557533482142857e-05 1.5 1.5575892857142857e-05 0.0 1.558482142857143e-05 0.0 1.5585379464285712e-05 1.5 1.5593191964285713e-05 1.5 1.559375e-05 0.0 1.560267857142857e-05 0.0 1.5603236607142857e-05 1.5 1.5611049107142855e-05 1.5 1.5611607142857142e-05 0.0 1.5620535714285713e-05 0.0 1.562109375e-05 1.5 1.5628906249999997e-05 1.5 1.5629464285714284e-05 0.0 1.5638392857142855e-05 0.0 1.5638950892857142e-05 1.5 1.5646763392857143e-05 1.5 1.5647321428571427e-05 0.0 1.5656249999999998e-05 0.0 1.5656808035714284e-05 1.5 1.5664620535714285e-05 1.5 1.566517857142857e-05 0.0 1.5674107142857143e-05 0.0 1.5674665178571427e-05 1.5 1.5682477678571428e-05 1.5 1.5683035714285715e-05 0.0 1.5691964285714286e-05 0.0 1.569252232142857e-05 1.5 1.570033482142857e-05 1.5 1.5700892857142857e-05 0.0 1.5709821428571428e-05 0.0 1.5710379464285715e-05 1.5 1.5718191964285712e-05 1.5 1.571875e-05 0.0 1.572767857142857e-05 0.0 1.5728236607142857e-05 1.5 1.5736049107142855e-05 1.5 1.573660714285714e-05 0.0 1.5745535714285713e-05 0.0 1.574609375e-05 1.5 1.575390625e-05 1.5 1.5754464285714284e-05 0.0 1.5763392857142855e-05 0.0 1.5763950892857142e-05 1.5 1.5771763392857143e-05 1.5 1.5772321428571426e-05 0.0 1.5781249999999997e-05 0.0 1.5781808035714284e-05 1.5 1.5789620535714285e-05 1.5 1.5790178571428572e-05 0.0 1.5799107142857143e-05 0.0 1.5799665178571426e-05 1.5 1.5807477678571427e-05 1.5 1.5808035714285714e-05 0.0 1.5816964285714285e-05 0.0 1.581752232142857e-05 1.5 1.582533482142857e-05 1.5 1.5825892857142857e-05 0.0 1.5834821428571428e-05 0.0 1.5835379464285714e-05 1.5 1.5843191964285712e-05 1.5 1.584375e-05 0.0 1.585267857142857e-05 0.0 1.5853236607142857e-05 1.5 1.5861049107142854e-05 1.5 1.586160714285714e-05 0.0 1.5870535714285712e-05 0.0 1.587109375e-05 1.5 1.587890625e-05 1.5 1.5879464285714284e-05 0.0 1.5888392857142855e-05 0.0 1.588895089285714e-05 1.5 1.5896763392857142e-05 1.5 1.5897321428571426e-05 0.0 1.590625e-05 0.0 1.5906808035714284e-05 1.5 1.5914620535714285e-05 1.5 1.591517857142857e-05 0.0 1.5924107142857143e-05 0.0 1.5924665178571426e-05 1.5 1.5932477678571427e-05 1.5 1.5933035714285714e-05 0.0 1.5941964285714285e-05 0.0 1.5942522321428572e-05 1.5 1.595033482142857e-05 1.5 1.5950892857142856e-05 0.0 1.5959821428571427e-05 0.0 1.5960379464285714e-05 1.5 1.5968191964285712e-05 1.5 1.596875e-05 0.0 1.597767857142857e-05 0.0 1.5978236607142856e-05 1.5 1.5986049107142857e-05 1.5 1.598660714285714e-05 0.0 1.5995535714285712e-05 0.0 1.599609375e-05 1.5 1.600390625e-05 1.5 1.6004464285714283e-05 0.0 1.6013392857142854e-05 0.0 1.601395089285714e-05 1.5 1.6021763392857142e-05 1.5 1.602232142857143e-05 0.0 1.603125e-05 0.0 1.6031808035714283e-05 1.5 1.6039620535714284e-05 1.5 1.604017857142857e-05 0.0 1.6049107142857142e-05 0.0 1.6049665178571426e-05 1.5 1.6058035714285714e-05 1.5 1.605859375e-05 0.0 1.6066406249999998e-05 0.0 1.6066964285714285e-05 1.5 1.6075892857142856e-05 1.5 1.6076450892857143e-05 0.0 1.608426339285714e-05 0.0 1.6084821428571427e-05 1.5 1.6093749999999998e-05 1.5 1.6094308035714285e-05 0.0 1.6102120535714286e-05 0.0 1.610267857142857e-05 1.5 1.611160714285714e-05 1.5 1.6112165178571427e-05 0.0 1.6119977678571428e-05 0.0 1.612053571428571e-05 1.5 1.6129464285714286e-05 1.5 1.613002232142857e-05 0.0 1.613783482142857e-05 0.0 1.6138392857142857e-05 1.5 1.614732142857143e-05 1.5 1.6147879464285712e-05 0.0 1.6155691964285713e-05 0.0 1.615625e-05 1.5 1.616517857142857e-05 1.5 1.6165736607142858e-05 0.0 1.6173549107142855e-05 0.0 1.6174107142857142e-05 1.5 1.6183035714285713e-05 1.5 1.618359375e-05 0.0 1.6191406249999998e-05 0.0 1.6191964285714284e-05 1.5 1.6200892857142855e-05 1.5 1.6201450892857142e-05 0.0 1.6209263392857143e-05 0.0 1.6209821428571427e-05 1.5 1.6218749999999998e-05 1.5 1.6219308035714285e-05 0.0 1.6227120535714286e-05 0.0 1.622767857142857e-05 1.5 1.623660714285714e-05 1.5 1.6237165178571427e-05 0.0 1.6244977678571428e-05 0.0 1.6245535714285715e-05 1.5 1.6254464285714286e-05 1.5 1.625502232142857e-05 0.0 1.626283482142857e-05 0.0 1.6263392857142857e-05 1.5 1.6272321428571428e-05 1.5 1.627287946428571e-05 0.0 1.6280691964285713e-05 0.0 1.628125e-05 1.5 1.629017857142857e-05 1.5 1.6290736607142857e-05 0.0 1.6298549107142855e-05 0.0 1.629910714285714e-05 1.5 1.6308035714285713e-05 1.5 1.630859375e-05 0.0 1.6316406249999997e-05 0.0 1.6316964285714284e-05 1.5 1.6325892857142855e-05 1.5 1.6326450892857142e-05 0.0 1.6334263392857143e-05 0.0 1.6334821428571426e-05 1.5 1.6343749999999997e-05 1.5 1.6344308035714284e-05 0.0 1.6352120535714285e-05 0.0 1.635267857142857e-05 1.5 1.6361607142857143e-05 1.5 1.6362165178571427e-05 0.0 1.6369977678571428e-05 0.0 1.6370535714285714e-05 1.5 1.6379464285714286e-05 1.5 1.638002232142857e-05 0.0 1.638783482142857e-05 0.0 1.6388392857142857e-05 1.5 1.6397321428571428e-05 1.5 1.6397879464285715e-05 0.0 1.6405691964285712e-05 0.0 1.640625e-05 1.5 1.641517857142857e-05 1.5 1.6415736607142857e-05 0.0 1.6423549107142855e-05 0.0 1.642410714285714e-05 1.5 1.6433035714285712e-05 1.5 1.643359375e-05 0.0 1.644140625e-05 0.0 1.6441964285714284e-05 1.5 1.6450892857142855e-05 1.5 1.645145089285714e-05 0.0 1.6459263392857143e-05 0.0 1.6459821428571426e-05 1.5 1.646875e-05 1.5 1.6469308035714284e-05 0.0 1.6477120535714285e-05 0.0 1.647767857142857e-05 1.5 1.6486607142857143e-05 1.5 1.6487165178571426e-05 0.0 1.6494977678571427e-05 0.0 1.6495535714285714e-05 1.5 1.6504464285714285e-05 1.5 1.6505022321428572e-05 0.0 1.651283482142857e-05 0.0 1.6513392857142856e-05 1.5 1.6522321428571427e-05 1.5 1.6522879464285714e-05 0.0 1.6530691964285712e-05 0.0 1.653125e-05 1.5 1.654017857142857e-05 1.5 1.6540736607142857e-05 0.0 1.6548549107142858e-05 0.0 1.654910714285714e-05 1.5 1.6558035714285712e-05 1.5 1.655859375e-05 0.0 1.656640625e-05 0.0 1.6566964285714283e-05 1.5 1.6575892857142854e-05 1.5 1.657645089285714e-05 0.0 1.6584263392857142e-05 0.0 1.658482142857143e-05 1.5 1.659375e-05 1.5 1.6594308035714284e-05 0.0 1.6602120535714285e-05 0.0 1.660267857142857e-05 1.5 1.6611607142857142e-05 1.5 1.6612165178571426e-05 0.0 1.6619977678571427e-05 0.0 1.6620535714285714e-05 1.5 1.6629464285714285e-05 1.5 1.663002232142857e-05 0.0 1.663783482142857e-05 0.0 1.6638392857142856e-05 1.5 1.6647321428571427e-05 1.5 1.6647879464285714e-05 0.0 1.665569196428571e-05 0.0 1.6656249999999998e-05 1.5 1.666517857142857e-05 1.5 1.6665736607142856e-05 0.0 1.6673549107142857e-05 0.0 1.667410714285714e-05 1.5 1.6683035714285712e-05 1.5 1.668359375e-05 0.0 1.669140625e-05 0.0 1.6691964285714283e-05 1.5 1.6700892857142857e-05 1.5 1.670145089285714e-05 0.0 1.6709263392857142e-05 0.0 1.670982142857143e-05 1.5 1.671875e-05 1.5 1.6719308035714283e-05 0.0 1.6726562499999997e-05 0.0 1.6727120535714284e-05 1.5 1.673716517857143e-05 1.5 1.6737723214285712e-05 0.0 1.6744419642857143e-05 0.0 1.6744977678571427e-05 1.5 1.675502232142857e-05 1.5 1.6755580357142855e-05 0.0 1.6762276785714285e-05 0.0 1.676283482142857e-05 1.5 1.6772879464285714e-05 1.5 1.67734375e-05 0.0 1.6780133928571428e-05 0.0 1.6780691964285715e-05 1.5 1.6790736607142856e-05 1.5 1.6791294642857143e-05 0.0 1.679799107142857e-05 0.0 1.6798549107142857e-05 1.5 1.6808593749999998e-05 1.5 1.6809151785714285e-05 0.0 1.6815848214285712e-05 0.0 1.681640625e-05 1.5 1.682645089285714e-05 1.5 1.6827008928571427e-05 0.0 1.6833705357142855e-05 0.0 1.683426339285714e-05 1.5 1.6844308035714283e-05 1.5 1.684486607142857e-05 0.0 1.6851562499999997e-05 0.0 1.6852120535714284e-05 1.5 1.686216517857143e-05 1.5 1.6862723214285712e-05 0.0 1.6869419642857143e-05 0.0 1.6869977678571426e-05 1.5 1.688002232142857e-05 1.5 1.6880580357142858e-05 0.0 1.6887276785714285e-05 0.0 1.6887834821428572e-05 1.5 1.6897879464285713e-05 1.5 1.68984375e-05 0.0 1.6905133928571427e-05 0.0 1.6905691964285714e-05 1.5 1.6915736607142856e-05 1.5 1.6916294642857142e-05 0.0 1.692299107142857e-05 0.0 1.6923549107142857e-05 1.5 1.6933593749999998e-05 1.5 1.6934151785714285e-05 0.0 1.6940848214285712e-05 0.0 1.694140625e-05 1.5 1.695145089285714e-05 1.5 1.6952008928571427e-05 0.0 1.6958705357142854e-05 0.0 1.695926339285714e-05 1.5 1.6969308035714286e-05 1.5 1.696986607142857e-05 0.0 1.69765625e-05 0.0 1.6977120535714284e-05 1.5 1.6987165178571428e-05 1.5 1.698772321428571e-05 0.0 1.6994419642857142e-05 0.0 1.6994977678571426e-05 1.5 1.700502232142857e-05 1.5 1.7005580357142857e-05 0.0 1.7012276785714285e-05 0.0 1.701283482142857e-05 1.5 1.7022879464285713e-05 1.5 1.70234375e-05 0.0 1.7030133928571427e-05 0.0 1.7030691964285714e-05 1.5 1.7040736607142855e-05 1.5 1.7041294642857142e-05 0.0 1.704799107142857e-05 0.0 1.7048549107142856e-05 1.5 1.7058593749999997e-05 1.5 1.7059151785714284e-05 0.0 1.7065848214285712e-05 0.0 1.706640625e-05 1.5 1.7076450892857143e-05 1.5 1.7077008928571427e-05 0.0 1.7083705357142857e-05 0.0 1.708426339285714e-05 1.5 1.7094308035714286e-05 1.5 1.709486607142857e-05 0.0 1.71015625e-05 0.0 1.7102120535714283e-05 1.5 1.7112165178571428e-05 1.5 1.7112723214285715e-05 0.0 1.7119419642857142e-05 0.0 1.711997767857143e-05 1.5 1.713002232142857e-05 1.5 1.7130580357142857e-05 0.0 1.7137276785714284e-05 0.0 1.713783482142857e-05 1.5 1.7147879464285712e-05 1.5 1.71484375e-05 0.0 1.7155133928571427e-05 0.0 1.7155691964285714e-05 1.5 1.7165736607142855e-05 1.5 1.716629464285714e-05 0.0 1.717299107142857e-05 0.0 1.7173549107142856e-05 1.5 1.7183593749999997e-05 1.5 1.7184151785714284e-05 0.0 1.719084821428571e-05 0.0 1.7191406249999998e-05 1.5 1.7201450892857143e-05 1.5 1.7202008928571426e-05 0.0 1.7208705357142857e-05 0.0 1.720926339285714e-05 1.5 1.7219308035714285e-05 1.5 1.721986607142857e-05 0.0 1.72265625e-05 0.0 1.7227120535714283e-05 1.5 1.7237165178571427e-05 1.5 1.7237723214285714e-05 0.0 1.7244419642857142e-05 0.0 1.724497767857143e-05 1.5 1.725502232142857e-05 1.5 1.7255580357142857e-05 0.0 1.7262276785714284e-05 0.0 1.726283482142857e-05 1.5 1.7272879464285712e-05 1.5 1.72734375e-05 0.0 1.7280133928571426e-05 0.0 1.7280691964285713e-05 1.5 1.7290736607142854e-05 1.5 1.729129464285714e-05 0.0 1.729799107142857e-05 0.0 1.7298549107142855e-05 1.5 1.730859375e-05 1.5 1.7309151785714284e-05 0.0 1.7315848214285714e-05 0.0 1.7316406249999998e-05 1.5 1.7326450892857142e-05 1.5 1.7327008928571426e-05 0.0 1.7333705357142857e-05 0.0 1.733426339285714e-05 1.5 1.7344308035714285e-05 1.5 1.734486607142857e-05 0.0 1.73515625e-05 0.0 1.7352120535714286e-05 1.5 1.7362165178571427e-05 1.5 1.7362723214285714e-05 0.0 1.736941964285714e-05 0.0 1.7369977678571428e-05 1.5 1.738002232142857e-05 1.5 1.7380580357142856e-05 0.0 1.7387276785714284e-05 0.0 1.738783482142857e-05 1.5 1.7397879464285712e-05 1.5 1.73984375e-05 0.0 1.7405133928571426e-05 0.0 1.7405691964285713e-05 1.5 1.7415736607142857e-05 1.5 1.741629464285714e-05 0.0 1.7422991071428572e-05 0.0 1.7423549107142855e-05 1.5 1.743359375e-05 1.5 1.7434151785714283e-05 0.0 1.7440848214285714e-05 0.0 1.7441406249999997e-05 1.5 1.7451450892857142e-05 1.5 1.745200892857143e-05 0.0 1.7458705357142856e-05 0.0 1.7459263392857143e-05 1.5 1.7469308035714284e-05 1.5 1.746986607142857e-05 0.0 1.74765625e-05 0.0 1.7477120535714286e-05 1.5 1.7487165178571427e-05 1.5 1.7487723214285714e-05 0.0 1.749441964285714e-05 0.0 1.7494977678571428e-05 1.5 1.750502232142857e-05 1.5 1.7505580357142856e-05 0.0 1.7512276785714283e-05 0.0 1.751283482142857e-05 1.5 1.752287946428571e-05 1.5 1.7523437499999998e-05 0.0 1.7530133928571426e-05 0.0 1.7530691964285712e-05 1.5 1.7540736607142857e-05 1.5 1.754129464285714e-05 0.0 1.754799107142857e-05 0.0 1.7548549107142855e-05 1.5 1.755859375e-05 1.5 1.7559151785714283e-05 0.0 1.7565848214285714e-05 0.0 1.7566406249999997e-05 1.5 1.7576450892857142e-05 1.5 1.757700892857143e-05 0.0 1.7583705357142856e-05 0.0 1.7584263392857143e-05 1.5 1.7594308035714284e-05 1.5 1.759486607142857e-05 0.0 1.76015625e-05 0.0 1.7602120535714285e-05 1.5 1.7612165178571426e-05 1.5 1.7612723214285713e-05 0.0 1.761941964285714e-05 0.0 1.7619977678571427e-05 1.5 1.763002232142857e-05 1.5 1.7630580357142856e-05 0.0 1.7637276785714283e-05 0.0 1.763783482142857e-05 1.5 1.7647879464285714e-05 1.5 1.7648437499999998e-05 0.0 1.765513392857143e-05 0.0 1.7655691964285712e-05 1.5 1.7665736607142857e-05 1.5 1.766629464285714e-05 0.0 1.767299107142857e-05 0.0 1.7673549107142854e-05 1.5 1.768359375e-05 1.5 1.7684151785714286e-05 0.0 1.7690848214285713e-05 0.0 1.769140625e-05 1.5 1.770145089285714e-05 1.5 1.7702008928571428e-05 0.0 1.7708705357142856e-05 0.0 1.7709263392857142e-05 1.5 1.7719308035714284e-05 1.5 1.771986607142857e-05 0.0 1.7726562499999998e-05 0.0 1.7727120535714285e-05 1.5 1.7737165178571426e-05 1.5 1.7737723214285713e-05 0.0 1.774441964285714e-05 0.0 1.7744977678571427e-05 1.5 1.7755022321428572e-05 1.5 1.7755580357142855e-05 0.0 1.7762276785714286e-05 0.0 1.776283482142857e-05 1.5 1.7772879464285714e-05 1.5 1.7773437499999997e-05 0.0 1.778013392857143e-05 0.0 1.7780691964285712e-05 1.5 1.7790736607142856e-05 1.5 1.7791294642857143e-05 0.0 1.779799107142857e-05 0.0 1.7798549107142857e-05 1.5 1.780859375e-05 1.5 1.7809151785714286e-05 0.0 1.7815848214285713e-05 0.0 1.781640625e-05 1.5 1.782645089285714e-05 1.5 1.7827008928571428e-05 0.0 1.7833705357142855e-05 0.0 1.7834263392857142e-05 1.5 1.7844308035714283e-05 1.5 1.784486607142857e-05 0.0 1.7851562499999998e-05 0.0 1.7852120535714284e-05 1.5 1.7862165178571426e-05 1.5 1.7862723214285712e-05 0.0 1.786941964285714e-05 0.0 1.7869977678571427e-05 1.5 1.788002232142857e-05 1.5 1.7880580357142855e-05 0.0 1.7887276785714286e-05 0.0 1.788783482142857e-05 1.5 1.7897879464285714e-05 1.5 1.7898437499999997e-05 0.0 1.7905133928571428e-05 0.0 1.790569196428571e-05 1.5 1.7915736607142856e-05 1.5 1.7916294642857143e-05 0.0 1.792299107142857e-05 0.0 1.7923549107142857e-05 1.5 1.793359375e-05 1.5 1.7934151785714285e-05 0.0 1.7940848214285713e-05 0.0 1.794140625e-05 1.5 1.795145089285714e-05 1.5 1.7952008928571427e-05 0.0 1.7958705357142855e-05 0.0 1.7959263392857142e-05 1.5 1.7969308035714283e-05 1.5 1.796986607142857e-05 0.0 1.7976562499999997e-05 0.0 1.7977120535714284e-05 1.5 1.798716517857143e-05 1.5 1.7987723214285712e-05 0.0 1.7994419642857143e-05 0.0 1.7994977678571426e-05 1.5 1.800502232142857e-05 1.5 1.8005580357142854e-05 0.0 1.8012276785714285e-05 0.0 1.801283482142857e-05 1.5 1.8022879464285713e-05 1.5 1.80234375e-05 0.0 1.8030133928571428e-05 0.0 1.8030691964285714e-05 1.5 1.8040736607142856e-05 1.5 1.8041294642857143e-05 0.0 1.804799107142857e-05 0.0 1.8048549107142857e-05 1.5 1.8058593749999998e-05 1.5 1.8059151785714285e-05 0.0 1.8065848214285712e-05 0.0 1.806640625e-05 1.5 1.807645089285714e-05 1.5 1.8077008928571427e-05 0.0 1.8083705357142855e-05 0.0 1.808426339285714e-05 1.5 1.8094308035714286e-05 1.5 1.809486607142857e-05 0.0 1.81015625e-05 0.0 1.8102120535714284e-05 1.5 1.811216517857143e-05 1.5 1.8112723214285712e-05 0.0 1.8119419642857143e-05 0.0 1.8119977678571426e-05 1.5 1.813002232142857e-05 1.5 1.8130580357142858e-05 0.0 1.8137276785714285e-05 0.0 1.8137834821428572e-05 1.5 1.8147879464285713e-05 1.5 1.81484375e-05 0.0 1.8155133928571427e-05 0.0 1.8155691964285714e-05 1.5 1.8165736607142855e-05 1.5 1.8166294642857142e-05 0.0 1.817299107142857e-05 0.0 1.8173549107142856e-05 1.5 1.8183593749999998e-05 1.5 1.8184151785714284e-05 0.0 1.8190848214285712e-05 0.0 1.819140625e-05 1.5 1.820145089285714e-05 1.5 1.8202008928571427e-05 0.0 1.8208705357142854e-05 0.0 1.820926339285714e-05 1.5 1.8219308035714286e-05 1.5 1.821986607142857e-05 0.0 1.82265625e-05 0.0 1.8227120535714283e-05 1.5 1.8237165178571428e-05 1.5 1.823772321428571e-05 0.0 1.8244419642857142e-05 0.0 1.8244977678571426e-05 1.5 1.825502232142857e-05 1.5 1.8255580357142857e-05 0.0 1.8262276785714285e-05 0.0 1.826283482142857e-05 1.5 1.8272879464285713e-05 1.5 1.82734375e-05 0.0 1.8280133928571427e-05 0.0 1.8280691964285714e-05 1.5 1.8290736607142855e-05 1.5 1.8291294642857142e-05 0.0 1.829799107142857e-05 0.0 1.8298549107142856e-05 1.5 1.8308593749999997e-05 1.5 1.8309151785714284e-05 0.0 1.831584821428571e-05 0.0 1.831640625e-05 1.5 1.8326450892857143e-05 1.5 1.8327008928571426e-05 0.0 1.8333705357142857e-05 0.0 1.833426339285714e-05 1.5 1.8344308035714285e-05 1.5 1.834486607142857e-05 0.0 1.83515625e-05 0.0 1.8352120535714283e-05 1.5 1.8362165178571428e-05 1.5 1.8362723214285714e-05 0.0 1.8369419642857142e-05 0.0 1.836997767857143e-05 1.5 1.838002232142857e-05 1.5 1.8380580357142857e-05 0.0 1.8387276785714284e-05 0.0 1.838783482142857e-05 1.5 1.8397879464285712e-05 1.5 1.83984375e-05 0.0 1.8405133928571427e-05 0.0 1.8405691964285713e-05 1.5 1.8415736607142855e-05 1.5 1.841629464285714e-05 0.0 1.842299107142857e-05 0.0 1.8423549107142856e-05 1.5 1.8433593749999997e-05 1.5 1.8434151785714284e-05 0.0 1.844084821428571e-05 0.0 1.8441406249999998e-05 1.5 1.8451450892857143e-05 1.5 1.8452008928571426e-05 0.0 1.8458705357142857e-05 0.0 1.845926339285714e-05 1.5 1.8469308035714285e-05 1.5 1.846986607142857e-05 0.0 1.84765625e-05 0.0 1.8477120535714283e-05 1.5 1.8487165178571427e-05 1.5 1.8487723214285714e-05 0.0 1.849441964285714e-05 0.0 1.849497767857143e-05 1.5 1.850502232142857e-05 1.5 1.8505580357142856e-05 0.0 1.8512276785714284e-05 0.0 1.851283482142857e-05 1.5 1.8522879464285712e-05 1.5 1.85234375e-05 0.0 1.8530133928571426e-05 0.0 1.8530691964285713e-05 1.5 1.8540736607142854e-05 1.5 1.854129464285714e-05 0.0 1.854799107142857e-05 0.0 1.8548549107142855e-05 1.5 1.855859375e-05 1.5 1.8559151785714283e-05 0.0 1.8565848214285714e-05 0.0 1.8566406249999998e-05 1.5 1.8576450892857142e-05 1.5 1.8577008928571426e-05 0.0 1.8583705357142857e-05 0.0 1.858426339285714e-05 1.5 1.8594308035714285e-05 1.5 1.859486607142857e-05 0.0 1.86015625e-05 0.0 1.8602120535714286e-05 1.5 1.8612165178571427e-05 1.5 1.8612723214285714e-05 0.0 1.861941964285714e-05 0.0 1.8619977678571428e-05 1.5 1.863002232142857e-05 1.5 1.8630580357142856e-05 0.0 1.8637276785714284e-05 0.0 1.863783482142857e-05 1.5 1.864787946428571e-05 1.5 1.86484375e-05 0.0 1.8655133928571426e-05 0.0 1.8655691964285713e-05 1.5 1.8665736607142857e-05 1.5 1.866629464285714e-05 0.0 1.867299107142857e-05 0.0 1.8673549107142855e-05 1.5 1.868359375e-05 1.5 1.8684151785714283e-05 0.0 1.8690848214285714e-05 0.0 1.8691406249999997e-05 1.5 1.8701450892857142e-05 1.5 1.870200892857143e-05 0.0 1.8708705357142856e-05 0.0 1.8709263392857143e-05 1.5 1.8719308035714284e-05 1.5 1.871986607142857e-05 0.0 1.87265625e-05 0.0 1.8727120535714285e-05 1.5 1.8737165178571427e-05 1.5 1.8737723214285713e-05 0.0 1.874441964285714e-05 0.0 1.8744977678571428e-05 1.5 1.875502232142857e-05 1.5 1.8755580357142856e-05 0.0 1.8762276785714283e-05 0.0 1.876283482142857e-05 1.5 1.877287946428571e-05 1.5 1.8773437499999998e-05 0.0 1.8780133928571426e-05 0.0 1.8780691964285712e-05 1.5 1.8790736607142857e-05 1.5 1.879129464285714e-05 0.0 1.879799107142857e-05 0.0 1.8798549107142855e-05 1.5 1.880859375e-05 1.5 1.8809151785714283e-05 0.0 1.8815848214285714e-05 0.0 1.8816406249999997e-05 1.5 1.882645089285714e-05 1.5 1.882700892857143e-05 0.0 1.8833705357142856e-05 0.0 1.8834263392857143e-05 1.5 1.8844308035714284e-05 1.5 1.884486607142857e-05 0.0 1.8851562499999998e-05 0.0 1.8852120535714285e-05 1.5 1.8862165178571426e-05 1.5 1.8862723214285713e-05 0.0 1.886941964285714e-05 0.0 1.8869977678571427e-05 1.5 1.888002232142857e-05 1.5 1.8880580357142855e-05 0.0 1.8887276785714283e-05 0.0 1.888783482142857e-05 1.5 1.8897879464285714e-05 1.5 1.8898437499999998e-05 0.0 1.890513392857143e-05 0.0 1.8905691964285712e-05 1.5 1.8915736607142857e-05 1.5 1.891629464285714e-05 0.0 1.892299107142857e-05 0.0 1.8923549107142854e-05 1.5 1.893359375e-05 1.5 1.8934151785714286e-05 0.0 1.8940848214285713e-05 0.0 1.894140625e-05 1.5 1.895145089285714e-05 1.5 1.8952008928571428e-05 0.0 1.8958705357142856e-05 0.0 1.8959263392857142e-05 1.5 1.8969308035714284e-05 1.5 1.896986607142857e-05 0.0 1.8976562499999998e-05 0.0 1.8977120535714285e-05 1.5 1.8987165178571426e-05 1.5 1.8987723214285713e-05 0.0 1.899441964285714e-05 0.0 1.8994977678571427e-05 1.5 1.900502232142857e-05 1.5 1.9005580357142855e-05 0.0 1.9012276785714286e-05 0.0 1.901283482142857e-05 1.5 1.9022879464285714e-05 1.5 1.9023437499999997e-05 0.0 1.9030133928571428e-05 0.0 1.903069196428571e-05 1.5 1.9040736607142856e-05 1.5 1.9041294642857143e-05 0.0 1.904799107142857e-05 0.0 1.9048549107142857e-05 1.5 1.905859375e-05 1.5 1.9059151785714285e-05 0.0 1.9065848214285713e-05 0.0 1.906640625e-05 1.5 1.907645089285714e-05 1.5 1.9077008928571428e-05 0.0 1.9083705357142855e-05 0.0 1.9084263392857142e-05 1.5 1.9094308035714283e-05 1.5 1.909486607142857e-05 0.0 1.9101562499999998e-05 0.0 1.9102120535714284e-05 1.5 1.9112165178571426e-05 1.5 1.9112723214285712e-05 0.0 1.911941964285714e-05 0.0 1.9119977678571427e-05 1.5 1.913002232142857e-05 1.5 1.9130580357142855e-05 0.0 1.9137276785714286e-05 0.0 1.913783482142857e-05 1.5 1.9147879464285714e-05 1.5 1.9148437499999997e-05 0.0 1.9155133928571428e-05 0.0 1.915569196428571e-05 1.5 1.9165736607142856e-05 1.5 1.9166294642857143e-05 0.0 1.917299107142857e-05 0.0 1.9173549107142857e-05 1.5 1.918359375e-05 1.5 1.9184151785714285e-05 0.0 1.9190848214285713e-05 0.0 1.919140625e-05 1.5 1.920145089285714e-05 1.5 1.9202008928571427e-05 0.0 1.9208705357142855e-05 0.0 1.920926339285714e-05 1.5 1.9219308035714283e-05 1.5 1.921986607142857e-05 0.0 1.9226562499999997e-05 0.0 1.9227120535714284e-05 1.5 1.923716517857143e-05 1.5 1.9237723214285712e-05 0.0 1.9244419642857143e-05 0.0 1.9244977678571426e-05 1.5 1.925502232142857e-05 1.5 1.9255580357142854e-05 0.0 1.9262276785714285e-05 0.0 1.926283482142857e-05 1.5 1.9272879464285713e-05 1.5 1.92734375e-05 0.0 1.9280133928571428e-05 0.0 1.9280691964285714e-05 1.5 1.9290736607142856e-05 1.5 1.9291294642857142e-05 0.0 1.929799107142857e-05 0.0 1.9298549107142857e-05 1.5 1.9308593749999998e-05 1.5 1.9309151785714285e-05 0.0 1.9315848214285712e-05 0.0 1.931640625e-05 1.5 1.932645089285714e-05 1.5 1.9327008928571427e-05 0.0 1.9333705357142855e-05 0.0 1.933426339285714e-05 1.5 1.9344308035714286e-05 1.5 1.934486607142857e-05 0.0 1.93515625e-05 0.0 1.9352120535714284e-05 1.5 1.936216517857143e-05 1.5 1.936272321428571e-05 0.0 1.9369419642857143e-05 0.0 1.9369977678571426e-05 1.5 1.938002232142857e-05 1.5 1.9380580357142857e-05 0.0 1.9387276785714285e-05 0.0 1.938783482142857e-05 1.5 1.9397321428571426e-05 1.5 1.9397879464285713e-05 0.0 1.9405691964285714e-05 0.0 1.9406249999999997e-05 1.5 1.941517857142857e-05 1.5 1.9415736607142855e-05 0.0 1.9423549107142856e-05 0.0 1.9424107142857143e-05 1.5 1.9433035714285714e-05 1.5 1.9433593749999998e-05 0.0 1.944140625e-05 0.0 1.9441964285714285e-05 1.5 1.9450892857142857e-05 1.5 1.945145089285714e-05 0.0 1.945926339285714e-05 0.0 1.9459821428571428e-05 1.5 1.946875e-05 1.5 1.9469308035714286e-05 0.0 1.9477120535714283e-05 0.0 1.947767857142857e-05 1.5 1.948660714285714e-05 1.5 1.9487165178571428e-05 0.0 1.9494977678571426e-05 0.0 1.9495535714285712e-05 1.5 1.9504464285714284e-05 1.5 1.950502232142857e-05 0.0 1.951283482142857e-05 0.0 1.9513392857142855e-05 1.5 1.9522321428571426e-05 1.5 1.9522879464285713e-05 0.0 1.9530691964285714e-05 0.0 1.9531249999999997e-05 1.5 1.954017857142857e-05 1.5 1.9540736607142855e-05 0.0 1.9548549107142856e-05 0.0 1.9549107142857143e-05 1.5 1.9558035714285714e-05 1.5 1.9558593749999997e-05 0.0 1.9566406249999998e-05 0.0 1.9566964285714285e-05 1.5 1.9575892857142856e-05 1.5 1.9576450892857143e-05 0.0 1.958426339285714e-05 0.0 1.9584821428571427e-05 1.5 1.959375e-05 1.5 1.9594308035714285e-05 0.0 1.9602120535714283e-05 0.0 1.960267857142857e-05 1.5 1.961160714285714e-05 1.5 1.9612165178571428e-05 0.0 1.961997767857143e-05 0.0 1.9620535714285712e-05 1.5 1.9629464285714283e-05 1.5 1.963002232142857e-05 0.0 1.963783482142857e-05 0.0 1.9638392857142854e-05 1.5 1.9647321428571426e-05 1.5 1.9647879464285712e-05 0.0 1.9655691964285713e-05 0.0 1.965625e-05 1.5 1.966517857142857e-05 1.5 1.9665736607142855e-05 0.0 1.9673549107142856e-05 0.0 1.9674107142857142e-05 1.5 1.9683035714285714e-05 1.5 1.9683593749999997e-05 0.0 1.9691406249999998e-05 0.0 1.9691964285714285e-05 1.5 1.9700892857142856e-05 1.5 1.9701450892857143e-05 0.0 1.970926339285714e-05 0.0 1.9709821428571427e-05 1.5 1.9718749999999998e-05 1.5 1.9719308035714285e-05 0.0 1.9727120535714286e-05 0.0 1.972767857142857e-05 1.5 1.973660714285714e-05 1.5 1.9737165178571427e-05 0.0 1.9744977678571428e-05 0.0 1.974553571428571e-05 1.5 1.9754464285714283e-05 1.5 1.975502232142857e-05 0.0 1.976283482142857e-05 0.0 1.9763392857142857e-05 1.5 1.977232142857143e-05 1.5 1.9772879464285712e-05 0.0 1.9780691964285713e-05 0.0 1.978125e-05 1.5 1.979017857142857e-05 1.5 1.9790736607142854e-05 0.0 1.9798549107142855e-05 0.0 1.9799107142857142e-05 1.5 1.9808035714285713e-05 1.5 1.980859375e-05 0.0 1.9816406249999998e-05 0.0 1.9816964285714284e-05 1.5 1.9825892857142856e-05 1.5 1.9826450892857142e-05 0.0 1.983426339285714e-05 0.0 1.9834821428571427e-05 1.5 1.9843749999999998e-05 1.5 1.9844308035714285e-05 0.0 1.9852120535714286e-05 0.0 1.985267857142857e-05 1.5 1.986160714285714e-05 1.5 1.9862165178571427e-05 0.0 1.9869977678571428e-05 0.0 1.987053571428571e-05 1.5 1.9879464285714286e-05 1.5 1.988002232142857e-05 0.0 1.988783482142857e-05 0.0 1.9888392857142857e-05 1.5 1.9897321428571428e-05 1.5 1.989787946428571e-05 0.0 1.9905691964285713e-05 0.0 1.990625e-05 1.5 1.991517857142857e-05 1.5 1.9915736607142857e-05 0.0 1.9923549107142855e-05 0.0 1.992410714285714e-05 1.5 1.9933035714285713e-05 1.5 1.993359375e-05 0.0 1.9941406249999997e-05 0.0 1.9941964285714284e-05 1.5 1.9950892857142855e-05 1.5 1.9951450892857142e-05 0.0 1.9959263392857143e-05 0.0 1.9959821428571426e-05 1.5 1.9968749999999997e-05 1.5 1.9969308035714284e-05 0.0 1.9977120535714285e-05 0.0 1.997767857142857e-05 1.5 1.998660714285714e-05 1.5 1.9987165178571427e-05 0.0 1.9994977678571428e-05 0.0 1.9995535714285714e-05 1.5 2.0004464285714286e-05 1.5 2.000502232142857e-05 0.0 2.001283482142857e-05 0.0 2.0013392857142857e-05 1.5 2.0022321428571428e-05 1.5 2.002287946428571e-05 0.0 2.0030691964285712e-05 0.0 2.003125e-05 1.5 2.004017857142857e-05 1.5 2.0040736607142857e-05 0.0 2.0048549107142855e-05 0.0 2.004910714285714e-05 1.5 2.0058035714285712e-05 1.5 2.005859375e-05 0.0 2.0066964285714284e-05 0.0 2.006752232142857e-05 1.5 2.007533482142857e-05 1.5 2.0075892857142855e-05 0.0 2.0084821428571426e-05 0.0 2.0085379464285713e-05 1.5 2.0093191964285714e-05 1.5 2.0093749999999997e-05 0.0 2.0102678571428568e-05 0.0 2.0103236607142855e-05 1.5 2.0111049107142856e-05 1.5 2.0111607142857143e-05 0.0 2.0120535714285714e-05 0.0 2.0121093749999997e-05 1.5 2.012890625e-05 1.5 2.0129464285714285e-05 0.0 2.0138392857142856e-05 0.0 2.0138950892857143e-05 1.5 2.014676339285714e-05 1.5 2.0147321428571427e-05 0.0 2.015625e-05 0.0 2.0156808035714285e-05 1.5 2.0164620535714283e-05 1.5 2.016517857142857e-05 0.0 2.017410714285714e-05 0.0 2.0174665178571428e-05 1.5 2.018247767857143e-05 1.5 2.0183035714285712e-05 0.0 2.0191964285714283e-05 0.0 2.019252232142857e-05 1.5 2.020033482142857e-05 1.5 2.0200892857142854e-05 0.0 2.0209821428571426e-05 0.0 2.0210379464285712e-05 1.5 2.0218191964285713e-05 1.5 2.021875e-05 0.0 2.022767857142857e-05 0.0 2.0228236607142855e-05 1.5 2.0236049107142856e-05 1.5 2.0236607142857143e-05 0.0 2.0245535714285714e-05 0.0 2.0246093749999997e-05 1.5 2.0253906249999998e-05 1.5 2.0254464285714285e-05 0.0 2.0263392857142856e-05 0.0 2.0263950892857143e-05 1.5 2.027176339285714e-05 1.5 2.0272321428571427e-05 0.0 2.028125e-05 0.0 2.0281808035714285e-05 1.5 2.0289620535714283e-05 1.5 2.029017857142857e-05 0.0 2.029910714285714e-05 0.0 2.0299665178571427e-05 1.5 2.030747767857143e-05 1.5 2.0308035714285712e-05 0.0 2.0316964285714283e-05 0.0 2.031752232142857e-05 1.5 2.032533482142857e-05 1.5 2.0325892857142854e-05 0.0 2.033482142857143e-05 0.0 2.0335379464285712e-05 1.5 2.0343191964285713e-05 1.5 2.034375e-05 0.0 2.035267857142857e-05 0.0 2.0353236607142854e-05 1.5 2.0361049107142855e-05 1.5 2.0361607142857142e-05 0.0 2.0370535714285713e-05 0.0 2.037109375e-05 1.5 2.0378906249999998e-05 1.5 2.0379464285714284e-05 0.0 2.0388392857142856e-05 0.0 2.0388950892857142e-05 1.5 2.039676339285714e-05 1.5 2.0397321428571427e-05 0.0 2.0406249999999998e-05 0.0 2.0406808035714285e-05 1.5 2.0414620535714286e-05 1.5 2.041517857142857e-05 0.0 2.042410714285714e-05 0.0 2.0424665178571427e-05 1.5 2.0432477678571428e-05 1.5 2.043303571428571e-05 0.0 2.0441964285714283e-05 0.0 2.044252232142857e-05 1.5 2.045033482142857e-05 1.5 2.0450892857142857e-05 0.0 2.045982142857143e-05 0.0 2.046037946428571e-05 1.5 2.0468191964285713e-05 1.5 2.046875e-05 0.0 2.047767857142857e-05 0.0 2.0478236607142854e-05 1.5 2.0486049107142855e-05 1.5 2.0486607142857142e-05 0.0 2.0495535714285713e-05 0.0 2.049609375e-05 1.5 2.0503906249999997e-05 1.5 2.0504464285714284e-05 0.0 2.0513392857142855e-05 0.0 2.0513950892857142e-05 1.5 2.0521763392857143e-05 1.5 2.0522321428571426e-05 0.0 2.0531249999999998e-05 0.0 2.0531808035714284e-05 1.5 2.0539620535714285e-05 1.5 2.054017857142857e-05 0.0 2.054910714285714e-05 0.0 2.0549665178571427e-05 1.5 2.0557477678571428e-05 1.5 2.0558035714285714e-05 0.0 2.0566964285714286e-05 0.0 2.056752232142857e-05 1.5 2.057533482142857e-05 1.5 2.0575892857142857e-05 0.0 2.0584821428571428e-05 0.0 2.058537946428571e-05 1.5 2.0593191964285712e-05 1.5 2.059375e-05 0.0 2.060267857142857e-05 0.0 2.0603236607142857e-05 1.5 2.0611049107142855e-05 1.5 2.061160714285714e-05 0.0 2.0620535714285713e-05 0.0 2.062109375e-05 1.5 2.0628906249999997e-05 1.5 2.0629464285714284e-05 0.0 2.0638392857142855e-05 0.0 2.063895089285714e-05 1.5 2.0646763392857143e-05 1.5 2.0647321428571426e-05 0.0 2.0656249999999997e-05 0.0 2.0656808035714284e-05 1.5 2.0664620535714285e-05 1.5 2.066517857142857e-05 0.0 2.0674107142857143e-05 0.0 2.0674665178571426e-05 1.5 2.0682477678571427e-05 1.5 2.0683035714285714e-05 0.0 2.0691964285714285e-05 0.0 2.069252232142857e-05 1.5 2.070033482142857e-05 1.5 2.0700892857142856e-05 0.0 2.0709821428571428e-05 0.0 2.0710379464285714e-05 1.5 2.0718191964285712e-05 1.5 2.071875e-05 0.0 2.072767857142857e-05 0.0 2.0728236607142857e-05 1.5 2.073549107142857e-05 1.5 2.0736049107142854e-05 0.0 2.074609375e-05 0.0 2.0746651785714286e-05 1.5 2.0753348214285713e-05 1.5 2.075390625e-05 0.0 2.076395089285714e-05 0.0 2.0764508928571428e-05 1.5 2.0771205357142856e-05 1.5 2.0771763392857142e-05 0.0 2.0781808035714284e-05 0.0 2.078236607142857e-05 1.5 2.0789062499999998e-05 1.5 2.0789620535714285e-05 0.0 2.0799665178571426e-05 0.0 2.0800223214285713e-05 1.5 2.080691964285714e-05 1.5 2.0807477678571427e-05 0.0 2.081752232142857e-05 0.0 2.0818080357142855e-05 1.5 2.0824776785714283e-05 1.5 2.082533482142857e-05 0.0 2.0835379464285714e-05 0.0 2.0835937499999997e-05 1.5 2.0842633928571428e-05 1.5 2.084319196428571e-05 0.0 2.0853236607142856e-05 0.0 2.085379464285714e-05 1.5 2.086049107142857e-05 1.5 2.0861049107142854e-05 0.0 2.087109375e-05 0.0 2.0871651785714285e-05 1.5 2.0878348214285713e-05 1.5 2.087890625e-05 0.0 2.088895089285714e-05 0.0 2.0889508928571428e-05 1.5 2.0896205357142855e-05 1.5 2.0896763392857142e-05 0.0 2.0906808035714283e-05 0.0 2.090736607142857e-05 1.5 2.0914062499999998e-05 1.5 2.0914620535714284e-05 0.0 2.0924665178571426e-05 0.0 2.0925223214285712e-05 1.5 2.093191964285714e-05 1.5 2.0932477678571427e-05 0.0 2.094252232142857e-05 0.0 2.0943080357142855e-05 1.5 2.0949776785714286e-05 1.5 2.095033482142857e-05 0.0 2.0960379464285714e-05 0.0 2.0960937499999997e-05 1.5 2.0967633928571428e-05 1.5 2.096819196428571e-05 0.0 2.0978236607142856e-05 0.0 2.0978794642857143e-05 1.5 2.098549107142857e-05 1.5 2.0986049107142857e-05 0.0 2.099609375e-05 0.0 2.0996651785714285e-05 1.5 2.1003348214285713e-05 1.5 2.100390625e-05 0.0 2.101395089285714e-05 0.0 2.1014508928571427e-05 1.5 2.1021205357142855e-05 1.5 2.102176339285714e-05 0.0 2.1031808035714283e-05 0.0 2.103236607142857e-05 1.5 2.1039062499999997e-05 1.5 2.1039620535714284e-05 0.0 2.104966517857143e-05 0.0 2.1050223214285712e-05 1.5 2.1056919642857143e-05 1.5 2.1057477678571426e-05 0.0 2.106752232142857e-05 0.0 2.1068080357142854e-05 1.5 2.1074776785714285e-05 1.5 2.107533482142857e-05 0.0 2.1085379464285713e-05 0.0 2.10859375e-05 1.5 2.1092633928571428e-05 1.5 2.1093191964285714e-05 0.0 2.1103236607142856e-05 0.0 2.1103794642857142e-05 1.5 2.111049107142857e-05 1.5 2.1111049107142857e-05 0.0 2.1121093749999998e-05 0.0 2.1121651785714285e-05 1.5 2.1128348214285712e-05 1.5 2.112890625e-05 0.0 2.113895089285714e-05 0.0 2.1139508928571427e-05 1.5 2.1146205357142855e-05 1.5 2.114676339285714e-05 0.0 2.1156808035714283e-05 0.0 2.115736607142857e-05 1.5 2.1164062499999997e-05 1.5 2.1164620535714284e-05 0.0 2.117466517857143e-05 0.0 2.1175223214285712e-05 1.5 2.1181919642857143e-05 1.5 2.1182477678571426e-05 0.0 2.119252232142857e-05 0.0 2.1193080357142854e-05 1.5 2.1199776785714285e-05 1.5 2.1200334821428568e-05 0.0 2.1210379464285713e-05 0.0 2.12109375e-05 1.5 2.1217633928571427e-05 1.5 2.1218191964285714e-05 0.0 2.1228236607142855e-05 0.0 2.1228794642857142e-05 1.5 2.123549107142857e-05 1.5 2.1236049107142856e-05 0.0 2.1246093749999998e-05 0.0 2.1246651785714284e-05 1.5 2.1253348214285712e-05 1.5 2.125390625e-05 0.0 2.126395089285714e-05 0.0 2.1264508928571427e-05 1.5 2.1271205357142854e-05 1.5 2.127176339285714e-05 0.0 2.1281808035714286e-05 0.0 2.128236607142857e-05 1.5 2.12890625e-05 1.5 2.1289620535714283e-05 0.0 2.1299665178571428e-05 0.0 2.130022321428571e-05 1.5 2.1306919642857142e-05 1.5 2.1307477678571426e-05 0.0 2.131752232142857e-05 0.0 2.1318080357142857e-05 1.5 2.1324776785714285e-05 1.5 2.132533482142857e-05 0.0 2.1335379464285713e-05 0.0 2.13359375e-05 1.5 2.1342633928571427e-05 1.5 2.1343191964285714e-05 0.0 2.1353236607142855e-05 0.0 2.1353794642857142e-05 1.5 2.136049107142857e-05 1.5 2.1361049107142856e-05 0.0 2.1371093749999997e-05 0.0 2.1371651785714284e-05 1.5 2.137834821428571e-05 1.5 2.137890625e-05 0.0 2.1388950892857143e-05 0.0 2.1389508928571426e-05 1.5 2.1396205357142857e-05 1.5 2.139676339285714e-05 0.0 2.1406808035714285e-05 0.0 2.140736607142857e-05 1.5 2.14140625e-05 1.5 2.1414620535714283e-05 0.0 2.1424665178571428e-05 0.0 2.1425223214285714e-05 1.5 2.1431919642857142e-05 1.5 2.143247767857143e-05 0.0 2.144252232142857e-05 0.0 2.1443080357142857e-05 1.5 2.1449776785714284e-05 1.5 2.145033482142857e-05 0.0 2.1460379464285712e-05 0.0 2.14609375e-05 1.5 2.1467633928571427e-05 1.5 2.1468191964285713e-05 0.0 2.1478236607142855e-05 0.0 2.147879464285714e-05 1.5 2.148549107142857e-05 1.5 2.1486049107142856e-05 0.0 2.1496093749999997e-05 0.0 2.1496651785714284e-05 1.5 2.150334821428571e-05 1.5 2.1503906249999998e-05 0.0 2.1513950892857143e-05 0.0 2.1514508928571426e-05 1.5 2.1521205357142857e-05 1.5 2.152176339285714e-05 0.0 2.1531808035714285e-05 0.0 2.153236607142857e-05 1.5 2.15390625e-05 1.5 2.1539620535714283e-05 0.0 2.1549665178571427e-05 0.0 2.1550223214285714e-05 1.5 2.155691964285714e-05 1.5 2.155747767857143e-05 0.0 2.156752232142857e-05 0.0 2.1568080357142856e-05 1.5 2.1574776785714284e-05 1.5 2.157533482142857e-05 0.0 2.1585379464285712e-05 0.0 2.15859375e-05 1.5 2.1592633928571426e-05 1.5 2.1593191964285713e-05 0.0 2.1603236607142854e-05 0.0 2.160379464285714e-05 1.5 2.161049107142857e-05 1.5 2.1611049107142855e-05 0.0 2.162109375e-05 0.0 2.1621651785714283e-05 1.5 2.1628348214285714e-05 1.5 2.1628906249999998e-05 0.0 2.1638950892857142e-05 0.0 2.1639508928571426e-05 1.5 2.1646205357142857e-05 1.5 2.164676339285714e-05 0.0 2.1656808035714285e-05 0.0 2.165736607142857e-05 1.5 2.16640625e-05 1.5 2.1664620535714286e-05 0.0 2.1674665178571427e-05 0.0 2.1675223214285714e-05 1.5 2.168191964285714e-05 1.5 2.1682477678571428e-05 0.0 2.169252232142857e-05 0.0 2.1693080357142856e-05 1.5 2.1699776785714284e-05 1.5 2.170033482142857e-05 0.0 2.171037946428571e-05 0.0 2.17109375e-05 1.5 2.1717633928571426e-05 1.5 2.1718191964285713e-05 0.0 2.1728236607142854e-05 0.0 2.172879464285714e-05 1.5 2.1735491071428568e-05 1.5 2.1736049107142855e-05 0.0 2.174609375e-05 0.0 2.1746651785714283e-05 1.5 2.1753348214285714e-05 1.5 2.1753906249999997e-05 0.0 2.1763950892857142e-05 0.0 2.176450892857143e-05 1.5 2.1771205357142856e-05 1.5 2.1771763392857143e-05 0.0 2.1781808035714284e-05 0.0 2.178236607142857e-05 1.5 2.17890625e-05 1.5 2.1789620535714285e-05 0.0 2.1799665178571427e-05 0.0 2.1800223214285713e-05 1.5 2.180691964285714e-05 1.5 2.1807477678571428e-05 0.0 2.181752232142857e-05 0.0 2.1818080357142856e-05 1.5 2.1824776785714283e-05 1.5 2.182533482142857e-05 0.0 2.183537946428571e-05 0.0 2.1835937499999998e-05 1.5 2.1842633928571426e-05 1.5 2.1843191964285712e-05 0.0 2.1853236607142857e-05 0.0 2.185379464285714e-05 1.5 2.186049107142857e-05 1.5 2.1861049107142855e-05 0.0 2.187109375e-05 0.0 2.1871651785714283e-05 1.5 2.1878348214285714e-05 1.5 2.1878906249999997e-05 0.0 2.188895089285714e-05 0.0 2.188950892857143e-05 1.5 2.1896205357142856e-05 1.5 2.1896763392857143e-05 0.0 2.1906808035714284e-05 0.0 2.190736607142857e-05 1.5 2.1914062499999998e-05 1.5 2.1914620535714285e-05 0.0 2.1924665178571426e-05 0.0 2.1925223214285713e-05 1.5 2.193191964285714e-05 1.5 2.1932477678571427e-05 0.0 2.194252232142857e-05 0.0 2.1943080357142855e-05 1.5 2.1949776785714283e-05 1.5 2.195033482142857e-05 0.0 2.1960379464285714e-05 0.0 2.1960937499999998e-05 1.5 2.196763392857143e-05 1.5 2.1968191964285712e-05 0.0 2.1978236607142857e-05 0.0 2.197879464285714e-05 1.5 2.198549107142857e-05 1.5 2.1986049107142854e-05 0.0 2.199609375e-05 0.0 2.1996651785714286e-05 1.5 2.2003348214285713e-05 1.5 2.200390625e-05 0.0 2.201395089285714e-05 0.0 2.2014508928571428e-05 1.5 2.2021205357142856e-05 1.5 2.2021763392857142e-05 0.0 2.2031808035714284e-05 0.0 2.203236607142857e-05 1.5 2.2039062499999998e-05 1.5 2.2039620535714285e-05 0.0 2.2049665178571426e-05 0.0 2.2050223214285713e-05 1.5 2.205691964285714e-05 1.5 2.2057477678571427e-05 0.0 2.2067522321428568e-05 0.0 2.2068080357142855e-05 1.5 2.2074776785714282e-05 1.5 2.207533482142857e-05 0.0 2.2085379464285714e-05 0.0 2.2085937499999997e-05 1.5 2.2092633928571428e-05 1.5 2.209319196428571e-05 0.0 2.2103236607142856e-05 0.0 2.210379464285714e-05 1.5 2.211049107142857e-05 1.5 2.2111049107142854e-05 0.0 2.212109375e-05 0.0 2.2121651785714285e-05 1.5 2.2128348214285713e-05 1.5 2.212890625e-05 0.0 2.213895089285714e-05 0.0 2.2139508928571428e-05 1.5 2.2146205357142855e-05 1.5 2.2146763392857142e-05 0.0 2.2156808035714283e-05 0.0 2.215736607142857e-05 1.5 2.2164062499999997e-05 1.5 2.2164620535714284e-05 0.0 2.2174665178571426e-05 0.0 2.2175223214285712e-05 1.5 2.218191964285714e-05 1.5 2.2182477678571427e-05 0.0 2.219252232142857e-05 0.0 2.2193080357142855e-05 1.5 2.2199776785714286e-05 1.5 2.220033482142857e-05 0.0 2.2210379464285714e-05 0.0 2.2210937499999997e-05 1.5 2.2217633928571428e-05 1.5 2.221819196428571e-05 0.0 2.2228236607142856e-05 0.0 2.2228794642857143e-05 1.5 2.223549107142857e-05 1.5 2.2236049107142857e-05 0.0 2.2246093749999998e-05 0.0 2.2246651785714285e-05 1.5 2.2253348214285712e-05 1.5 2.225390625e-05 0.0 2.226395089285714e-05 0.0 2.2264508928571427e-05 1.5 2.2271205357142855e-05 1.5 2.227176339285714e-05 0.0 2.2281808035714283e-05 0.0 2.228236607142857e-05 1.5 2.2289062499999997e-05 1.5 2.2289620535714284e-05 0.0 2.229966517857143e-05 0.0 2.2300223214285712e-05 1.5 2.2306919642857143e-05 1.5 2.2307477678571426e-05 0.0 2.231752232142857e-05 0.0 2.2318080357142854e-05 1.5 2.2324776785714285e-05 1.5 2.232533482142857e-05 0.0 2.2335379464285713e-05 0.0 2.23359375e-05 1.5 2.2342633928571427e-05 1.5 2.2343191964285714e-05 0.0 2.2353236607142856e-05 0.0 2.2353794642857142e-05 1.5 2.236049107142857e-05 1.5 2.2361049107142857e-05 0.0 2.2371093749999998e-05 0.0 2.2371651785714285e-05 1.5 2.2378348214285712e-05 1.5 2.237890625e-05 0.0 2.238895089285714e-05 0.0 2.2389508928571427e-05 1.5 2.2396205357142854e-05 1.5 2.239676339285714e-05 0.0 2.2406808035714283e-05 0.0 2.240736607142857e-05 1.5 2.2414062499999997e-05 1.5 2.2414620535714284e-05 0.0 2.2424665178571428e-05 0.0 2.242522321428571e-05 1.5 2.2431919642857142e-05 1.5 2.2432477678571426e-05 0.0 2.244252232142857e-05 0.0 2.2443080357142854e-05 1.5 2.2449776785714285e-05 1.5 2.2450334821428568e-05 0.0 2.2460379464285713e-05 0.0 2.24609375e-05 1.5 2.2467633928571427e-05 1.5 2.2468191964285714e-05 0.0 2.2478236607142855e-05 0.0 2.2478794642857142e-05 1.5 2.248549107142857e-05 1.5 2.2486049107142856e-05 0.0 2.2496093749999998e-05 0.0 2.2496651785714284e-05 1.5 2.2503348214285712e-05 1.5 2.250390625e-05 0.0 2.251395089285714e-05 0.0 2.2514508928571427e-05 1.5 2.2521205357142854e-05 1.5 2.252176339285714e-05 0.0 2.2531808035714286e-05 0.0 2.253236607142857e-05 1.5 2.25390625e-05 1.5 2.2539620535714283e-05 0.0 2.2549665178571428e-05 0.0 2.255022321428571e-05 1.5 2.2556919642857142e-05 1.5 2.2557477678571426e-05 0.0 2.256752232142857e-05 0.0 2.2568080357142857e-05 1.5 2.2574776785714284e-05 1.5 2.257533482142857e-05 0.0 2.2585379464285713e-05 0.0 2.25859375e-05 1.5 2.2592633928571427e-05 1.5 2.2593191964285714e-05 0.0 2.2603236607142855e-05 0.0 2.260379464285714e-05 1.5 2.261049107142857e-05 1.5 2.2611049107142856e-05 0.0 2.2621093749999997e-05 0.0 2.2621651785714284e-05 1.5 2.262834821428571e-05 1.5 2.2628906249999998e-05 0.0 2.2638950892857143e-05 0.0 2.2639508928571426e-05 1.5 2.2646205357142857e-05 1.5 2.264676339285714e-05 0.0 2.2656808035714285e-05 0.0 2.265736607142857e-05 1.5 2.26640625e-05 1.5 2.2664620535714283e-05 0.0 2.2674665178571428e-05 0.0 2.2675223214285714e-05 1.5 2.2681919642857142e-05 1.5 2.268247767857143e-05 0.0 2.269252232142857e-05 0.0 2.2693080357142857e-05 1.5 2.2699776785714284e-05 1.5 2.270033482142857e-05 0.0 2.2710379464285712e-05 0.0 2.27109375e-05 1.5 2.2717633928571426e-05 1.5 2.2718191964285713e-05 0.0 2.2728236607142854e-05 0.0 2.272879464285714e-05 1.5 2.273549107142857e-05 1.5 2.2736049107142856e-05 0.0 2.2746093749999997e-05 0.0 2.2746651785714284e-05 1.5 2.275334821428571e-05 1.5 2.2753906249999998e-05 0.0 2.2763950892857143e-05 0.0 2.2764508928571426e-05 1.5 2.2771205357142857e-05 1.5 2.277176339285714e-05 0.0 2.2781808035714285e-05 0.0 2.2782366071428568e-05 1.5 2.27890625e-05 1.5 2.2789620535714282e-05 0.0 2.2799665178571427e-05 0.0 2.2800223214285714e-05 1.5 2.280691964285714e-05 1.5 2.2807477678571428e-05 0.0 2.281752232142857e-05 0.0 2.2818080357142856e-05 1.5 2.2824776785714284e-05 1.5 2.282533482142857e-05 0.0 2.2835379464285712e-05 0.0 2.28359375e-05 1.5 2.2842633928571426e-05 1.5 2.2843191964285713e-05 0.0 2.2853236607142854e-05 0.0 2.285379464285714e-05 1.5 2.286049107142857e-05 1.5 2.2861049107142855e-05 0.0 2.287109375e-05 0.0 2.2871651785714283e-05 1.5 2.2878348214285714e-05 1.5 2.2878906249999997e-05 0.0 2.2888950892857142e-05 0.0 2.2889508928571426e-05 1.5 2.2896205357142856e-05 1.5 2.289676339285714e-05 0.0 2.2906808035714284e-05 0.0 2.290736607142857e-05 1.5 2.29140625e-05 1.5 2.2914620535714286e-05 0.0 2.2924665178571427e-05 0.0 2.2925223214285714e-05 1.5 2.293191964285714e-05 1.5 2.2932477678571428e-05 0.0 2.294252232142857e-05 0.0 2.2943080357142856e-05 1.5 2.2949776785714283e-05 1.5 2.295033482142857e-05 0.0 2.296037946428571e-05 0.0 2.2960937499999998e-05 1.5 2.2967633928571426e-05 1.5 2.2968191964285713e-05 0.0 2.2978236607142857e-05 0.0 2.297879464285714e-05 1.5 2.298549107142857e-05 1.5 2.2986049107142855e-05 0.0 2.299609375e-05 0.0 2.2996651785714283e-05 1.5 2.3003348214285714e-05 1.5 2.3003906249999997e-05 0.0 2.3013950892857142e-05 0.0 2.301450892857143e-05 1.5 2.3021205357142856e-05 1.5 2.3021763392857143e-05 0.0 2.3031808035714284e-05 0.0 2.303236607142857e-05 1.5 2.30390625e-05 1.5 2.3039620535714285e-05 0.0 2.3049665178571426e-05 0.0 2.3050223214285713e-05 1.5 2.305691964285714e-05 1.5 2.3057477678571428e-05 0.0 2.306752232142857e-05 0.0 2.3068080357142856e-05 1.5 2.3074776785714283e-05 1.5 2.307533482142857e-05 0.0 2.308537946428571e-05 0.0 2.3085937499999998e-05 1.5 2.3092633928571425e-05 1.5 2.3093191964285712e-05 0.0 2.3103236607142857e-05 0.0 2.310379464285714e-05 1.5 2.311049107142857e-05 1.5 2.3111049107142854e-05 0.0 2.312109375e-05 0.0 2.3121651785714283e-05 1.5 2.3128348214285713e-05 1.5 2.3128906249999997e-05 0.0 2.313895089285714e-05 0.0 2.3139508928571428e-05 1.5 2.3146205357142856e-05 1.5 2.3146763392857143e-05 0.0 2.3156808035714284e-05 0.0 2.315736607142857e-05 1.5 2.3164062499999998e-05 1.5 2.3164620535714285e-05 0.0 2.3174665178571426e-05 0.0 2.3175223214285713e-05 1.5 2.318191964285714e-05 1.5 2.3182477678571427e-05 0.0 2.319252232142857e-05 0.0 2.3193080357142855e-05 1.5 2.3199776785714283e-05 1.5 2.320033482142857e-05 0.0 2.3210379464285714e-05 0.0 2.3210937499999998e-05 1.5 2.321763392857143e-05 1.5 2.3218191964285712e-05 0.0 2.3228236607142856e-05 0.0 2.322879464285714e-05 1.5 2.323549107142857e-05 1.5 2.3236049107142854e-05 0.0 2.324609375e-05 0.0 2.3246651785714286e-05 1.5 2.3253348214285713e-05 1.5 2.325390625e-05 0.0 2.326395089285714e-05 0.0 2.3264508928571428e-05 1.5 2.3271205357142855e-05 1.5 2.3271763392857142e-05 0.0 2.3281808035714283e-05 0.0 2.328236607142857e-05 1.5 2.3289062499999998e-05 1.5 2.3289620535714284e-05 0.0 2.3299665178571426e-05 0.0 2.3300223214285713e-05 1.5 2.330691964285714e-05 1.5 2.3307477678571427e-05 0.0 2.3317522321428568e-05 0.0 2.3318080357142855e-05 1.5 2.3324776785714282e-05 1.5 2.332533482142857e-05 0.0 2.3335379464285714e-05 0.0 2.3335937499999997e-05 1.5 2.3342633928571428e-05 1.5 2.334319196428571e-05 0.0 2.3353236607142856e-05 0.0 2.335379464285714e-05 1.5 2.336049107142857e-05 1.5 2.3361049107142854e-05 0.0 2.337109375e-05 0.0 2.3371651785714285e-05 1.5 2.3378348214285713e-05 1.5 2.337890625e-05 0.0 2.338895089285714e-05 0.0 2.3389508928571428e-05 1.5 2.3396205357142855e-05 1.5 2.3396763392857142e-05 0.0 2.3406808035714283e-05 0.0 2.340736607142857e-05 1.5 2.3414620535714284e-05 1.5 2.341517857142857e-05 0.0 2.3424107142857142e-05 0.0 2.3424665178571425e-05 1.5 2.3432477678571426e-05 1.5 2.3433035714285713e-05 0.0 2.3441964285714284e-05 0.0 2.344252232142857e-05 1.5 2.345033482142857e-05 1.5 2.3450892857142856e-05 0.0 2.3459821428571427e-05 0.0 2.3460379464285713e-05 1.5 2.346819196428571e-05 1.5 2.3468749999999998e-05 0.0 2.347767857142857e-05 0.0 2.3478236607142856e-05 1.5 2.3486049107142857e-05 1.5 2.348660714285714e-05 0.0 2.349553571428571e-05 0.0 2.3496093749999998e-05 1.5 2.350390625e-05 1.5 2.3504464285714283e-05 0.0 2.3513392857142857e-05 0.0 2.351395089285714e-05 1.5 2.352176339285714e-05 1.5 2.3522321428571428e-05 0.0 2.353125e-05 0.0 2.3531808035714283e-05 1.5 2.3539620535714284e-05 1.5 2.354017857142857e-05 0.0 2.3549107142857142e-05 0.0 2.354966517857143e-05 1.5 2.3557477678571426e-05 1.5 2.3558035714285713e-05 0.0 2.3566964285714284e-05 0.0 2.356752232142857e-05 1.5 2.357533482142857e-05 1.5 2.3575892857142855e-05 0.0 2.3584821428571426e-05 0.0 2.3585379464285713e-05 1.5 2.3593191964285714e-05 1.5 2.3593749999999998e-05 0.0 2.360267857142857e-05 0.0 2.3603236607142855e-05 1.5 2.3611049107142856e-05 1.5 2.361160714285714e-05 0.0 2.362053571428571e-05 0.0 2.3621093749999998e-05 1.5 2.362890625e-05 1.5 2.3629464285714286e-05 0.0 2.3638392857142857e-05 0.0 2.363895089285714e-05 1.5 2.364676339285714e-05 1.5 2.3647321428571428e-05 0.0 2.365625e-05 0.0 2.3656808035714282e-05 1.5 2.3664620535714283e-05 1.5 2.366517857142857e-05 0.0 2.367410714285714e-05 0.0 2.3674665178571428e-05 1.5 2.3682477678571426e-05 1.5 2.3683035714285713e-05 0.0 2.3691964285714284e-05 0.0 2.369252232142857e-05 1.5 2.3700334821428568e-05 1.5 2.3700892857142855e-05 0.0 2.3709821428571426e-05 0.0 2.3710379464285713e-05 1.5 2.3718191964285714e-05 1.5 2.3718749999999997e-05 0.0 2.372767857142857e-05 0.0 2.3728236607142855e-05 1.5 2.3736049107142856e-05 1.5 2.373660714285714e-05 0.0 2.3745535714285714e-05 0.0 2.3746093749999997e-05 1.5 2.375390625e-05 1.5 2.3754464285714285e-05 0.0 2.3763392857142856e-05 0.0 2.376395089285714e-05 1.5 2.377176339285714e-05 1.5 2.3772321428571428e-05 0.0 2.378125e-05 0.0 2.3781808035714285e-05 1.5 2.3789620535714283e-05 1.5 2.379017857142857e-05 0.0 2.379910714285714e-05 0.0 2.3799665178571428e-05 1.5 2.3807477678571425e-05 1.5 2.3808035714285712e-05 0.0 2.3816964285714283e-05 0.0 2.381752232142857e-05 1.5 2.382533482142857e-05 1.5 2.3825892857142854e-05 0.0 2.3834821428571426e-05 0.0 2.3835379464285712e-05 1.5 2.3843191964285713e-05 1.5 2.3843749999999997e-05 0.0 2.385267857142857e-05 0.0 2.3853236607142855e-05 1.5 2.3861049107142856e-05 1.5 2.3861607142857143e-05 0.0 2.3870535714285714e-05 0.0 2.3871093749999997e-05 1.5 2.3878906249999998e-05 1.5 2.3879464285714285e-05 0.0 2.3888392857142856e-05 0.0 2.3888950892857143e-05 1.5 2.389676339285714e-05 1.5 2.3897321428571427e-05 0.0 2.390625e-05 0.0 2.3906808035714285e-05 1.5 2.3914620535714283e-05 1.5 2.391517857142857e-05 0.0 2.392410714285714e-05 0.0 2.3924665178571427e-05 1.5 2.393247767857143e-05 1.5 2.3933035714285712e-05 0.0 2.3941964285714283e-05 0.0 2.394252232142857e-05 1.5 2.395033482142857e-05 1.5 2.3950892857142854e-05 0.0 2.3959821428571425e-05 0.0 2.3960379464285712e-05 1.5 2.3968191964285713e-05 1.5 2.396875e-05 0.0 2.397767857142857e-05 0.0 2.3978236607142854e-05 1.5 2.3986049107142855e-05 1.5 2.3986607142857142e-05 0.0 2.3995535714285713e-05 0.0 2.3996093749999997e-05 1.5 2.4003906249999998e-05 1.5 2.4004464285714284e-05 0.0 2.4013392857142856e-05 0.0 2.4013950892857142e-05 1.5 2.402176339285714e-05 1.5 2.4022321428571427e-05 0.0 2.4031249999999998e-05 0.0 2.4031808035714285e-05 1.5 2.4039620535714282e-05 1.5 2.404017857142857e-05 0.0 2.404910714285714e-05 0.0 2.4049665178571427e-05 1.5 2.4057477678571428e-05 1.5 2.405803571428571e-05 0.0 2.4066964285714283e-05 0.0 2.406752232142857e-05 1.5 2.407533482142857e-05 1.5 2.4075892857142854e-05 0.0 2.408426339285714e-05 0.0 2.408482142857143e-05 1.5 2.409375e-05 1.5 2.4094308035714283e-05 0.0 2.4102120535714284e-05 0.0 2.410267857142857e-05 1.5 2.4111607142857142e-05 1.5 2.4112165178571425e-05 0.0 2.4119977678571426e-05 0.0 2.4120535714285713e-05 1.5 2.4129464285714284e-05 1.5 2.413002232142857e-05 0.0 2.413783482142857e-05 0.0 2.4138392857142855e-05 1.5 2.4147321428571426e-05 1.5 2.4147879464285713e-05 0.0 2.415569196428571e-05 0.0 2.4156249999999998e-05 1.5 2.416517857142857e-05 1.5 2.4165736607142856e-05 0.0 2.4173549107142857e-05 0.0 2.417410714285714e-05 1.5 2.418303571428571e-05 1.5 2.4183593749999998e-05 0.0 2.419140625e-05 0.0 2.4191964285714286e-05 1.5 2.4200892857142857e-05 1.5 2.420145089285714e-05 0.0 2.420926339285714e-05 0.0 2.4209821428571428e-05 1.5 2.421875e-05 1.5 2.4219308035714283e-05 0.0 2.4227120535714284e-05 0.0 2.422767857142857e-05 1.5 2.423660714285714e-05 1.5 2.4237165178571428e-05 0.0 2.4244977678571426e-05 0.0 2.4245535714285713e-05 1.5 2.4254464285714284e-05 1.5 2.425502232142857e-05 0.0 2.4262834821428568e-05 0.0 2.4263392857142855e-05 1.5 2.4272321428571426e-05 1.5 2.4272879464285713e-05 0.0 2.4280691964285714e-05 0.0 2.4281249999999997e-05 1.5 2.429017857142857e-05 1.5 2.4290736607142855e-05 0.0 2.4298549107142856e-05 0.0 2.429910714285714e-05 1.5 2.4308035714285714e-05 1.5 2.4308593749999998e-05 0.0 2.431640625e-05 0.0 2.4316964285714285e-05 1.5 2.4325892857142856e-05 1.5 2.432645089285714e-05 0.0 2.433426339285714e-05 0.0 2.4334821428571428e-05 1.5 2.434375e-05 1.5 2.4344308035714286e-05 0.0 2.4352120535714283e-05 0.0 2.435267857142857e-05 1.5 2.436160714285714e-05 1.5 2.4362165178571428e-05 0.0 2.4369977678571426e-05 0.0 2.4370535714285712e-05 1.5 2.4379464285714283e-05 1.5 2.438002232142857e-05 0.0 2.438783482142857e-05 0.0 2.4388392857142855e-05 1.5 2.4397321428571426e-05 1.5 2.4397879464285713e-05 0.0 2.4405691964285714e-05 0.0 2.4406249999999997e-05 1.5 2.4415178571428568e-05 1.5 2.4415736607142855e-05 0.0 2.4423549107142856e-05 0.0 2.4424107142857143e-05 1.5 2.4433035714285714e-05 1.5 2.4433593749999997e-05 0.0 2.4441406249999998e-05 0.0 2.4441964285714285e-05 1.5 2.4450892857142856e-05 1.5 2.445145089285714e-05 0.0 2.445926339285714e-05 0.0 2.4459821428571427e-05 1.5 2.446875e-05 1.5 2.4469308035714285e-05 0.0 2.4477120535714283e-05 0.0 2.447767857142857e-05 1.5 2.448660714285714e-05 1.5 2.4487165178571428e-05 0.0 2.4494977678571425e-05 0.0 2.4495535714285712e-05 1.5 2.4504464285714283e-05 1.5 2.450502232142857e-05 0.0 2.451283482142857e-05 0.0 2.4513392857142854e-05 1.5 2.4522321428571425e-05 1.5 2.4522879464285712e-05 0.0 2.4530691964285713e-05 0.0 2.4531249999999997e-05 1.5 2.454017857142857e-05 1.5 2.4540736607142854e-05 0.0 2.4548549107142856e-05 0.0 2.4549107142857142e-05 1.5 2.4558035714285713e-05 1.5 2.4558593749999997e-05 0.0 2.4566406249999998e-05 0.0 2.4566964285714285e-05 1.5 2.4575892857142856e-05 1.5 2.4576450892857143e-05 0.0 2.458426339285714e-05 0.0 2.4584821428571427e-05 1.5 2.4593749999999998e-05 1.5 2.4594308035714285e-05 0.0 2.4602120535714283e-05 0.0 2.460267857142857e-05 1.5 2.461160714285714e-05 1.5 2.4612165178571427e-05 0.0 2.4619977678571428e-05 0.0 2.462053571428571e-05 1.5 2.4629464285714283e-05 1.5 2.463002232142857e-05 0.0 2.463783482142857e-05 0.0 2.4638392857142854e-05 1.5 2.464732142857143e-05 1.5 2.4647879464285712e-05 0.0 2.4655691964285713e-05 0.0 2.465625e-05 1.5 2.466517857142857e-05 1.5 2.4665736607142854e-05 0.0 2.4673549107142855e-05 0.0 2.4674107142857142e-05 1.5 2.4683035714285713e-05 1.5 2.468359375e-05 0.0 2.4691406249999998e-05 0.0 2.4691964285714284e-05 1.5 2.4700892857142855e-05 1.5 2.4701450892857142e-05 0.0 2.470926339285714e-05 0.0 2.4709821428571427e-05 1.5 2.4718749999999998e-05 1.5 2.4719308035714285e-05 0.0 2.4727120535714286e-05 0.0 2.472767857142857e-05 1.5 2.473660714285714e-05 1.5 2.4737165178571427e-05 0.0 2.4744977678571428e-05 0.0 2.474553571428571e-05 1.5 2.475502232142857e-05 1.5 2.4755580357142856e-05 0.0 2.4762276785714283e-05 0.0 2.476283482142857e-05 1.5 2.477287946428571e-05 1.5 2.4773437499999998e-05 0.0 2.4780133928571426e-05 0.0 2.4780691964285713e-05 1.5 2.4790736607142854e-05 1.5 2.479129464285714e-05 0.0 2.4797991071428568e-05 0.0 2.4798549107142855e-05 1.5 2.480859375e-05 1.5 2.4809151785714283e-05 0.0 2.4815848214285714e-05 0.0 2.4816406249999997e-05 1.5 2.4826450892857142e-05 1.5 2.4827008928571425e-05 0.0 2.4833705357142856e-05 0.0 2.483426339285714e-05 1.5 2.4844308035714284e-05 1.5 2.484486607142857e-05 0.0 2.48515625e-05 0.0 2.4852120535714285e-05 1.5 2.4862165178571426e-05 1.5 2.4862723214285713e-05 0.0 2.486941964285714e-05 0.0 2.4869977678571428e-05 1.5 2.488002232142857e-05 1.5 2.4880580357142856e-05 0.0 2.4887276785714283e-05 0.0 2.488783482142857e-05 1.5 2.489787946428571e-05 1.5 2.4898437499999998e-05 0.0 2.4905133928571425e-05 0.0 2.4905691964285712e-05 1.5 2.4915736607142857e-05 1.5 2.491629464285714e-05 0.0 2.492299107142857e-05 0.0 2.4923549107142854e-05 1.5 2.493359375e-05 1.5 2.4934151785714283e-05 0.0 2.4940848214285713e-05 0.0 2.4941406249999997e-05 1.5 2.495145089285714e-05 1.5 2.4952008928571428e-05 0.0 2.4958705357142856e-05 0.0 2.4959263392857143e-05 1.5 2.4969308035714284e-05 1.5 2.496986607142857e-05 0.0 2.4976562499999998e-05 0.0 2.4977120535714285e-05 1.5 2.4987165178571426e-05 1.5 2.4987723214285713e-05 0.0 2.499441964285714e-05 0.0 2.4994977678571427e-05 1.5 2.500502232142857e-05 1.5 2.5005580357142855e-05 0.0 2.5012276785714283e-05 0.0 2.501283482142857e-05 1.5 2.5022879464285714e-05 1.5 2.5023437499999998e-05 0.0 2.503013392857143e-05 0.0 2.5030691964285712e-05 1.5 2.5040736607142856e-05 1.5 2.504129464285714e-05 0.0 2.504799107142857e-05 0.0 2.5048549107142854e-05 1.5 2.505859375e-05 1.5 2.5059151785714286e-05 0.0 2.5065848214285713e-05 0.0 2.506640625e-05 1.5 2.507645089285714e-05 1.5 2.5077008928571428e-05 0.0 2.5083705357142855e-05 0.0 2.5084263392857142e-05 1.5 2.5094308035714283e-05 1.5 2.509486607142857e-05 0.0 2.5101562499999998e-05 0.0 2.5102120535714284e-05 1.5 2.5112165178571426e-05 1.5 2.5112723214285713e-05 0.0 2.511941964285714e-05 0.0 2.5119977678571427e-05 1.5 2.5130022321428568e-05 1.5 2.5130580357142855e-05 0.0 2.5137276785714282e-05 0.0 2.513783482142857e-05 1.5 2.5147879464285714e-05 1.5 2.5148437499999997e-05 0.0 2.5155133928571428e-05 0.0 2.515569196428571e-05 1.5 2.5165736607142856e-05 1.5 2.516629464285714e-05 0.0 2.517299107142857e-05 0.0 2.5173549107142854e-05 1.5 2.518359375e-05 1.5 2.5184151785714285e-05 0.0 2.5190848214285713e-05 0.0 2.519140625e-05 1.5 2.520145089285714e-05 1.5 2.5202008928571428e-05 0.0 2.5208705357142855e-05 0.0 2.5209263392857142e-05 1.5 2.5219308035714283e-05 1.5 2.521986607142857e-05 0.0 2.5226562499999997e-05 0.0 2.5227120535714284e-05 1.5 2.5237165178571425e-05 1.5 2.5237723214285712e-05 0.0 2.524441964285714e-05 0.0 2.5244977678571426e-05 1.5 2.525502232142857e-05 1.5 2.5255580357142855e-05 0.0 2.5262276785714285e-05 0.0 2.526283482142857e-05 1.5 2.5272879464285713e-05 1.5 2.5273437499999997e-05 0.0 2.5280133928571428e-05 0.0 2.528069196428571e-05 1.5 2.5290736607142856e-05 1.5 2.5291294642857143e-05 0.0 2.529799107142857e-05 0.0 2.5298549107142857e-05 1.5 2.5308593749999998e-05 1.5 2.5309151785714285e-05 0.0 2.5315848214285712e-05 0.0 2.531640625e-05 1.5 2.532645089285714e-05 1.5 2.5327008928571427e-05 0.0 2.5333705357142855e-05 0.0 2.533426339285714e-05 1.5 2.5344308035714283e-05 1.5 2.534486607142857e-05 0.0 2.5351562499999997e-05 0.0 2.5352120535714284e-05 1.5 2.5362165178571425e-05 1.5 2.5362723214285712e-05 0.0 2.536941964285714e-05 0.0 2.5369977678571426e-05 1.5 2.538002232142857e-05 1.5 2.5380580357142854e-05 0.0 2.5387276785714285e-05 0.0 2.538783482142857e-05 1.5 2.5397879464285713e-05 1.5 2.53984375e-05 0.0 2.5405133928571427e-05 0.0 2.5405691964285714e-05 1.5 2.5415736607142855e-05 1.5 2.5416294642857142e-05 0.0 2.542299107142857e-05 0.0 2.5423549107142856e-05 1.5 2.5433593749999998e-05 1.5 2.5434151785714285e-05 0.0 2.5440848214285712e-05 0.0 2.544140625e-05 1.5 2.545145089285714e-05 1.5 2.5452008928571427e-05 0.0 2.5458705357142854e-05 0.0 2.545926339285714e-05 1.5 2.5469308035714282e-05 1.5 2.546986607142857e-05 0.0 2.5476562499999997e-05 0.0 2.5477120535714283e-05 1.5 2.5487165178571428e-05 1.5 2.548772321428571e-05 0.0 2.5494419642857142e-05 0.0 2.5494977678571426e-05 1.5 2.550502232142857e-05 1.5 2.5505580357142854e-05 0.0 2.5512276785714285e-05 0.0 2.5512834821428568e-05 1.5 2.5522879464285713e-05 1.5 2.55234375e-05 0.0 2.5530133928571427e-05 0.0 2.5530691964285714e-05 1.5 2.5540736607142855e-05 1.5 2.5541294642857142e-05 0.0 2.554799107142857e-05 0.0 2.5548549107142856e-05 1.5 2.5558593749999997e-05 1.5 2.5559151785714284e-05 0.0 2.556584821428571e-05 0.0 2.556640625e-05 1.5 2.557645089285714e-05 1.5 2.5577008928571426e-05 0.0 2.5583705357142854e-05 0.0 2.558426339285714e-05 1.5 2.5594308035714285e-05 1.5 2.559486607142857e-05 0.0 2.56015625e-05 0.0 2.5602120535714283e-05 1.5 2.5612165178571428e-05 1.5 2.561272321428571e-05 0.0 2.5619419642857142e-05 0.0 2.5619977678571425e-05 1.5 2.563002232142857e-05 1.5 2.5630580357142857e-05 0.0 2.5637276785714284e-05 0.0 2.563783482142857e-05 1.5 2.5647879464285712e-05 1.5 2.56484375e-05 0.0 2.5655133928571427e-05 0.0 2.5655691964285713e-05 1.5 2.5665736607142855e-05 1.5 2.566629464285714e-05 0.0 2.567299107142857e-05 0.0 2.5673549107142856e-05 1.5 2.5683593749999997e-05 1.5 2.5684151785714284e-05 0.0 2.569084821428571e-05 0.0 2.5691406249999998e-05 1.5 2.570145089285714e-05 1.5 2.5702008928571426e-05 0.0 2.5708705357142854e-05 0.0 2.570926339285714e-05 1.5 2.5719308035714285e-05 1.5 2.571986607142857e-05 0.0 2.57265625e-05 0.0 2.5727120535714283e-05 1.5 2.5737165178571427e-05 1.5 2.573772321428571e-05 0.0 2.5744419642857142e-05 0.0 2.5744977678571425e-05 1.5 2.575502232142857e-05 1.5 2.5755580357142856e-05 0.0 2.5762276785714284e-05 0.0 2.576283482142857e-05 1.5 2.5772879464285712e-05 1.5 2.57734375e-05 0.0 2.5780133928571426e-05 0.0 2.5780691964285713e-05 1.5 2.5790736607142854e-05 1.5 2.579129464285714e-05 0.0 2.579799107142857e-05 0.0 2.5798549107142855e-05 1.5 2.5808593749999997e-05 1.5 2.5809151785714283e-05 0.0 2.581584821428571e-05 0.0 2.5816406249999998e-05 1.5 2.5826450892857142e-05 1.5 2.5827008928571426e-05 0.0 2.5833705357142857e-05 0.0 2.583426339285714e-05 1.5 2.5844308035714285e-05 1.5 2.5844866071428568e-05 0.0 2.58515625e-05 0.0 2.5852120535714282e-05 1.5 2.5862165178571427e-05 1.5 2.5862723214285714e-05 0.0 2.586941964285714e-05 0.0 2.5869977678571428e-05 1.5 2.588002232142857e-05 1.5 2.5880580357142856e-05 0.0 2.5887276785714284e-05 0.0 2.588783482142857e-05 1.5 2.5897879464285712e-05 1.5 2.58984375e-05 0.0 2.5905133928571426e-05 0.0 2.5905691964285713e-05 1.5 2.5915736607142854e-05 1.5 2.591629464285714e-05 0.0 2.592299107142857e-05 0.0 2.5923549107142855e-05 1.5 2.593359375e-05 1.5 2.5934151785714283e-05 0.0 2.5940848214285714e-05 0.0 2.5941406249999997e-05 1.5 2.5951450892857142e-05 1.5 2.5952008928571425e-05 0.0 2.5958705357142856e-05 0.0 2.595926339285714e-05 1.5 2.5969308035714284e-05 1.5 2.596986607142857e-05 0.0 2.59765625e-05 0.0 2.5977120535714285e-05 1.5 2.5987165178571427e-05 1.5 2.5987723214285713e-05 0.0 2.599441964285714e-05 0.0 2.5994977678571428e-05 1.5 2.600502232142857e-05 1.5 2.6005580357142856e-05 0.0 2.6012276785714283e-05 0.0 2.601283482142857e-05 1.5 2.602287946428571e-05 1.5 2.6023437499999998e-05 0.0 2.6030133928571426e-05 0.0 2.6030691964285712e-05 1.5 2.6040736607142854e-05 1.5 2.604129464285714e-05 0.0 2.6047991071428568e-05 0.0 2.6048549107142855e-05 1.5 2.605859375e-05 1.5 2.6059151785714283e-05 0.0 2.6065848214285714e-05 0.0 2.6066406249999997e-05 1.5 2.6076450892857142e-05 1.5 2.6077008928571425e-05 0.0 2.6083705357142856e-05 0.0 2.608426339285714e-05 1.5 2.6094308035714284e-05 1.5 2.609486607142857e-05 0.0 2.61015625e-05 0.0 2.6102120535714285e-05 1.5 2.6112165178571426e-05 1.5 2.6112723214285713e-05 0.0 2.611941964285714e-05 0.0 2.6119977678571427e-05 1.5 2.613002232142857e-05 1.5 2.6130580357142855e-05 0.0 2.6137276785714283e-05 0.0 2.613783482142857e-05 1.5 2.614787946428571e-05 1.5 2.6148437499999998e-05 0.0 2.6155133928571425e-05 0.0 2.6155691964285712e-05 1.5 2.6165736607142857e-05 1.5 2.616629464285714e-05 0.0 2.617299107142857e-05 0.0 2.6173549107142854e-05 1.5 2.618359375e-05 1.5 2.6184151785714282e-05 0.0 2.6190848214285713e-05 0.0 2.6191406249999997e-05 1.5 2.620145089285714e-05 1.5 2.6202008928571428e-05 0.0 2.6208705357142856e-05 0.0 2.6209263392857142e-05 1.5 2.6219308035714284e-05 1.5 2.621986607142857e-05 0.0 2.6226562499999998e-05 0.0 2.6227120535714285e-05 1.5 2.6237165178571426e-05 1.5 2.6237723214285713e-05 0.0 2.624441964285714e-05 0.0 2.6244977678571427e-05 1.5 2.625502232142857e-05 1.5 2.6255580357142855e-05 0.0 2.6262276785714283e-05 0.0 2.626283482142857e-05 1.5 2.6272879464285714e-05 1.5 2.6273437499999997e-05 0.0 2.628013392857143e-05 0.0 2.6280691964285712e-05 1.5 2.6290736607142856e-05 1.5 2.629129464285714e-05 0.0 2.629799107142857e-05 0.0 2.6298549107142854e-05 1.5 2.630859375e-05 1.5 2.6309151785714285e-05 0.0 2.6315848214285713e-05 0.0 2.631640625e-05 1.5 2.632645089285714e-05 1.5 2.6327008928571428e-05 0.0 2.6333705357142855e-05 0.0 2.6334263392857142e-05 1.5 2.6344308035714283e-05 1.5 2.634486607142857e-05 0.0 2.6351562499999998e-05 0.0 2.6352120535714284e-05 1.5 2.6362165178571426e-05 1.5 2.6362723214285712e-05 0.0 2.636941964285714e-05 0.0 2.6369977678571427e-05 1.5 2.6380022321428568e-05 1.5 2.6380580357142855e-05 0.0 2.6387276785714282e-05 0.0 2.638783482142857e-05 1.5 2.6397879464285714e-05 1.5 2.6398437499999997e-05 0.0 2.6405133928571428e-05 0.0 2.640569196428571e-05 1.5 2.6415736607142856e-05 1.5 2.641629464285714e-05 0.0 2.642299107142857e-05 0.0 2.6423549107142854e-05 1.5 2.643359375e-05 1.5 2.6434151785714285e-05 0.0 2.6440848214285713e-05 0.0 2.644140625e-05 1.5 2.645145089285714e-05 1.5 2.6452008928571427e-05 0.0 2.6458705357142855e-05 0.0 2.6459263392857142e-05 1.5 2.6469308035714283e-05 1.5 2.646986607142857e-05 0.0 2.6476562499999997e-05 0.0 2.6477120535714284e-05 1.5 2.6487165178571425e-05 1.5 2.6487723214285712e-05 0.0 2.649441964285714e-05 0.0 2.6494977678571426e-05 1.5 2.650502232142857e-05 1.5 2.6505580357142854e-05 0.0 2.6512276785714285e-05 0.0 2.651283482142857e-05 1.5 2.6522879464285713e-05 1.5 2.6523437499999997e-05 0.0 2.6530133928571428e-05 0.0 2.653069196428571e-05 1.5 2.6540736607142856e-05 1.5 2.6541294642857142e-05 0.0 2.654799107142857e-05 0.0 2.6548549107142857e-05 1.5 2.6558593749999998e-05 1.5 2.6559151785714285e-05 0.0 2.6565848214285712e-05 0.0 2.656640625e-05 1.5 2.657645089285714e-05 1.5 2.6577008928571427e-05 0.0 2.6583705357142855e-05 0.0 2.658426339285714e-05 1.5 2.6594308035714283e-05 1.5 2.659486607142857e-05 0.0 2.6601562499999997e-05 0.0 2.6602120535714284e-05 1.5 2.6612165178571425e-05 1.5 2.6612723214285712e-05 0.0 2.6619419642857143e-05 0.0 2.6619977678571426e-05 1.5 2.663002232142857e-05 1.5 2.6630580357142854e-05 0.0 2.6637276785714285e-05 0.0 2.663783482142857e-05 1.5 2.6647879464285713e-05 1.5 2.66484375e-05 0.0 2.6655133928571427e-05 0.0 2.6655691964285714e-05 1.5 2.6665736607142855e-05 1.5 2.6666294642857142e-05 0.0 2.667299107142857e-05 0.0 2.6673549107142856e-05 1.5 2.6683593749999998e-05 1.5 2.6684151785714284e-05 0.0 2.6690848214285712e-05 0.0 2.669140625e-05 1.5 2.670145089285714e-05 1.5 2.6702008928571427e-05 0.0 2.6708705357142854e-05 0.0 2.670926339285714e-05 1.5 2.6719308035714282e-05 1.5 2.671986607142857e-05 0.0 2.6726562499999997e-05 0.0 2.6727120535714283e-05 1.5 2.6737165178571428e-05 1.5 2.673772321428571e-05 0.0 2.6744419642857142e-05 0.0 2.6744977678571426e-05 1.5 2.675502232142857e-05 1.5 2.6755580357142854e-05 0.0 2.6762276785714285e-05 0.0 2.6762834821428568e-05 1.5 2.6772879464285713e-05 1.5 2.67734375e-05 0.0 2.6780133928571427e-05 0.0 2.6780691964285714e-05 1.5 2.6790736607142855e-05 1.5 2.6791294642857142e-05 0.0 2.679799107142857e-05 0.0 2.6798549107142856e-05 1.5 2.6808593749999997e-05 1.5 2.6809151785714284e-05 0.0 2.681584821428571e-05 0.0 2.681640625e-05 1.5 2.682645089285714e-05 1.5 2.6827008928571426e-05 0.0 2.6833705357142854e-05 0.0 2.683426339285714e-05 1.5 2.6844308035714285e-05 1.5 2.684486607142857e-05 0.0 2.68515625e-05 0.0 2.6852120535714283e-05 1.5 2.6862165178571428e-05 1.5 2.686272321428571e-05 0.0 2.6869419642857142e-05 0.0 2.6869977678571425e-05 1.5 2.688002232142857e-05 1.5 2.6880580357142857e-05 0.0 2.6887276785714284e-05 0.0 2.688783482142857e-05 1.5 2.6897879464285712e-05 1.5 2.68984375e-05 0.0 2.6905133928571427e-05 0.0 2.6905691964285713e-05 1.5 2.6915736607142855e-05 1.5 2.691629464285714e-05 0.0 2.692299107142857e-05 0.0 2.6923549107142856e-05 1.5 2.6933593749999997e-05 1.5 2.6934151785714284e-05 0.0 2.694084821428571e-05 0.0 2.6941406249999998e-05 1.5 2.695145089285714e-05 1.5 2.6952008928571426e-05 0.0 2.6958705357142854e-05 0.0 2.695926339285714e-05 1.5 2.6969308035714285e-05 1.5 2.696986607142857e-05 0.0 2.69765625e-05 0.0 2.6977120535714283e-05 1.5 2.6987165178571427e-05 1.5 2.698772321428571e-05 0.0 2.699441964285714e-05 0.0 2.6994977678571425e-05 1.5 2.700502232142857e-05 1.5 2.7005580357142856e-05 0.0 2.7012276785714284e-05 0.0 2.701283482142857e-05 1.5 2.7022879464285712e-05 1.5 2.70234375e-05 0.0 2.7030133928571426e-05 0.0 2.7030691964285713e-05 1.5 2.7040736607142854e-05 1.5 2.704129464285714e-05 0.0 2.704799107142857e-05 0.0 2.7048549107142855e-05 1.5 2.7058593749999997e-05 1.5 2.7059151785714283e-05 0.0 2.706584821428571e-05 0.0 2.7066406249999998e-05 1.5 2.7076450892857142e-05 1.5 2.7077008928571426e-05 0.0 2.7083705357142857e-05 0.0 2.708426339285714e-05 1.5 2.7094308035714285e-05 1.5 2.7094866071428568e-05 0.0 2.71015625e-05 0.0 2.7102120535714282e-05 1.5 2.7112165178571427e-05 1.5 2.7112723214285714e-05 0.0 2.711941964285714e-05 0.0 2.7119977678571428e-05 1.5 2.713002232142857e-05 1.5 2.7130580357142856e-05 0.0 2.7137276785714284e-05 0.0 2.713783482142857e-05 1.5 2.714787946428571e-05 1.5 2.71484375e-05 0.0 2.7155133928571426e-05 0.0 2.7155691964285713e-05 1.5 2.7165736607142854e-05 1.5 2.716629464285714e-05 0.0 2.7172991071428568e-05 0.0 2.7173549107142855e-05 1.5 2.718359375e-05 1.5 2.7184151785714283e-05 0.0 2.7190848214285714e-05 0.0 2.7191406249999997e-05 1.5 2.7201450892857142e-05 1.5 2.7202008928571425e-05 0.0 2.7208705357142856e-05 0.0 2.720926339285714e-05 1.5 2.7219308035714284e-05 1.5 2.721986607142857e-05 0.0 2.72265625e-05 0.0 2.7227120535714285e-05 1.5 2.7237165178571427e-05 1.5 2.7237723214285713e-05 0.0 2.724441964285714e-05 0.0 2.7244977678571428e-05 1.5 2.725502232142857e-05 1.5 2.7255580357142856e-05 0.0 2.7262276785714283e-05 0.0 2.726283482142857e-05 1.5 2.727287946428571e-05 1.5 2.7273437499999998e-05 0.0 2.7280133928571426e-05 0.0 2.7280691964285712e-05 1.5 2.7290736607142854e-05 1.5 2.729129464285714e-05 0.0 2.7297991071428568e-05 0.0 2.7298549107142855e-05 1.5 2.730859375e-05 1.5 2.7309151785714283e-05 0.0 2.7315848214285714e-05 0.0 2.7316406249999997e-05 1.5 2.732645089285714e-05 1.5 2.7327008928571425e-05 0.0 2.7333705357142856e-05 0.0 2.733426339285714e-05 1.5 2.7344308035714284e-05 1.5 2.734486607142857e-05 0.0 2.7351562499999998e-05 0.0 2.7352120535714285e-05 1.5 2.7362165178571426e-05 1.5 2.7362723214285713e-05 0.0 2.736941964285714e-05 0.0 2.7369977678571427e-05 1.5 2.738002232142857e-05 1.5 2.7380580357142855e-05 0.0 2.7387276785714283e-05 0.0 2.738783482142857e-05 1.5 2.739787946428571e-05 1.5 2.7398437499999998e-05 0.0 2.7405133928571425e-05 0.0 2.7405691964285712e-05 1.5 2.7415736607142857e-05 1.5 2.741629464285714e-05 0.0 2.7423549107142854e-05 0.0 2.742410714285714e-05 1.5 2.7433035714285712e-05 1.5 2.743359375e-05 0.0 2.7441406249999997e-05 0.0 2.7441964285714283e-05 1.5 2.7450892857142855e-05 1.5 2.745145089285714e-05 0.0 2.7459263392857142e-05 0.0 2.7459821428571426e-05 1.5 2.7468749999999997e-05 1.5 2.7469308035714284e-05 0.0 2.7477120535714285e-05 0.0 2.7477678571428568e-05 1.5 2.7486607142857143e-05 1.5 2.7487165178571426e-05 0.0 2.7494977678571427e-05 0.0 2.7495535714285714e-05 1.5 2.7504464285714285e-05 1.5 2.7505022321428568e-05 0.0 2.751283482142857e-05 0.0 2.7513392857142856e-05 1.5 2.7522321428571427e-05 1.5 2.7522879464285714e-05 0.0 2.753069196428571e-05 0.0 2.753125e-05 1.5 2.754017857142857e-05 1.5 2.7540736607142856e-05 0.0 2.7548549107142854e-05 0.0 2.754910714285714e-05 1.5 2.7558035714285712e-05 1.5 2.755859375e-05 0.0 2.756640625e-05 0.0 2.7566964285714283e-05 1.5 2.7575892857142854e-05 1.5 2.757645089285714e-05 0.0 2.7584263392857142e-05 0.0 2.7584821428571425e-05 1.5 2.7593749999999996e-05 1.5 2.7594308035714283e-05 0.0 2.7602120535714284e-05 0.0 2.760267857142857e-05 1.5 2.7611607142857142e-05 1.5 2.7612165178571426e-05 0.0 2.7619977678571427e-05 0.0 2.7620535714285713e-05 1.5 2.7629464285714285e-05 1.5 2.7630022321428568e-05 0.0 2.763783482142857e-05 0.0 2.7638392857142856e-05 1.5 2.7647321428571427e-05 1.5 2.7647879464285714e-05 0.0 2.765569196428571e-05 0.0 2.7656249999999998e-05 1.5 2.766517857142857e-05 1.5 2.7665736607142856e-05 0.0 2.7673549107142854e-05 0.0 2.767410714285714e-05 1.5 2.768303571428571e-05 1.5 2.7683593749999998e-05 0.0 2.769140625e-05 0.0 2.7691964285714283e-05 1.5 2.7700892857142854e-05 1.5 2.770145089285714e-05 0.0 2.770926339285714e-05 0.0 2.7709821428571425e-05 1.5 2.771875e-05 1.5 2.7719308035714283e-05 0.0 2.7727120535714284e-05 0.0 2.772767857142857e-05 1.5 2.7736607142857142e-05 1.5 2.7737165178571425e-05 0.0 2.7744977678571426e-05 0.0 2.7745535714285713e-05 1.5 2.7754464285714284e-05 1.5 2.775502232142857e-05 0.0 2.776283482142857e-05 0.0 2.7763392857142855e-05 1.5 2.7772321428571426e-05 1.5 2.7772879464285713e-05 0.0 2.778069196428571e-05 0.0 2.7781249999999998e-05 1.5 2.779017857142857e-05 1.5 2.7790736607142856e-05 0.0 2.7798549107142857e-05 0.0 2.779910714285714e-05 1.5 2.780803571428571e-05 1.5 2.7808593749999998e-05 0.0 2.781640625e-05 0.0 2.7816964285714282e-05 1.5 2.7825892857142853e-05 1.5 2.782645089285714e-05 0.0 2.783426339285714e-05 0.0 2.7834821428571428e-05 1.5 2.784375e-05 1.5 2.7844308035714283e-05 0.0 2.7852120535714284e-05 0.0 2.785267857142857e-05 1.5 2.786160714285714e-05 1.5 2.7862165178571428e-05 0.0 2.7869977678571426e-05 0.0 2.7870535714285713e-05 1.5 2.7879464285714284e-05 1.5 2.788002232142857e-05 0.0 2.7887834821428568e-05 0.0 2.7888392857142855e-05 1.5 2.7897321428571426e-05 1.5 2.7897879464285713e-05 0.0 2.7905691964285714e-05 0.0 2.7906249999999997e-05 1.5 2.791517857142857e-05 1.5 2.7915736607142855e-05 0.0 2.7923549107142856e-05 0.0 2.792410714285714e-05 1.5 2.793303571428571e-05 1.5 2.7933593749999998e-05 0.0 2.794140625e-05 0.0 2.7941964285714285e-05 1.5 2.7950892857142856e-05 1.5 2.795145089285714e-05 0.0 2.795926339285714e-05 0.0 2.7959821428571428e-05 1.5 2.796875e-05 1.5 2.7969308035714282e-05 0.0 2.7977120535714283e-05 0.0 2.797767857142857e-05 1.5 2.798660714285714e-05 1.5 2.7987165178571428e-05 0.0 2.7994977678571426e-05 0.0 2.7995535714285712e-05 1.5 2.8004464285714283e-05 1.5 2.800502232142857e-05 0.0 2.8012834821428568e-05 0.0 2.8013392857142855e-05 1.5 2.8022321428571426e-05 1.5 2.8022879464285713e-05 0.0 2.8030691964285714e-05 0.0 2.8031249999999997e-05 1.5 2.8040178571428568e-05 1.5 2.8040736607142855e-05 0.0 2.8048549107142856e-05 0.0 2.804910714285714e-05 1.5 2.8058035714285714e-05 1.5 2.8058593749999997e-05 0.0 2.8066406249999998e-05 0.0 2.8066964285714285e-05 1.5 2.8075892857142856e-05 1.5 2.807645089285714e-05 0.0 2.808426339285714e-05 0.0 2.8084821428571427e-05 1.5 2.8093191964285712e-05 1.5 2.809375e-05 0.0 2.810267857142857e-05 0.0 2.8103236607142856e-05 1.5 2.8111049107142854e-05 1.5 2.811160714285714e-05 0.0 2.8120535714285712e-05 0.0 2.812109375e-05 1.5 2.8128906249999996e-05 1.5 2.8129464285714283e-05 0.0 2.8138392857142854e-05 0.0 2.813895089285714e-05 1.5 2.8146763392857142e-05 1.5 2.8147321428571425e-05 0.0 2.8156249999999997e-05 0.0 2.8156808035714283e-05 1.5 2.8164620535714284e-05 1.5 2.8165178571428568e-05 0.0 2.8174107142857142e-05 0.0 2.8174665178571426e-05 1.5 2.8182477678571427e-05 1.5 2.8183035714285713e-05 0.0 2.8191964285714285e-05 0.0 2.8192522321428568e-05 1.5 2.820033482142857e-05 1.5 2.8200892857142856e-05 0.0 2.8209821428571427e-05 0.0 2.8210379464285714e-05 1.5 2.821819196428571e-05 1.5 2.8218749999999998e-05 0.0 2.822767857142857e-05 0.0 2.8228236607142856e-05 1.5 2.8236049107142854e-05 1.5 2.823660714285714e-05 0.0 2.824553571428571e-05 0.0 2.824609375e-05 1.5 2.825390625e-05 1.5 2.8254464285714283e-05 0.0 2.8263392857142854e-05 0.0 2.826395089285714e-05 1.5 2.8271763392857142e-05 1.5 2.8272321428571425e-05 0.0 2.828125e-05 0.0 2.8281808035714283e-05 1.5 2.8289620535714284e-05 1.5 2.829017857142857e-05 0.0 2.8299107142857142e-05 0.0 2.8299665178571425e-05 1.5 2.8307477678571426e-05 1.5 2.8308035714285713e-05 0.0 2.8316964285714284e-05 0.0 2.831752232142857e-05 1.5 2.832533482142857e-05 1.5 2.8325892857142855e-05 0.0 2.8334821428571427e-05 0.0 2.8335379464285713e-05 1.5 2.834319196428571e-05 1.5 2.8343749999999998e-05 0.0 2.835267857142857e-05 0.0 2.8353236607142856e-05 1.5 2.8361049107142857e-05 1.5 2.836160714285714e-05 0.0 2.837053571428571e-05 0.0 2.8371093749999998e-05 1.5 2.837890625e-05 1.5 2.8379464285714282e-05 0.0 2.8388392857142854e-05 0.0 2.838895089285714e-05 1.5 2.839676339285714e-05 1.5 2.8397321428571428e-05 0.0 2.840625e-05 0.0 2.8406808035714283e-05 1.5 2.8414620535714284e-05 1.5 2.841517857142857e-05 0.0 2.842410714285714e-05 0.0 2.8424665178571425e-05 1.5 2.8432477678571426e-05 1.5 2.8433035714285713e-05 0.0 2.8441964285714284e-05 0.0 2.844252232142857e-05 1.5 2.845033482142857e-05 1.5 2.8450892857142855e-05 0.0 2.8459821428571426e-05 0.0 2.8460379464285713e-05 1.5 2.846819196428571e-05 1.5 2.8468749999999997e-05 0.0 2.847767857142857e-05 0.0 2.8478236607142855e-05 1.5 2.8486049107142856e-05 1.5 2.848660714285714e-05 0.0 2.849553571428571e-05 0.0 2.8496093749999998e-05 1.5 2.850390625e-05 1.5 2.8504464285714282e-05 0.0 2.8513392857142857e-05 0.0 2.851395089285714e-05 1.5 2.852176339285714e-05 1.5 2.8522321428571428e-05 0.0 2.853125e-05 0.0 2.8531808035714282e-05 1.5 2.8539620535714283e-05 1.5 2.854017857142857e-05 0.0 2.854910714285714e-05 0.0 2.8549665178571428e-05 1.5 2.8557477678571426e-05 1.5 2.8558035714285712e-05 0.0 2.8566964285714284e-05 0.0 2.856752232142857e-05 1.5 2.8575334821428568e-05 1.5 2.8575892857142855e-05 0.0 2.8584821428571426e-05 0.0 2.8585379464285713e-05 1.5 2.8593191964285714e-05 1.5 2.8593749999999997e-05 0.0 2.8602678571428568e-05 0.0 2.8603236607142855e-05 1.5 2.8611049107142856e-05 1.5 2.861160714285714e-05 0.0 2.862053571428571e-05 0.0 2.8621093749999997e-05 1.5 2.862890625e-05 1.5 2.8629464285714285e-05 0.0 2.8638392857142856e-05 0.0 2.863895089285714e-05 1.5 2.864676339285714e-05 1.5 2.8647321428571427e-05 0.0 2.865625e-05 0.0 2.8656808035714285e-05 1.5 2.8664620535714283e-05 1.5 2.866517857142857e-05 0.0 2.867410714285714e-05 0.0 2.8674665178571428e-05 1.5 2.8682477678571425e-05 1.5 2.8683035714285712e-05 0.0 2.8691964285714283e-05 0.0 2.869252232142857e-05 1.5 2.870033482142857e-05 1.5 2.8700892857142854e-05 0.0 2.8709821428571426e-05 0.0 2.8710379464285712e-05 1.5 2.8718191964285713e-05 1.5 2.8718749999999997e-05 0.0 2.8727678571428568e-05 0.0 2.8728236607142855e-05 1.5 2.8736049107142856e-05 1.5 2.8736607142857142e-05 0.0 2.8745535714285714e-05 0.0 2.8746093749999997e-05 1.5 2.8753906249999998e-05 1.5 2.8754464285714285e-05 0.0 2.876395089285714e-05 0.0 2.8764508928571426e-05 1.5 2.8771205357142854e-05 1.5 2.877176339285714e-05 0.0 2.8781808035714285e-05 0.0 2.878236607142857e-05 1.5 2.87890625e-05 1.5 2.8789620535714283e-05 0.0 2.8799665178571427e-05 0.0 2.880022321428571e-05 1.5 2.880691964285714e-05 1.5 2.8807477678571425e-05 0.0 2.881752232142857e-05 0.0 2.8818080357142856e-05 1.5 2.8824776785714284e-05 1.5 2.882533482142857e-05 0.0 2.8835379464285712e-05 0.0 2.88359375e-05 1.5 2.8842633928571426e-05 1.5 2.8843191964285713e-05 0.0 2.8853236607142854e-05 0.0 2.885379464285714e-05 1.5 2.886049107142857e-05 1.5 2.8861049107142855e-05 0.0 2.8871093749999997e-05 0.0 2.8871651785714283e-05 1.5 2.887834821428571e-05 1.5 2.8878906249999998e-05 0.0 2.8888950892857142e-05 0.0 2.8889508928571426e-05 1.5 2.8896205357142857e-05 1.5 2.889676339285714e-05 0.0 2.8906808035714285e-05 0.0 2.8907366071428568e-05 1.5 2.89140625e-05 1.5 2.8914620535714282e-05 0.0 2.8924665178571427e-05 0.0 2.8925223214285714e-05 1.5 2.893191964285714e-05 1.5 2.8932477678571428e-05 0.0 2.894252232142857e-05 0.0 2.8943080357142856e-05 1.5 2.8949776785714284e-05 1.5 2.895033482142857e-05 0.0 2.896037946428571e-05 0.0 2.89609375e-05 1.5 2.8967633928571426e-05 1.5 2.8968191964285713e-05 0.0 2.8978236607142854e-05 0.0 2.897879464285714e-05 1.5 2.8985491071428568e-05 1.5 2.8986049107142855e-05 0.0 2.8996093749999996e-05 0.0 2.8996651785714283e-05 1.5 2.900334821428571e-05 1.5 2.9003906249999997e-05 0.0 2.9013950892857142e-05 0.0 2.9014508928571425e-05 1.5 2.9021205357142856e-05 1.5 2.902176339285714e-05 0.0 2.9031808035714284e-05 0.0 2.9032366071428568e-05 1.5 2.90390625e-05 1.5 2.9039620535714282e-05 0.0 2.9049665178571427e-05 0.0 2.9050223214285713e-05 1.5 2.905691964285714e-05 1.5 2.9057477678571428e-05 0.0 2.906752232142857e-05 0.0 2.9068080357142856e-05 1.5 2.9074776785714283e-05 1.5 2.907533482142857e-05 0.0 2.908537946428571e-05 0.0 2.9085937499999998e-05 1.5 2.9092633928571426e-05 1.5 2.9093191964285712e-05 0.0 2.9103236607142854e-05 0.0 2.910379464285714e-05 1.5 2.9110491071428568e-05 1.5 2.9111049107142855e-05 0.0 2.912109375e-05 0.0 2.9121651785714283e-05 1.5 2.9128348214285714e-05 1.5 2.9128906249999997e-05 0.0 2.913895089285714e-05 0.0 2.9139508928571425e-05 1.5 2.9146205357142856e-05 1.5 2.914676339285714e-05 0.0 2.9156808035714284e-05 0.0 2.915736607142857e-05 1.5 2.9164062499999998e-05 1.5 2.9164620535714285e-05 0.0 2.9174665178571426e-05 0.0 2.9175223214285713e-05 1.5 2.918191964285714e-05 1.5 2.9182477678571427e-05 0.0 2.919252232142857e-05 0.0 2.9193080357142855e-05 1.5 2.9199776785714283e-05 1.5 2.920033482142857e-05 0.0 2.921037946428571e-05 0.0 2.9210937499999998e-05 1.5 2.9217633928571425e-05 1.5 2.9218191964285712e-05 0.0 2.9228236607142857e-05 0.0 2.922879464285714e-05 1.5 2.923549107142857e-05 1.5 2.9236049107142854e-05 0.0 2.924609375e-05 0.0 2.9246651785714282e-05 1.5 2.9253348214285713e-05 1.5 2.9253906249999997e-05 0.0 2.926395089285714e-05 0.0 2.9264508928571428e-05 1.5 2.9271205357142856e-05 1.5 2.9271763392857142e-05 0.0 2.9281808035714284e-05 0.0 2.928236607142857e-05 1.5 2.9289062499999998e-05 1.5 2.9289620535714285e-05 0.0 2.9299665178571426e-05 0.0 2.9300223214285713e-05 1.5 2.930691964285714e-05 1.5 2.9307477678571427e-05 0.0 2.9317522321428568e-05 0.0 2.9318080357142855e-05 1.5 2.9324776785714283e-05 1.5 2.932533482142857e-05 0.0 2.933537946428571e-05 0.0 2.9335937499999997e-05 1.5 2.9342633928571425e-05 1.5 2.934319196428571e-05 0.0 2.9353236607142856e-05 0.0 2.935379464285714e-05 1.5 2.936049107142857e-05 1.5 2.9361049107142854e-05 0.0 2.937109375e-05 0.0 2.9371651785714282e-05 1.5 2.9378348214285713e-05 1.5 2.9378906249999996e-05 0.0 2.938895089285714e-05 0.0 2.9389508928571428e-05 1.5 2.9396205357142855e-05 1.5 2.9396763392857142e-05 0.0 2.9406808035714283e-05 0.0 2.940736607142857e-05 1.5 2.9414062499999998e-05 1.5 2.9414620535714284e-05 0.0 2.9424665178571426e-05 0.0 2.9425223214285712e-05 1.5 2.943191964285714e-05 1.5 2.9432477678571427e-05 0.0 2.9442522321428568e-05 0.0 2.9443080357142855e-05 1.5 2.9449776785714282e-05 1.5 2.945033482142857e-05 0.0 2.9460379464285714e-05 0.0 2.9460937499999997e-05 1.5 2.9467633928571428e-05 1.5 2.946819196428571e-05 0.0 2.9478236607142856e-05 0.0 2.947879464285714e-05 1.5 2.948549107142857e-05 1.5 2.9486049107142854e-05 0.0 2.9496093749999998e-05 0.0 2.9496651785714285e-05 1.5 2.9503348214285713e-05 1.5 2.950390625e-05 0.0 2.951395089285714e-05 0.0 2.9514508928571427e-05 1.5 2.9521205357142855e-05 1.5 2.952176339285714e-05 0.0 2.9531808035714283e-05 0.0 2.953236607142857e-05 1.5 2.9539062499999997e-05 1.5 2.9539620535714284e-05 0.0 2.9549665178571425e-05 0.0 2.9550223214285712e-05 1.5 2.955691964285714e-05 1.5 2.9557477678571426e-05 0.0 2.956752232142857e-05 0.0 2.9568080357142854e-05 1.5 2.9574776785714285e-05 1.5 2.957533482142857e-05 0.0 2.9585379464285713e-05 0.0 2.9585937499999997e-05 1.5 2.9592633928571428e-05 1.5 2.959319196428571e-05 0.0 2.9603236607142856e-05 0.0 2.9603794642857142e-05 1.5 2.961049107142857e-05 1.5 2.9611049107142857e-05 0.0 2.9621093749999998e-05 0.0 2.9621651785714285e-05 1.5 2.9628348214285712e-05 1.5 2.962890625e-05 0.0 2.963895089285714e-05 0.0 2.9639508928571427e-05 1.5 2.9646205357142855e-05 1.5 2.964676339285714e-05 0.0 2.9656808035714283e-05 0.0 2.965736607142857e-05 1.5 2.9664062499999997e-05 1.5 2.9664620535714284e-05 0.0 2.9674665178571425e-05 0.0 2.967522321428571e-05 1.5 2.968191964285714e-05 1.5 2.9682477678571426e-05 0.0 2.969252232142857e-05 0.0 2.9693080357142854e-05 1.5 2.9699776785714285e-05 1.5 2.9700334821428568e-05 0.0 2.9710379464285713e-05 0.0 2.9710937499999996e-05 1.5 2.9717633928571427e-05 1.5 2.971819196428571e-05 0.0 2.9728236607142855e-05 0.0 2.9728794642857142e-05 1.5 2.973549107142857e-05 1.5 2.9736049107142856e-05 0.0 2.9746093749999998e-05 0.0 2.9746651785714284e-05 1.5 2.9753348214285712e-05 1.5 2.975390625e-05 0.0 2.976395089285714e-05 0.0 2.9764508928571427e-05 1.5 2.9771205357142854e-05 1.5 2.977176339285714e-05 0.0 2.9781808035714282e-05 0.0 2.978236607142857e-05 1.5 2.9789062499999996e-05 1.5 2.9789620535714283e-05 0.0 2.9799665178571428e-05 0.0 2.980022321428571e-05 1.5 2.9806919642857142e-05 1.5 2.9807477678571426e-05 0.0 2.981752232142857e-05 0.0 2.9818080357142854e-05 1.5 2.9824776785714285e-05 1.5 2.9825334821428568e-05 0.0 2.9835379464285713e-05 0.0 2.98359375e-05 1.5 2.9842633928571427e-05 1.5 2.9843191964285714e-05 0.0 2.9853236607142855e-05 0.0 2.985379464285714e-05 1.5 2.986049107142857e-05 1.5 2.9861049107142856e-05 0.0 2.9871093749999997e-05 0.0 2.9871651785714284e-05 1.5 2.987834821428571e-05 1.5 2.9878906249999998e-05 0.0 2.988895089285714e-05 0.0 2.9889508928571426e-05 1.5 2.9896205357142854e-05 1.5 2.989676339285714e-05 0.0 2.9906808035714285e-05 0.0 2.990736607142857e-05 1.5 2.99140625e-05 1.5 2.9914620535714283e-05 0.0 2.9924665178571428e-05 0.0 2.992522321428571e-05 1.5 2.9931919642857142e-05 1.5 2.9932477678571425e-05 0.0 2.994252232142857e-05 0.0 2.9943080357142857e-05 1.5 2.9949776785714284e-05 1.5 2.995033482142857e-05 0.0 2.9960379464285712e-05 0.0 2.99609375e-05 1.5 2.9967633928571426e-05 1.5 2.9968191964285713e-05 0.0 2.9978236607142855e-05 0.0 2.997879464285714e-05 1.5 2.998549107142857e-05 1.5 2.9986049107142856e-05 0.0 2.9996093749999997e-05 0.0 2.9996651785714284e-05 1.5 3.000334821428571e-05 1.5 3.0003906249999998e-05 0.0 3.001395089285714e-05 0.0 3.0014508928571426e-05 1.5 3.0021205357142853e-05 1.5 3.002176339285714e-05 0.0 3.0031808035714285e-05 0.0 3.0032366071428568e-05 1.5 3.00390625e-05 1.5 3.0039620535714283e-05 0.0 3.0049665178571427e-05 0.0 3.005022321428571e-05 1.5 3.005691964285714e-05 1.5 3.0057477678571425e-05 0.0 3.006752232142857e-05 0.0 3.0068080357142856e-05 1.5 3.0074776785714284e-05 1.5 3.007533482142857e-05 0.0 3.0085379464285712e-05 0.0 3.00859375e-05 1.5 3.0092633928571426e-05 1.5 3.0093191964285713e-05 0.0 3.0103236607142854e-05 0.0 3.010379464285714e-05 1.5 3.011049107142857e-05 1.5 3.0111049107142855e-05 0.0 3.0121093749999997e-05 0.0 3.0121651785714283e-05 1.5 3.012834821428571e-05 1.5 3.0128906249999998e-05 0.0 3.0138950892857142e-05 0.0 3.0139508928571426e-05 1.5 3.0146205357142856e-05 1.5 3.014676339285714e-05 0.0 3.0156808035714285e-05 0.0 3.0157366071428568e-05 1.5 3.01640625e-05 1.5 3.0164620535714282e-05 0.0 3.0174665178571427e-05 0.0 3.0175223214285714e-05 1.5 3.018191964285714e-05 1.5 3.0182477678571428e-05 0.0 3.019252232142857e-05 0.0 3.0193080357142856e-05 1.5 3.0199776785714283e-05 1.5 3.020033482142857e-05 0.0 3.021037946428571e-05 0.0 3.0210937499999998e-05 1.5 3.0217633928571426e-05 1.5 3.0218191964285713e-05 0.0 3.0228236607142854e-05 0.0 3.022879464285714e-05 1.5 3.0235491071428568e-05 1.5 3.0236049107142855e-05 0.0 3.0246093749999996e-05 0.0 3.0246651785714283e-05 1.5 3.025334821428571e-05 1.5 3.0253906249999997e-05 0.0 3.0263950892857142e-05 0.0 3.0264508928571425e-05 1.5 3.0271205357142856e-05 1.5 3.027176339285714e-05 0.0 3.0281808035714284e-05 0.0 3.028236607142857e-05 1.5 3.02890625e-05 1.5 3.0289620535714285e-05 0.0 3.0299665178571427e-05 0.0 3.0300223214285713e-05 1.5 3.030691964285714e-05 1.5 3.0307477678571428e-05 0.0 3.031752232142857e-05 0.0 3.0318080357142856e-05 1.5 3.0324776785714283e-05 1.5 3.032533482142857e-05 0.0 3.033537946428571e-05 0.0 3.0335937499999998e-05 1.5 3.0342633928571425e-05 1.5 3.0343191964285712e-05 0.0 3.0353236607142853e-05 0.0 3.035379464285714e-05 1.5 3.0360491071428568e-05 1.5 3.0361049107142855e-05 0.0 3.037109375e-05 0.0 3.0371651785714283e-05 1.5 3.0378348214285713e-05 1.5 3.0378906249999997e-05 0.0 3.038895089285714e-05 0.0 3.0389508928571425e-05 1.5 3.0396205357142856e-05 1.5 3.039676339285714e-05 0.0 3.0406808035714284e-05 0.0 3.040736607142857e-05 1.5 3.0414062499999998e-05 1.5 3.0414620535714285e-05 0.0 3.0424665178571426e-05 0.0 3.0425223214285713e-05 1.5 3.043191964285714e-05 1.5 3.0432477678571427e-05 0.0 3.044252232142857e-05 0.0 3.0443080357142855e-05 1.5 3.0449776785714283e-05 1.5 3.045033482142857e-05 0.0 3.046037946428571e-05 0.0 3.0460937499999998e-05 1.5 3.0467633928571425e-05 1.5 3.0468191964285712e-05 0.0 3.0478236607142857e-05 0.0 3.047879464285714e-05 1.5 3.048549107142857e-05 1.5 3.0486049107142854e-05 0.0 3.049609375e-05 0.0 3.0496651785714282e-05 1.5 3.0503348214285713e-05 1.5 3.0503906249999996e-05 0.0 3.051395089285714e-05 0.0 3.0514508928571428e-05 1.5 3.052120535714285e-05 1.5 3.052176339285714e-05 0.0 3.0531808035714283e-05 0.0 3.053236607142857e-05 1.5 3.05390625e-05 1.5 3.0539620535714285e-05 0.0 3.0549665178571426e-05 0.0 3.055022321428571e-05 1.5 3.0556919642857143e-05 1.5 3.055747767857143e-05 0.0 3.056752232142857e-05 0.0 3.056808035714286e-05 1.5 3.0574776785714286e-05 1.5 3.057533482142857e-05 0.0 3.058537946428571e-05 0.0 3.05859375e-05 1.5 3.059263392857143e-05 1.5 3.059319196428571e-05 0.0 3.060323660714285e-05 0.0 3.060379464285714e-05 1.5 3.061049107142857e-05 1.5 3.0611049107142854e-05 0.0 3.0621093749999995e-05 0.0 3.0621651785714285e-05 1.5 3.062834821428571e-05 1.5 3.0628906249999996e-05 0.0 3.063895089285714e-05 0.0 3.063950892857143e-05 1.5 3.0646205357142855e-05 1.5 3.064676339285714e-05 0.0 3.0656808035714287e-05 0.0 3.065736607142857e-05 1.5 3.06640625e-05 1.5 3.066462053571428e-05 0.0 3.067466517857143e-05 0.0 3.067522321428571e-05 1.5 3.068191964285714e-05 1.5 3.068247767857142e-05 0.0 3.069252232142857e-05 0.0 3.0693080357142855e-05 1.5 3.069977678571428e-05 1.5 3.070033482142857e-05 0.0 3.0710379464285713e-05 0.0 3.07109375e-05 1.5 3.0717633928571424e-05 1.5 3.0718191964285715e-05 0.0 3.0728236607142856e-05 0.0 3.072879464285714e-05 1.5 3.073549107142857e-05 1.5 3.073604910714286e-05 0.0 3.074609375e-05 0.0 3.074665178571428e-05 1.5 3.075334821428571e-05 1.5 3.075390625e-05 0.0 3.076395089285714e-05 0.0 3.0764508928571424e-05 1.5 3.077120535714286e-05 1.5 3.077176339285714e-05 0.0 3.078180803571428e-05 0.0 3.0782366071428566e-05 1.5 3.07890625e-05 1.5 3.0789620535714284e-05 0.0 3.0799665178571425e-05 0.0 3.0800223214285715e-05 1.5 3.080691964285714e-05 1.5 3.0807477678571426e-05 0.0 3.081752232142857e-05 0.0 3.081808035714286e-05 1.5 3.0824776785714285e-05 1.5 3.082533482142857e-05 0.0 3.083537946428571e-05 0.0 3.08359375e-05 1.5 3.084263392857143e-05 1.5 3.084319196428571e-05 0.0 3.085323660714285e-05 0.0 3.085379464285714e-05 1.5 3.086049107142857e-05 1.5 3.086104910714285e-05 0.0 3.0871093749999994e-05 0.0 3.0871651785714285e-05 1.5 3.087834821428571e-05 1.5 3.0878906249999995e-05 0.0 3.0888950892857144e-05 0.0 3.088950892857143e-05 1.5 3.0896205357142854e-05 1.5 3.089676339285714e-05 0.0 3.0906808035714286e-05 0.0 3.090736607142857e-05 1.5 3.09140625e-05 1.5 3.091462053571429e-05 0.0 3.092466517857143e-05 0.0 3.092522321428571e-05 1.5 3.093191964285714e-05 1.5 3.093247767857143e-05 0.0 3.094252232142857e-05 0.0 3.0943080357142854e-05 1.5 3.094977678571428e-05 1.5 3.095033482142857e-05 0.0 3.096037946428571e-05 0.0 3.0960937499999996e-05 1.5 3.0967633928571424e-05 1.5 3.0968191964285714e-05 0.0 3.0978236607142855e-05 0.0 3.097879464285714e-05 1.5 3.0985491071428566e-05 1.5 3.0986049107142856e-05 0.0 3.099609375e-05 0.0 3.099665178571428e-05 1.5 3.1003348214285715e-05 1.5 3.100390625e-05 0.0 3.101395089285714e-05 0.0 3.101450892857142e-05 1.5 3.102120535714286e-05 1.5 3.102176339285714e-05 0.0 3.103180803571428e-05 0.0 3.103236607142857e-05 1.5 3.10390625e-05 1.5 3.103962053571428e-05 0.0 3.1049665178571424e-05 0.0 3.1050223214285715e-05 1.5 3.105691964285714e-05 1.5 3.1057477678571425e-05 0.0 3.106752232142857e-05 0.0 3.106808035714286e-05 1.5 3.1074776785714284e-05 1.5 3.107533482142857e-05 0.0 3.108537946428571e-05 0.0 3.10859375e-05 1.5 3.109263392857143e-05 1.5 3.109319196428571e-05 0.0 3.110323660714286e-05 0.0 3.110379464285714e-05 1.5 3.111049107142857e-05 1.5 3.111104910714285e-05 0.0 3.112109375e-05 0.0 3.1121651785714284e-05 1.5 3.112834821428571e-05 1.5 3.1128906249999995e-05 0.0 3.113895089285714e-05 0.0 3.1139508928571426e-05 1.5 3.1146205357142854e-05 1.5 3.1146763392857144e-05 0.0 3.1156808035714285e-05 0.0 3.115736607142857e-05 1.5 3.1164062499999996e-05 1.5 3.1164620535714286e-05 0.0 3.117466517857143e-05 0.0 3.117522321428571e-05 1.5 3.118191964285714e-05 1.5 3.118247767857143e-05 0.0 3.119252232142857e-05 0.0 3.119308035714285e-05 1.5 3.119977678571428e-05 1.5 3.120033482142857e-05 0.0 3.121037946428571e-05 0.0 3.1210937499999995e-05 1.5 3.121763392857142e-05 1.5 3.121819196428571e-05 0.0 3.1228236607142854e-05 0.0 3.122879464285714e-05 1.5 3.123549107142857e-05 1.5 3.1236049107142855e-05 0.0 3.124609375e-05 0.0 3.124665178571428e-05 1.5 3.1253348214285714e-05 1.5 3.125390625e-05 0.0 3.126395089285714e-05 0.0 3.126450892857143e-05 1.5 3.127120535714286e-05 1.5 3.127176339285714e-05 0.0 3.128180803571428e-05 0.0 3.128236607142857e-05 1.5 3.12890625e-05 1.5 3.128962053571428e-05 0.0 3.1299665178571424e-05 0.0 3.1300223214285714e-05 1.5 3.130691964285714e-05 1.5 3.1307477678571425e-05 0.0 3.1317522321428566e-05 0.0 3.1318080357142856e-05 1.5 3.1324776785714284e-05 1.5 3.132533482142857e-05 0.0 3.1335379464285715e-05 0.0 3.13359375e-05 1.5 3.1342633928571426e-05 1.5 3.134319196428571e-05 0.0 3.135323660714286e-05 0.0 3.135379464285714e-05 1.5 3.136049107142857e-05 1.5 3.136104910714285e-05 0.0 3.137109375e-05 0.0 3.137165178571428e-05 1.5 3.137834821428571e-05 1.5 3.137890625e-05 0.0 3.138895089285714e-05 0.0 3.1389508928571425e-05 1.5 3.139620535714285e-05 1.5 3.139676339285714e-05 0.0 3.1406808035714284e-05 0.0 3.140736607142857e-05 1.5 3.1414062499999995e-05 1.5 3.1414620535714285e-05 0.0 3.142466517857143e-05 0.0 3.142522321428571e-05 1.5 3.143191964285714e-05 1.5 3.143247767857143e-05 0.0 3.1441964285714286e-05 0.0 3.144252232142857e-05 1.5 3.145033482142857e-05 1.5 3.1450892857142853e-05 0.0 3.145982142857143e-05 0.0 3.146037946428571e-05 1.5 3.146819196428571e-05 1.5 3.1468749999999996e-05 0.0 3.147767857142857e-05 0.0 3.1478236607142854e-05 1.5 3.1486049107142855e-05 1.5 3.148660714285714e-05 0.0 3.149553571428571e-05 0.0 3.1496093749999996e-05 1.5 3.150390625e-05 1.5 3.150446428571428e-05 0.0 3.1513392857142855e-05 0.0 3.151395089285714e-05 1.5 3.152176339285714e-05 1.5 3.152232142857143e-05 0.0 3.153125e-05 0.0 3.153180803571428e-05 1.5 3.153962053571428e-05 1.5 3.154017857142857e-05 0.0 3.154910714285714e-05 0.0 3.154966517857142e-05 1.5 3.1557477678571424e-05 1.5 3.1558035714285714e-05 0.0 3.156696428571428e-05 0.0 3.156752232142857e-05 1.5 3.1575334821428566e-05 1.5 3.1575892857142857e-05 0.0 3.1584821428571424e-05 0.0 3.1585379464285714e-05 1.5 3.159319196428571e-05 1.5 3.159375e-05 0.0 3.160267857142857e-05 0.0 3.160323660714286e-05 1.5 3.161104910714286e-05 1.5 3.161160714285714e-05 0.0 3.162053571428571e-05 0.0 3.162109375e-05 1.5 3.162890625e-05 1.5 3.1629464285714283e-05 0.0 3.163839285714286e-05 0.0 3.163895089285714e-05 1.5 3.164676339285714e-05 1.5 3.1647321428571426e-05 0.0 3.165625e-05 0.0 3.1656808035714284e-05 1.5 3.1664620535714285e-05 1.5 3.166517857142857e-05 0.0 3.167410714285714e-05 0.0 3.1674665178571426e-05 1.5 3.168247767857143e-05 1.5 3.168303571428571e-05 0.0 3.1691964285714285e-05 0.0 3.169252232142857e-05 1.5 3.170033482142857e-05 1.5 3.170089285714285e-05 0.0 3.170982142857143e-05 0.0 3.171037946428571e-05 1.5 3.171819196428571e-05 1.5 3.1718749999999995e-05 0.0 3.172767857142857e-05 0.0 3.172823660714285e-05 1.5 3.1736049107142854e-05 1.5 3.173660714285714e-05 0.0 3.174553571428571e-05 0.0 3.1746093749999995e-05 1.5 3.1753906249999996e-05 1.5 3.1754464285714287e-05 0.0 3.1763392857142854e-05 0.0 3.176395089285714e-05 1.5 3.177176339285714e-05 1.5 3.177232142857143e-05 0.0 3.178125e-05 0.0 3.178180803571429e-05 1.5 3.178962053571428e-05 1.5 3.179017857142857e-05 0.0 3.179910714285714e-05 0.0 3.179966517857143e-05 1.5 3.180747767857142e-05 1.5 3.1808035714285713e-05 0.0 3.181696428571428e-05 0.0 3.181752232142857e-05 1.5 3.182533482142857e-05 1.5 3.1825892857142856e-05 0.0 3.1834821428571424e-05 0.0 3.1835379464285714e-05 1.5 3.1843191964285715e-05 1.5 3.184375e-05 0.0 3.1852678571428566e-05 0.0 3.1853236607142856e-05 1.5 3.186104910714286e-05 1.5 3.186160714285714e-05 0.0 3.1870535714285715e-05 0.0 3.187109375e-05 1.5 3.187890625e-05 1.5 3.187946428571428e-05 0.0 3.188839285714286e-05 0.0 3.188895089285714e-05 1.5 3.189676339285714e-05 1.5 3.1897321428571425e-05 0.0 3.190625e-05 0.0 3.190680803571428e-05 1.5 3.1914620535714284e-05 1.5 3.191517857142857e-05 0.0 3.192410714285714e-05 0.0 3.1924665178571425e-05 1.5 3.1932477678571426e-05 1.5 3.193303571428571e-05 0.0 3.1941964285714284e-05 0.0 3.194252232142857e-05 1.5 3.195033482142857e-05 1.5 3.195089285714285e-05 0.0 3.195982142857143e-05 0.0 3.196037946428571e-05 1.5 3.196819196428571e-05 1.5 3.1968749999999994e-05 0.0 3.197767857142857e-05 0.0 3.197823660714285e-05 1.5 3.198604910714285e-05 1.5 3.1986607142857144e-05 0.0 3.199553571428571e-05 0.0 3.1996093749999995e-05 1.5 3.2003906249999996e-05 1.5 3.2004464285714286e-05 0.0 3.2013392857142854e-05 0.0 3.2013950892857144e-05 1.5 3.202176339285714e-05 1.5 3.202232142857143e-05 0.0 3.2031249999999996e-05 0.0 3.2031808035714286e-05 1.5 3.203962053571428e-05 1.5 3.204017857142857e-05 0.0 3.204910714285714e-05 0.0 3.204966517857143e-05 1.5 3.205747767857143e-05 1.5 3.205803571428571e-05 0.0 3.206696428571428e-05 0.0 3.206752232142857e-05 1.5 3.207533482142857e-05 1.5 3.2075892857142855e-05 0.0 3.208482142857142e-05 0.0 3.208537946428571e-05 1.5 3.2093191964285714e-05 1.5 3.209375e-05 0.0 )"}
C {devices/vsource.sym} 640 -1610 0 0 {name=vpwm_cosine_25 spice_ignore=true hide_texts=true value="dc 0 pwl(0.0 1.5 5.022321428571428e-09 1.5 5.580357142857142e-09 0.0 1.2276785714285713e-08 0.0 1.2834821428571427e-08 1.5 2.2879464285714283e-08 1.5 2.3437499999999997e-08 0.0 3.013392857142857e-08 0.0 3.069196428571428e-08 1.5 4.073660714285714e-08 1.5 4.129464285714285e-08 0.0 4.799107142857142e-08 0.0 4.854910714285714e-08 1.5 5.8593749999999995e-08 1.5 5.915178571428571e-08 0.0 6.584821428571428e-08 0.0 6.640625e-08 1.5 7.645089285714285e-08 1.5 7.700892857142857e-08 0.0 8.370535714285714e-08 0.0 8.426339285714285e-08 1.5 9.430803571428571e-08 1.5 9.486607142857142e-08 0.0 1.015625e-07 0.0 1.021205357142857e-07 1.5 1.1216517857142857e-07 1.5 1.1272321428571428e-07 0.0 1.1941964285714286e-07 0.0 1.1997767857142856e-07 1.5 1.3002232142857143e-07 1.5 1.3058035714285713e-07 0.0 1.372767857142857e-07 0.0 1.378348214285714e-07 1.5 1.4787946428571428e-07 1.5 1.4843749999999998e-07 0.0 1.5513392857142856e-07 0.0 1.5569196428571426e-07 1.5 1.6573660714285714e-07 1.5 1.6629464285714283e-07 0.0 1.7299107142857142e-07 0.0 1.7354910714285714e-07 1.5 1.8359375e-07 1.5 1.8415178571428571e-07 0.0 1.9084821428571427e-07 0.0 1.9140625e-07 1.5 2.0145089285714284e-07 1.5 2.0200892857142857e-07 0.0 2.0870535714285712e-07 0.0 2.0926339285714285e-07 1.5 2.193080357142857e-07 1.5 2.1986607142857142e-07 0.0 2.2656249999999997e-07 0.0 2.271205357142857e-07 1.5 2.3716517857142855e-07 1.5 2.3772321428571427e-07 0.0 2.4441964285714285e-07 0.0 2.4497767857142855e-07 1.5 2.550223214285714e-07 1.5 2.555803571428571e-07 0.0 2.622767857142857e-07 0.0 2.628348214285714e-07 1.5 2.728794642857143e-07 1.5 2.734375e-07 0.0 2.8013392857142856e-07 0.0 2.8069196428571426e-07 1.5 2.9073660714285713e-07 1.5 2.9129464285714283e-07 0.0 2.979910714285714e-07 0.0 2.985491071428571e-07 1.5 3.0859375e-07 1.5 3.091517857142857e-07 0.0 3.1584821428571426e-07 0.0 3.1640624999999996e-07 1.5 3.2645089285714284e-07 1.5 3.2700892857142853e-07 0.0 3.337053571428571e-07 0.0 3.342633928571428e-07 1.5 3.443080357142857e-07 1.5 3.448660714285714e-07 0.0 3.5156249999999997e-07 0.0 3.5212053571428567e-07 1.5 3.6216517857142854e-07 1.5 3.6272321428571424e-07 0.0 3.694196428571428e-07 0.0 3.699776785714285e-07 1.5 3.800223214285714e-07 1.5 3.805803571428571e-07 0.0 3.872767857142857e-07 0.0 3.878348214285714e-07 1.5 3.9787946428571425e-07 1.5 3.984375e-07 0.0 4.0513392857142853e-07 0.0 4.056919642857143e-07 1.5 4.157366071428571e-07 1.5 4.1629464285714285e-07 0.0 4.229910714285714e-07 0.0 4.2354910714285713e-07 1.5 4.3359374999999995e-07 1.5 4.341517857142857e-07 0.0 4.4084821428571423e-07 0.0 4.4140625e-07 1.5 4.514508928571428e-07 1.5 4.5200892857142855e-07 0.0 4.587053571428571e-07 0.0 4.5926339285714284e-07 1.5 4.6930803571428566e-07 1.5 4.698660714285714e-07 0.0 4.765625e-07 0.0 4.771205357142856e-07 1.5 4.871651785714285e-07 1.5 4.877232142857142e-07 0.0 4.944196428571428e-07 0.0 4.949776785714285e-07 1.5 5.050223214285714e-07 1.5 5.055803571428571e-07 0.0 5.122767857142856e-07 0.0 5.128348214285713e-07 1.5 5.228794642857142e-07 1.5 5.234374999999999e-07 0.0 5.301339285714285e-07 0.0 5.306919642857143e-07 1.5 5.407366071428571e-07 1.5 5.412946428571429e-07 0.0 5.479910714285713e-07 0.0 5.485491071428572e-07 1.5 5.585937499999999e-07 1.5 5.591517857142857e-07 0.0 5.658482142857142e-07 0.0 5.6640625e-07 1.5 5.764508928571428e-07 1.5 5.770089285714286e-07 0.0 5.83705357142857e-07 0.0 5.842633928571429e-07 1.5 5.943080357142856e-07 1.5 5.948660714285714e-07 0.0 6.015624999999999e-07 0.0 6.021205357142857e-07 1.5 6.121651785714285e-07 1.5 6.127232142857143e-07 0.0 6.194196428571429e-07 0.0 6.199776785714286e-07 1.5 6.300223214285714e-07 1.5 6.305803571428571e-07 0.0 6.372767857142857e-07 0.0 6.378348214285714e-07 1.5 6.478794642857143e-07 1.5 6.484375e-07 0.0 6.551339285714286e-07 0.0 6.556919642857143e-07 1.5 6.657366071428571e-07 1.5 6.662946428571428e-07 0.0 6.729910714285714e-07 0.0 6.735491071428571e-07 1.5 6.8359375e-07 1.5 6.841517857142857e-07 0.0 6.908482142857143e-07 0.0 6.9140625e-07 1.5 7.014508928571428e-07 1.5 7.020089285714285e-07 0.0 7.087053571428571e-07 0.0 7.092633928571428e-07 1.5 7.193080357142857e-07 1.5 7.198660714285714e-07 0.0 7.265625e-07 0.0 7.271205357142857e-07 1.5 7.371651785714286e-07 1.5 7.377232142857142e-07 0.0 7.444196428571428e-07 0.0 7.449776785714285e-07 1.5 7.550223214285714e-07 1.5 7.555803571428571e-07 0.0 7.622767857142857e-07 0.0 7.628348214285714e-07 1.5 7.728794642857143e-07 1.5 7.734375e-07 0.0 7.801339285714285e-07 0.0 7.806919642857142e-07 1.5 7.907366071428571e-07 1.5 7.912946428571428e-07 0.0 7.979910714285714e-07 0.0 7.985491071428571e-07 1.5 8.0859375e-07 1.5 8.091517857142857e-07 0.0 8.158482142857142e-07 0.0 8.164062499999999e-07 1.5 8.264508928571428e-07 1.5 8.270089285714285e-07 0.0 8.337053571428571e-07 0.0 8.342633928571428e-07 1.5 8.443080357142857e-07 1.5 8.448660714285714e-07 0.0 8.515624999999999e-07 0.0 8.521205357142856e-07 1.5 8.621651785714285e-07 1.5 8.627232142857142e-07 0.0 8.694196428571428e-07 0.0 8.699776785714285e-07 1.5 8.800223214285714e-07 1.5 8.805803571428571e-07 0.0 8.872767857142857e-07 0.0 8.878348214285713e-07 1.5 8.978794642857142e-07 1.5 8.984374999999999e-07 0.0 9.051339285714285e-07 0.0 9.056919642857142e-07 1.5 9.157366071428571e-07 1.5 9.162946428571428e-07 0.0 9.229910714285714e-07 0.0 9.235491071428571e-07 1.5 9.335937499999999e-07 1.5 9.341517857142856e-07 0.0 9.408482142857142e-07 0.0 9.414062499999999e-07 1.5 9.514508928571428e-07 1.5 9.520089285714285e-07 0.0 9.58705357142857e-07 0.0 9.592633928571428e-07 1.5 9.693080357142857e-07 1.5 9.698660714285714e-07 0.0 9.765625e-07 0.0 9.771205357142857e-07 1.5 9.871651785714285e-07 1.5 9.877232142857142e-07 0.0 9.944196428571428e-07 0.0 9.949776785714285e-07 1.5 1.0050223214285714e-06 1.5 1.0055803571428571e-06 0.0 1.0122767857142857e-06 0.0 1.0128348214285714e-06 1.5 1.0228794642857142e-06 1.5 1.0234374999999999e-06 0.0 1.0301339285714285e-06 0.0 1.0306919642857142e-06 1.5 1.0407366071428572e-06 1.5 1.0412946428571428e-06 0.0 1.0479910714285714e-06 0.0 1.0485491071428571e-06 1.5 1.05859375e-06 1.5 1.0591517857142856e-06 0.0 1.0658482142857142e-06 0.0 1.0664062499999999e-06 1.5 1.0764508928571429e-06 1.5 1.0770089285714286e-06 0.0 1.0837053571428571e-06 0.0 1.0842633928571428e-06 1.5 1.0943080357142856e-06 1.5 1.0948660714285713e-06 0.0 1.1015624999999999e-06 0.0 1.1021205357142856e-06 1.5 1.1121651785714286e-06 1.5 1.1127232142857143e-06 0.0 1.1194196428571428e-06 0.0 1.1199776785714285e-06 1.5 1.1300223214285713e-06 1.5 1.130580357142857e-06 0.0 1.1372767857142856e-06 0.0 1.1378348214285713e-06 1.5 1.1478794642857143e-06 1.5 1.1484375e-06 0.0 1.1551339285714285e-06 0.0 1.1556919642857142e-06 1.5 1.165736607142857e-06 1.5 1.1662946428571427e-06 0.0 1.1729910714285713e-06 0.0 1.173549107142857e-06 1.5 1.18359375e-06 1.5 1.1841517857142857e-06 0.0 1.1908482142857143e-06 0.0 1.19140625e-06 1.5 1.2014508928571427e-06 1.5 1.2020089285714284e-06 0.0 1.208705357142857e-06 0.0 1.2092633928571427e-06 1.5 1.2193080357142857e-06 1.5 1.2198660714285714e-06 0.0 1.2265625e-06 0.0 1.2271205357142857e-06 1.5 1.2371651785714284e-06 1.5 1.2377232142857141e-06 0.0 1.2444196428571427e-06 0.0 1.2449776785714284e-06 1.5 1.2550223214285714e-06 1.5 1.255580357142857e-06 0.0 1.2622767857142857e-06 0.0 1.2628348214285714e-06 1.5 1.2728794642857141e-06 1.5 1.2734374999999998e-06 0.0 1.2801339285714284e-06 0.0 1.280691964285714e-06 1.5 1.290736607142857e-06 1.5 1.2912946428571428e-06 0.0 1.2979910714285714e-06 0.0 1.298549107142857e-06 1.5 1.3085937499999998e-06 1.5 1.3091517857142855e-06 0.0 1.3158482142857141e-06 0.0 1.3164062499999998e-06 1.5 1.3264508928571428e-06 1.5 1.3270089285714285e-06 0.0 1.333705357142857e-06 0.0 1.3342633928571428e-06 1.5 1.3437499999999998e-06 1.5 1.3443080357142855e-06 0.0 1.3521205357142855e-06 0.0 1.3526785714285714e-06 1.5 1.3616071428571428e-06 1.5 1.3621651785714285e-06 0.0 1.3699776785714285e-06 0.0 1.3705357142857142e-06 1.5 1.3794642857142855e-06 1.5 1.3800223214285712e-06 0.0 1.3878348214285714e-06 0.0 1.3883928571428571e-06 1.5 1.3973214285714285e-06 1.5 1.3978794642857142e-06 0.0 1.4056919642857142e-06 0.0 1.4062499999999999e-06 1.5 1.4151785714285713e-06 1.5 1.415736607142857e-06 0.0 1.4235491071428571e-06 0.0 1.4241071428571428e-06 1.5 1.4330357142857142e-06 1.5 1.43359375e-06 0.0 1.4414062499999999e-06 0.0 1.4419642857142856e-06 1.5 1.450892857142857e-06 1.5 1.4514508928571427e-06 0.0 1.4592633928571428e-06 0.0 1.4598214285714285e-06 1.5 1.46875e-06 1.5 1.4693080357142856e-06 0.0 1.4771205357142856e-06 0.0 1.4776785714285713e-06 1.5 1.4866071428571427e-06 1.5 1.4871651785714286e-06 0.0 1.4949776785714285e-06 0.0 1.4955357142857142e-06 1.5 1.5044642857142856e-06 1.5 1.5050223214285713e-06 0.0 1.5128348214285713e-06 0.0 1.513392857142857e-06 1.5 1.5223214285714284e-06 1.5 1.5228794642857143e-06 0.0 1.5306919642857143e-06 0.0 1.53125e-06 1.5 1.5401785714285713e-06 1.5 1.540736607142857e-06 0.0 1.548549107142857e-06 0.0 1.5491071428571427e-06 1.5 1.558035714285714e-06 1.5 1.55859375e-06 0.0 1.56640625e-06 0.0 1.5669642857142857e-06 1.5 1.575892857142857e-06 1.5 1.5764508928571427e-06 0.0 1.5842633928571427e-06 0.0 1.5848214285714284e-06 1.5 1.59375e-06 1.5 1.5943080357142857e-06 0.0 1.6021205357142857e-06 0.0 1.6026785714285714e-06 1.5 1.6116071428571427e-06 1.5 1.6121651785714284e-06 0.0 1.6199776785714284e-06 0.0 1.6205357142857141e-06 1.5 1.6294642857142857e-06 1.5 1.6300223214285714e-06 0.0 1.6378348214285714e-06 0.0 1.638392857142857e-06 1.5 1.6473214285714284e-06 1.5 1.6478794642857141e-06 0.0 1.6556919642857141e-06 0.0 1.6562499999999998e-06 1.5 1.6651785714285714e-06 1.5 1.665736607142857e-06 0.0 1.673549107142857e-06 0.0 1.6741071428571428e-06 1.5 1.6830357142857141e-06 1.5 1.6835937499999998e-06 0.0 1.6914062499999998e-06 0.0 1.6919642857142855e-06 1.5 1.700892857142857e-06 1.5 1.7014508928571428e-06 0.0 1.7092633928571428e-06 0.0 1.7098214285714285e-06 1.5 1.7187499999999998e-06 1.5 1.7193080357142855e-06 0.0 1.7271205357142855e-06 0.0 1.7276785714285712e-06 1.5 1.7366071428571428e-06 1.5 1.7371651785714285e-06 0.0 1.7449776785714285e-06 0.0 1.7455357142857142e-06 1.5 1.7544642857142856e-06 1.5 1.7550223214285713e-06 0.0 1.7628348214285712e-06 0.0 1.763392857142857e-06 1.5 1.7723214285714285e-06 1.5 1.7728794642857142e-06 0.0 1.7806919642857142e-06 0.0 1.7812499999999999e-06 1.5 1.7901785714285713e-06 1.5 1.790736607142857e-06 0.0 1.798549107142857e-06 0.0 1.7991071428571426e-06 1.5 1.8080357142857142e-06 1.5 1.80859375e-06 0.0 1.8164062499999999e-06 0.0 1.8169642857142856e-06 1.5 1.825892857142857e-06 1.5 1.8264508928571427e-06 0.0 1.8342633928571426e-06 0.0 1.8348214285714283e-06 1.5 1.84375e-06 1.5 1.8443080357142856e-06 0.0 1.8521205357142856e-06 0.0 1.8526785714285713e-06 1.5 1.8616071428571427e-06 1.5 1.8621651785714284e-06 0.0 1.8699776785714283e-06 0.0 1.8705357142857143e-06 1.5 1.8794642857142856e-06 1.5 1.8800223214285713e-06 0.0 1.8878348214285713e-06 0.0 1.888392857142857e-06 1.5 1.8973214285714284e-06 1.5 1.897879464285714e-06 0.0 1.905691964285714e-06 0.0 1.90625e-06 1.5 1.9151785714285713e-06 1.5 1.915736607142857e-06 0.0 1.923549107142857e-06 0.0 1.924107142857143e-06 1.5 1.933035714285714e-06 1.5 1.93359375e-06 0.0 1.9414062499999998e-06 0.0 1.9419642857142857e-06 1.5 1.950892857142857e-06 1.5 1.9514508928571427e-06 0.0 1.959263392857143e-06 0.0 1.9598214285714284e-06 1.5 1.96875e-06 1.5 1.9693080357142855e-06 0.0 1.9771205357142857e-06 0.0 1.977678571428571e-06 1.5 1.9866071428571427e-06 1.5 1.9871651785714282e-06 0.0 1.9949776785714284e-06 0.0 1.9955357142857143e-06 1.5 2.0044642857142855e-06 1.5 2.0050223214285714e-06 0.0 2.013392857142857e-06 0.0 2.0139508928571426e-06 1.5 2.0217633928571428e-06 1.5 2.0223214285714282e-06 0.0 2.03125e-06 0.0 2.0318080357142857e-06 1.5 2.0396205357142855e-06 1.5 2.0401785714285714e-06 0.0 2.0491071428571426e-06 0.0 2.0496651785714285e-06 1.5 2.0574776785714282e-06 1.5 2.058035714285714e-06 0.0 2.0669642857142857e-06 0.0 2.0675223214285712e-06 1.5 2.0753348214285714e-06 1.5 2.075892857142857e-06 0.0 2.0848214285714285e-06 0.0 2.085379464285714e-06 1.5 2.093191964285714e-06 1.5 2.0937499999999996e-06 0.0 2.1026785714285712e-06 0.0 2.103236607142857e-06 1.5 2.111049107142857e-06 1.5 2.111607142857143e-06 0.0 2.120535714285714e-06 0.0 2.12109375e-06 1.5 2.1289062499999997e-06 1.5 2.1294642857142856e-06 0.0 2.138392857142857e-06 0.0 2.1389508928571426e-06 1.5 2.146763392857143e-06 1.5 2.1473214285714283e-06 0.0 2.15625e-06 0.0 2.1568080357142854e-06 1.5 2.1646205357142856e-06 1.5 2.1651785714285715e-06 0.0 2.1741071428571426e-06 0.0 2.1746651785714286e-06 1.5 2.1824776785714283e-06 1.5 2.1830357142857142e-06 0.0 2.1919642857142854e-06 0.0 2.1925223214285713e-06 1.5 2.200334821428571e-06 1.5 2.200892857142857e-06 0.0 2.2098214285714286e-06 0.0 2.210379464285714e-06 1.5 2.2181919642857142e-06 1.5 2.2187499999999997e-06 0.0 2.2276785714285713e-06 0.0 2.228236607142857e-06 1.5 2.236049107142857e-06 1.5 2.236607142857143e-06 0.0 2.245535714285714e-06 0.0 2.24609375e-06 1.5 2.2539062499999997e-06 1.5 2.2544642857142856e-06 0.0 2.263392857142857e-06 0.0 2.2639508928571427e-06 1.5 2.271763392857143e-06 1.5 2.2723214285714284e-06 0.0 2.28125e-06 0.0 2.2818080357142855e-06 1.5 2.2896205357142856e-06 1.5 2.290178571428571e-06 0.0 2.2991071428571427e-06 0.0 2.299665178571428e-06 1.5 2.3074776785714284e-06 1.5 2.3080357142857143e-06 0.0 2.3169642857142855e-06 0.0 2.3175223214285714e-06 1.5 2.325334821428571e-06 1.5 2.325892857142857e-06 0.0 2.334821428571428e-06 0.0 2.335379464285714e-06 1.5 2.3431919642857143e-06 1.5 2.34375e-06 0.0 2.3526785714285714e-06 0.0 2.353236607142857e-06 1.5 2.361049107142857e-06 1.5 2.3616071428571425e-06 0.0 2.370535714285714e-06 0.0 2.37109375e-06 1.5 2.37890625e-06 1.5 2.3794642857142857e-06 0.0 2.388392857142857e-06 0.0 2.3889508928571428e-06 1.5 2.3967633928571425e-06 1.5 2.3973214285714285e-06 0.0 2.4062499999999996e-06 0.0 2.4068080357142855e-06 1.5 2.4146205357142857e-06 1.5 2.415178571428571e-06 0.0 2.424107142857143e-06 0.0 2.4246651785714283e-06 1.5 2.4324776785714285e-06 1.5 2.433035714285714e-06 0.0 2.4419642857142855e-06 0.0 2.4425223214285714e-06 1.5 2.4503348214285712e-06 1.5 2.450892857142857e-06 0.0 2.4598214285714283e-06 0.0 2.460379464285714e-06 1.5 2.468191964285714e-06 1.5 2.46875e-06 0.0 2.4776785714285715e-06 0.0 2.478236607142857e-06 1.5 2.486049107142857e-06 1.5 2.4866071428571426e-06 0.0 2.495535714285714e-06 0.0 2.4960937499999997e-06 1.5 2.50390625e-06 1.5 2.5044642857142854e-06 0.0 2.513392857142857e-06 0.0 2.513950892857143e-06 1.5 2.5217633928571426e-06 1.5 2.5223214285714285e-06 0.0 2.5312499999999997e-06 0.0 2.5318080357142856e-06 1.5 2.5396205357142854e-06 1.5 2.5401785714285713e-06 0.0 2.549107142857143e-06 0.0 2.5496651785714283e-06 1.5 2.5574776785714285e-06 1.5 2.558035714285714e-06 0.0 2.5669642857142856e-06 0.0 2.567522321428571e-06 1.5 2.5753348214285713e-06 1.5 2.5758928571428568e-06 0.0 2.5848214285714284e-06 0.0 2.5853794642857143e-06 1.5 2.593191964285714e-06 1.5 2.59375e-06 0.0 2.602678571428571e-06 0.0 2.603236607142857e-06 1.5 2.6110491071428568e-06 1.5 2.6116071428571427e-06 0.0 2.6205357142857143e-06 0.0 2.6210937499999998e-06 1.5 2.62890625e-06 1.5 2.6294642857142854e-06 0.0 2.638392857142857e-06 0.0 2.6389508928571425e-06 1.5 2.6467633928571427e-06 1.5 2.647321428571428e-06 0.0 2.6562499999999998e-06 0.0 2.6568080357142857e-06 1.5 2.6646205357142854e-06 1.5 2.6651785714285714e-06 0.0 2.6741071428571425e-06 0.0 2.6746651785714284e-06 1.5 2.6819196428571427e-06 1.5 2.682477678571428e-06 0.0 2.692522321428571e-06 0.0 2.693080357142857e-06 1.5 2.6997767857142855e-06 1.5 2.7003348214285714e-06 0.0 2.710379464285714e-06 0.0 2.7109375e-06 1.5 2.717633928571428e-06 1.5 2.718191964285714e-06 0.0 2.728236607142857e-06 0.0 2.7287946428571426e-06 1.5 2.7354910714285714e-06 1.5 2.736049107142857e-06 0.0 2.74609375e-06 0.0 2.7466517857142853e-06 1.5 2.753348214285714e-06 1.5 2.7539062499999996e-06 0.0 2.7639508928571426e-06 0.0 2.7645089285714285e-06 1.5 2.771205357142857e-06 1.5 2.7717633928571428e-06 0.0 2.7818080357142853e-06 0.0 2.7823660714285712e-06 1.5 2.7890624999999996e-06 1.5 2.7896205357142855e-06 0.0 2.7996651785714285e-06 0.0 2.800223214285714e-06 1.5 2.8069196428571428e-06 1.5 2.8074776785714283e-06 0.0 2.8175223214285712e-06 0.0 2.8180803571428567e-06 1.5 2.8247767857142855e-06 1.5 2.8253348214285714e-06 0.0 2.835379464285714e-06 0.0 2.8359375e-06 1.5 2.8426339285714283e-06 1.5 2.843191964285714e-06 0.0 2.8532366071428567e-06 0.0 2.8537946428571426e-06 1.5 2.860491071428571e-06 1.5 2.861049107142857e-06 0.0 2.87109375e-06 0.0 2.8716517857142854e-06 1.5 2.878348214285714e-06 1.5 2.8789062499999997e-06 0.0 2.8889508928571427e-06 0.0 2.8895089285714286e-06 1.5 2.896205357142857e-06 1.5 2.896763392857143e-06 0.0 2.9068080357142854e-06 0.0 2.9073660714285713e-06 1.5 2.9140624999999997e-06 1.5 2.9146205357142856e-06 0.0 2.9246651785714286e-06 0.0 2.925223214285714e-06 1.5 2.931919642857143e-06 1.5 2.9324776785714283e-06 0.0 2.9425223214285713e-06 0.0 2.943080357142857e-06 1.5 2.9497767857142856e-06 1.5 2.950334821428571e-06 0.0 2.960379464285714e-06 0.0 2.9609375e-06 1.5 2.9676339285714283e-06 1.5 2.9681919642857143e-06 0.0 2.978236607142857e-06 0.0 2.9787946428571427e-06 1.5 2.985491071428571e-06 1.5 2.986049107142857e-06 0.0 2.99609375e-06 0.0 2.9966517857142855e-06 1.5 3.0033482142857143e-06 1.5 3.0039062499999997e-06 0.0 3.0139508928571427e-06 0.0 3.0145089285714282e-06 1.5 3.021205357142857e-06 1.5 3.0217633928571425e-06 0.0 3.0318080357142855e-06 0.0 3.0323660714285714e-06 1.5 3.0390624999999998e-06 1.5 3.0396205357142857e-06 0.0 3.0496651785714282e-06 0.0 3.050223214285714e-06 1.5 3.0569196428571425e-06 1.5 3.0574776785714284e-06 0.0 3.0675223214285714e-06 0.0 3.068080357142857e-06 1.5 3.0747767857142857e-06 1.5 3.075334821428571e-06 0.0 3.085379464285714e-06 0.0 3.0859374999999996e-06 1.5 3.0926339285714284e-06 1.5 3.093191964285714e-06 0.0 3.103236607142857e-06 0.0 3.103794642857143e-06 1.5 3.110491071428571e-06 1.5 3.111049107142857e-06 0.0 3.1210937499999996e-06 0.0 3.1216517857142855e-06 1.5 3.128348214285714e-06 1.5 3.12890625e-06 0.0 3.138950892857143e-06 0.0 3.1395089285714283e-06 1.5 3.146205357142857e-06 1.5 3.1467633928571426e-06 0.0 3.1568080357142855e-06 0.0 3.157366071428571e-06 1.5 3.1640625e-06 1.5 3.1646205357142853e-06 0.0 3.1746651785714283e-06 0.0 3.175223214285714e-06 1.5 3.1819196428571426e-06 1.5 3.1824776785714285e-06 0.0 3.192522321428571e-06 0.0 3.193080357142857e-06 1.5 3.1997767857142853e-06 1.5 3.2003348214285712e-06 0.0 3.210379464285714e-06 0.0 3.2109374999999997e-06 1.5 3.2176339285714285e-06 1.5 3.218191964285714e-06 0.0 3.228236607142857e-06 0.0 3.2287946428571424e-06 1.5 3.2354910714285712e-06 1.5 3.2360491071428567e-06 0.0 3.2460937499999997e-06 0.0 3.2466517857142856e-06 1.5 3.253348214285714e-06 1.5 3.25390625e-06 0.0 3.2639508928571425e-06 0.0 3.2645089285714284e-06 1.5 3.2712053571428567e-06 1.5 3.2717633928571426e-06 0.0 3.2818080357142856e-06 0.0 3.282366071428571e-06 1.5 3.2890625e-06 1.5 3.2896205357142854e-06 0.0 3.2996651785714284e-06 0.0 3.300223214285714e-06 1.5 3.3069196428571426e-06 1.5 3.307477678571428e-06 0.0 3.317522321428571e-06 0.0 3.318080357142857e-06 1.5 3.3247767857142854e-06 1.5 3.3253348214285713e-06 0.0 3.335379464285714e-06 0.0 3.3359374999999998e-06 1.5 3.342633928571428e-06 1.5 3.343191964285714e-06 0.0 3.353236607142857e-06 0.0 3.3537946428571425e-06 1.5 3.3604910714285713e-06 1.5 3.361049107142857e-06 0.0 3.3710937499999998e-06 0.0 3.3716517857142853e-06 1.5 3.378348214285714e-06 1.5 3.37890625e-06 0.0 3.3889508928571425e-06 0.0 3.3895089285714284e-06 1.5 3.396205357142857e-06 1.5 3.3967633928571427e-06 0.0 3.4068080357142853e-06 0.0 3.407366071428571e-06 1.5 3.4140624999999996e-06 1.5 3.4146205357142855e-06 0.0 3.4246651785714284e-06 0.0 3.425223214285714e-06 1.5 3.4319196428571427e-06 1.5 3.432477678571428e-06 0.0 3.442522321428571e-06 0.0 3.443080357142857e-06 1.5 3.4497767857142855e-06 1.5 3.4503348214285714e-06 0.0 3.460379464285714e-06 0.0 3.4609375e-06 1.5 3.4676339285714282e-06 1.5 3.468191964285714e-06 0.0 3.4782366071428567e-06 0.0 3.4787946428571426e-06 1.5 3.4854910714285714e-06 1.5 3.486049107142857e-06 0.0 3.49609375e-06 0.0 3.4966517857142853e-06 1.5 3.503348214285714e-06 1.5 3.5039062499999996e-06 0.0 3.5139508928571426e-06 0.0 3.5145089285714285e-06 1.5 3.521205357142857e-06 1.5 3.521763392857143e-06 0.0 3.5318080357142853e-06 0.0 3.5323660714285713e-06 1.5 3.5390624999999996e-06 1.5 3.5396205357142855e-06 0.0 3.5496651785714285e-06 0.0 3.550223214285714e-06 1.5 3.556919642857143e-06 1.5 3.5574776785714283e-06 0.0 3.5675223214285713e-06 0.0 3.5680803571428567e-06 1.5 3.5747767857142855e-06 1.5 3.575334821428571e-06 0.0 3.585379464285714e-06 0.0 3.5859375e-06 1.5 3.5926339285714283e-06 1.5 3.593191964285714e-06 0.0 3.6032366071428568e-06 0.0 3.6037946428571427e-06 1.5 3.610491071428571e-06 1.5 3.611049107142857e-06 0.0 3.62109375e-06 0.0 3.6216517857142854e-06 1.5 3.628348214285714e-06 1.5 3.6289062499999997e-06 0.0 3.6389508928571427e-06 0.0 3.639508928571428e-06 1.5 3.646205357142857e-06 1.5 3.6467633928571424e-06 0.0 3.6568080357142854e-06 0.0 3.6573660714285713e-06 1.5 3.6640624999999997e-06 1.5 3.6646205357142856e-06 0.0 3.674665178571428e-06 0.0 3.675223214285714e-06 1.5 3.6819196428571424e-06 1.5 3.6824776785714284e-06 0.0 3.6925223214285713e-06 0.0 3.693080357142857e-06 1.5 3.6997767857142856e-06 1.5 3.700334821428571e-06 0.0 3.710379464285714e-06 0.0 3.7109374999999996e-06 1.5 3.7176339285714284e-06 1.5 3.718191964285714e-06 0.0 3.728236607142857e-06 0.0 3.7287946428571427e-06 1.5 3.735491071428571e-06 1.5 3.736049107142857e-06 0.0 3.7460937499999996e-06 0.0 3.7466517857142855e-06 1.5 3.753348214285714e-06 1.5 3.7539062499999998e-06 0.0 3.7639508928571427e-06 0.0 3.7645089285714282e-06 1.5 3.771205357142857e-06 1.5 3.7717633928571425e-06 0.0 3.7818080357142855e-06 0.0 3.782366071428571e-06 1.5 3.7890624999999998e-06 1.5 3.7896205357142853e-06 0.0 3.7996651785714282e-06 0.0 3.800223214285714e-06 1.5 3.8069196428571425e-06 1.5 3.8074776785714284e-06 0.0 3.817522321428571e-06 0.0 3.818080357142857e-06 1.5 3.824776785714285e-06 1.5 3.825334821428571e-06 0.0 3.835379464285714e-06 0.0 3.8359375e-06 1.5 3.8426339285714284e-06 1.5 3.843191964285714e-06 0.0 3.8532366071428565e-06 0.0 3.853794642857142e-06 1.5 3.860491071428571e-06 1.5 3.861049107142857e-06 0.0 3.87109375e-06 0.0 3.8716517857142856e-06 1.5 3.878348214285714e-06 1.5 3.87890625e-06 0.0 3.888950892857143e-06 0.0 3.889508928571428e-06 1.5 3.896205357142857e-06 1.5 3.896763392857142e-06 0.0 3.906808035714285e-06 0.0 3.907366071428571e-06 1.5 3.9140624999999994e-06 1.5 3.914620535714285e-06 0.0 3.924665178571428e-06 0.0 3.925223214285714e-06 1.5 3.931919642857143e-06 1.5 3.9324776785714285e-06 0.0 3.9425223214285715e-06 0.0 3.9430803571428565e-06 1.5 3.949776785714286e-06 1.5 3.950334821428571e-06 0.0 3.960379464285714e-06 0.0 3.9609375e-06 1.5 3.967633928571428e-06 1.5 3.968191964285714e-06 0.0 3.978236607142857e-06 0.0 3.978794642857143e-06 1.5 3.985491071428571e-06 1.5 3.986049107142857e-06 0.0 3.996093749999999e-06 0.0 3.996651785714285e-06 1.5 4.003348214285714e-06 1.5 4.0039062499999995e-06 0.0 4.0139508928571425e-06 0.0 4.014508928571428e-06 1.5 4.021205357142857e-06 1.5 4.021763392857143e-06 0.0 4.031808035714286e-06 0.0 4.0323660714285716e-06 1.5 4.0390625e-06 1.5 4.039620535714286e-06 0.0 4.049665178571428e-06 0.0 4.050223214285714e-06 1.5 4.056919642857142e-06 1.5 4.057477678571428e-06 0.0 4.067522321428571e-06 0.0 4.068080357142857e-06 1.5 4.074776785714285e-06 1.5 4.075334821428571e-06 0.0 4.085379464285714e-06 0.0 4.085937499999999e-06 1.5 4.092633928571429e-06 1.5 4.093191964285714e-06 0.0 4.103236607142857e-06 0.0 4.1037946428571425e-06 1.5 4.110491071428571e-06 1.5 4.111049107142857e-06 0.0 4.12109375e-06 0.0 4.121651785714286e-06 1.5 4.128348214285714e-06 1.5 4.12890625e-06 0.0 4.138950892857143e-06 0.0 4.139508928571428e-06 1.5 4.146205357142857e-06 1.5 4.146763392857142e-06 0.0 4.156808035714285e-06 0.0 4.157366071428571e-06 1.5 4.1640624999999996e-06 1.5 4.1646205357142855e-06 0.0 4.1746651785714285e-06 0.0 4.175223214285714e-06 1.5 4.181919642857143e-06 1.5 4.182477678571429e-06 0.0 4.192522321428571e-06 0.0 4.193080357142857e-06 1.5 4.199776785714285e-06 1.5 4.200334821428571e-06 0.0 4.210379464285714e-06 0.0 4.2109375e-06 1.5 4.217633928571428e-06 1.5 4.218191964285714e-06 0.0 4.228236607142857e-06 0.0 4.228794642857142e-06 1.5 4.235491071428571e-06 1.5 4.2360491071428565e-06 0.0 4.2460937499999994e-06 0.0 4.246651785714285e-06 1.5 4.253348214285714e-06 1.5 4.25390625e-06 0.0 4.263950892857143e-06 0.0 4.2645089285714285e-06 1.5 4.271205357142857e-06 1.5 4.271763392857143e-06 0.0 4.281808035714286e-06 0.0 4.282366071428571e-06 1.5 4.2890625e-06 1.5 4.289620535714285e-06 0.0 4.299665178571428e-06 0.0 4.300223214285714e-06 1.5 4.306919642857142e-06 1.5 4.307477678571428e-06 0.0 4.317522321428571e-06 0.0 4.318080357142857e-06 1.5 4.3247767857142856e-06 1.5 4.3253348214285715e-06 0.0 4.335379464285714e-06 0.0 4.3359374999999995e-06 1.5 4.342633928571428e-06 1.5 4.343191964285714e-06 0.0 4.353236607142857e-06 0.0 4.353794642857143e-06 1.5 4.360491071428571e-06 1.5 4.361049107142857e-06 0.0 4.37109375e-06 0.0 4.371651785714285e-06 1.5 4.378348214285714e-06 1.5 4.378906249999999e-06 0.0 4.388950892857142e-06 0.0 4.389508928571428e-06 1.5 4.3962053571428565e-06 1.5 4.3967633928571425e-06 0.0 4.4068080357142854e-06 0.0 4.407366071428571e-06 1.5 4.4140625e-06 1.5 4.414620535714286e-06 0.0 4.424665178571429e-06 0.0 4.425223214285714e-06 1.5 4.431919642857143e-06 1.5 4.432477678571428e-06 0.0 4.442522321428571e-06 0.0 4.443080357142857e-06 1.5 4.449776785714285e-06 1.5 4.450334821428571e-06 0.0 4.460379464285714e-06 0.0 4.4609375e-06 1.5 4.467633928571428e-06 1.5 4.468191964285714e-06 0.0 4.4782366071428564e-06 0.0 4.478794642857142e-06 1.5 4.485491071428571e-06 1.5 4.486049107142857e-06 0.0 4.49609375e-06 0.0 4.4966517857142855e-06 1.5 4.503348214285714e-06 1.5 4.50390625e-06 0.0 4.513950892857143e-06 0.0 4.514508928571428e-06 1.5 4.521205357142857e-06 1.5 4.521763392857143e-06 0.0 4.531808035714285e-06 0.0 4.532366071428571e-06 1.5 4.539062499999999e-06 1.5 4.539620535714285e-06 0.0 4.549665178571428e-06 0.0 4.550223214285714e-06 1.5 4.5569196428571425e-06 1.5 4.5574776785714284e-06 0.0 4.5675223214285714e-06 0.0 4.5680803571428565e-06 1.5 4.574776785714286e-06 1.5 4.575334821428571e-06 0.0 4.585379464285714e-06 0.0 4.5859375e-06 1.5 4.592633928571428e-06 1.5 4.593191964285714e-06 0.0 4.603236607142857e-06 0.0 4.603794642857143e-06 1.5 4.610491071428571e-06 1.5 4.611049107142857e-06 0.0 4.621093749999999e-06 0.0 4.621651785714285e-06 1.5 4.628348214285714e-06 1.5 4.6289062499999994e-06 0.0 4.638950892857142e-06 0.0 4.639508928571428e-06 1.5 4.646205357142857e-06 1.5 4.646763392857143e-06 0.0 4.656808035714286e-06 0.0 4.6573660714285715e-06 1.5 4.6640625e-06 1.5 4.664620535714286e-06 0.0 4.674665178571428e-06 0.0 4.675223214285714e-06 1.5 4.681919642857142e-06 1.5 4.682477678571428e-06 0.0 4.692522321428571e-06 0.0 4.693080357142857e-06 1.5 4.699776785714285e-06 1.5 4.700334821428571e-06 0.0 4.710379464285714e-06 0.0 4.710937499999999e-06 1.5 4.7176339285714285e-06 1.5 4.718191964285714e-06 0.0 4.7282366071428566e-06 0.0 4.7287946428571425e-06 1.5 4.735491071428571e-06 1.5 4.736049107142857e-06 0.0 4.74609375e-06 0.0 4.746651785714286e-06 1.5 4.753348214285714e-06 1.5 4.75390625e-06 0.0 4.763950892857143e-06 0.0 4.764508928571428e-06 1.5 4.771205357142857e-06 1.5 4.771763392857142e-06 0.0 4.781808035714285e-06 0.0 4.782366071428571e-06 1.5 4.7890624999999995e-06 1.5 4.7896205357142854e-06 0.0 4.799665178571428e-06 0.0 4.800223214285714e-06 1.5 4.806919642857143e-06 1.5 4.807477678571429e-06 0.0 4.817522321428571e-06 0.0 4.818080357142857e-06 1.5 4.824776785714285e-06 1.5 4.825334821428571e-06 0.0 4.835379464285714e-06 0.0 4.8359375e-06 1.5 4.842633928571428e-06 1.5 4.843191964285714e-06 0.0 4.853236607142857e-06 0.0 4.853794642857142e-06 1.5 4.860491071428571e-06 1.5 4.861049107142856e-06 0.0 4.871093749999999e-06 0.0 4.871651785714285e-06 1.5 4.878348214285714e-06 1.5 4.87890625e-06 0.0 4.8889508928571426e-06 0.0 4.8895089285714285e-06 1.5 4.896205357142857e-06 1.5 4.896763392857143e-06 0.0 4.906808035714286e-06 0.0 4.907366071428571e-06 1.5 4.9140625e-06 1.5 4.914620535714285e-06 0.0 4.924665178571428e-06 0.0 4.925223214285714e-06 1.5 4.931919642857142e-06 1.5 4.932477678571428e-06 0.0 4.942522321428571e-06 0.0 4.943080357142857e-06 1.5 4.9497767857142855e-06 1.5 4.950334821428571e-06 0.0 4.9603794642857136e-06 0.0 4.9609374999999995e-06 1.5 4.967633928571428e-06 1.5 4.968191964285714e-06 0.0 4.978236607142857e-06 0.0 4.978794642857143e-06 1.5 4.985491071428571e-06 1.5 4.986049107142857e-06 0.0 4.99609375e-06 0.0 4.996651785714285e-06 1.5 5.003348214285714e-06 1.5 5.003906249999999e-06 0.0 5.013950892857142e-06 0.0 5.014508928571428e-06 1.5 5.0212053571428565e-06 1.5 5.021763392857142e-06 0.0 5.031808035714285e-06 0.0 5.032366071428571e-06 1.5 5.0390625e-06 1.5 5.0396205357142856e-06 0.0 5.0496651785714286e-06 0.0 5.050223214285714e-06 1.5 5.056919642857143e-06 1.5 5.057477678571428e-06 0.0 5.067522321428571e-06 0.0 5.068080357142857e-06 1.5 5.074776785714285e-06 1.5 5.075334821428571e-06 0.0 5.085379464285714e-06 0.0 5.0859375e-06 1.5 5.092633928571428e-06 1.5 5.093191964285714e-06 0.0 5.103236607142856e-06 0.0 5.103794642857142e-06 1.5 5.110491071428571e-06 1.5 5.1110491071428566e-06 0.0 5.1210937499999995e-06 0.0 5.1216517857142855e-06 1.5 5.128348214285714e-06 1.5 5.12890625e-06 0.0 5.138950892857143e-06 0.0 5.139508928571429e-06 1.5 5.146205357142857e-06 1.5 5.146763392857143e-06 0.0 5.156808035714285e-06 0.0 5.157366071428571e-06 1.5 5.164062499999999e-06 1.5 5.164620535714285e-06 0.0 5.174665178571428e-06 0.0 5.175223214285714e-06 1.5 5.1819196428571425e-06 1.5 5.182477678571428e-06 0.0 5.192522321428571e-06 0.0 5.1930803571428564e-06 1.5 5.199776785714286e-06 1.5 5.200334821428571e-06 0.0 5.210379464285714e-06 0.0 5.2109375e-06 1.5 5.217633928571428e-06 1.5 5.218191964285714e-06 0.0 5.228236607142857e-06 0.0 5.228794642857143e-06 1.5 5.235491071428571e-06 1.5 5.236049107142857e-06 0.0 5.24609375e-06 0.0 5.246651785714285e-06 1.5 5.253348214285714e-06 1.5 5.253906249999999e-06 0.0 5.263950892857142e-06 0.0 5.264508928571428e-06 1.5 5.271205357142857e-06 1.5 5.2717633928571426e-06 0.0 5.2818080357142855e-06 0.0 5.2823660714285714e-06 1.5 5.2890625e-06 1.5 5.289620535714286e-06 0.0 5.299665178571428e-06 0.0 5.300223214285714e-06 1.5 5.306919642857142e-06 1.5 5.307477678571428e-06 0.0 5.317522321428571e-06 0.0 5.318080357142857e-06 1.5 5.324776785714285e-06 1.5 5.325334821428571e-06 0.0 5.335379464285714e-06 0.0 5.335937499999999e-06 1.5 5.3426339285714285e-06 1.5 5.3431919642857135e-06 0.0 5.3526785714285715e-06 0.0 5.3532366071428565e-06 1.5 5.361049107142857e-06 1.5 5.361607142857143e-06 0.0 5.370535714285714e-06 0.0 5.37109375e-06 1.5 5.37890625e-06 1.5 5.379464285714285e-06 0.0 5.388392857142857e-06 0.0 5.388950892857143e-06 1.5 5.396763392857142e-06 1.5 5.397321428571428e-06 0.0 5.406249999999999e-06 0.0 5.406808035714285e-06 1.5 5.414620535714285e-06 1.5 5.415178571428571e-06 0.0 5.4241071428571424e-06 0.0 5.424665178571428e-06 1.5 5.4324776785714285e-06 1.5 5.433035714285714e-06 0.0 5.441964285714286e-06 0.0 5.442522321428571e-06 1.5 5.450334821428571e-06 1.5 5.450892857142857e-06 0.0 5.459821428571428e-06 0.0 5.460379464285714e-06 1.5 5.468191964285714e-06 1.5 5.46875e-06 0.0 5.477678571428571e-06 0.0 5.478236607142857e-06 1.5 5.486049107142856e-06 1.5 5.486607142857142e-06 0.0 5.495535714285714e-06 0.0 5.496093749999999e-06 1.5 5.5039062499999995e-06 1.5 5.5044642857142854e-06 0.0 5.513392857142857e-06 0.0 5.5139508928571425e-06 1.5 5.521763392857143e-06 1.5 5.522321428571428e-06 0.0 5.53125e-06 0.0 5.531808035714286e-06 1.5 5.539620535714285e-06 1.5 5.540178571428571e-06 0.0 5.549107142857142e-06 0.0 5.549665178571428e-06 1.5 5.557477678571428e-06 1.5 5.558035714285714e-06 0.0 5.566964285714285e-06 0.0 5.567522321428571e-06 1.5 5.575334821428571e-06 1.5 5.5758928571428564e-06 0.0 5.5848214285714284e-06 0.0 5.5853794642857135e-06 1.5 5.593191964285714e-06 1.5 5.59375e-06 0.0 5.602678571428571e-06 0.0 5.603236607142857e-06 1.5 5.611049107142857e-06 1.5 5.611607142857143e-06 0.0 5.620535714285714e-06 0.0 5.62109375e-06 1.5 5.628906249999999e-06 1.5 5.629464285714285e-06 0.0 5.638392857142857e-06 0.0 5.638950892857142e-06 1.5 5.646763392857142e-06 1.5 5.647321428571428e-06 0.0 5.656249999999999e-06 0.0 5.656808035714285e-06 1.5 5.6646205357142855e-06 1.5 5.6651785714285714e-06 0.0 5.674107142857143e-06 0.0 5.6746651785714285e-06 1.5 5.682477678571428e-06 1.5 5.683035714285714e-06 0.0 5.691964285714285e-06 0.0 5.692522321428571e-06 1.5 5.700334821428571e-06 1.5 5.700892857142857e-06 0.0 5.709821428571428e-06 0.0 5.710379464285714e-06 1.5 5.718191964285714e-06 1.5 5.718749999999999e-06 0.0 5.727678571428571e-06 0.0 5.728236607142856e-06 1.5 5.7360491071428565e-06 1.5 5.736607142857142e-06 0.0 5.745535714285714e-06 0.0 5.7460937499999995e-06 1.5 5.75390625e-06 1.5 5.754464285714286e-06 0.0 5.763392857142857e-06 0.0 5.763950892857143e-06 1.5 5.771763392857143e-06 1.5 5.772321428571428e-06 0.0 5.78125e-06 0.0 5.781808035714285e-06 1.5 5.789620535714285e-06 1.5 5.790178571428571e-06 0.0 5.799107142857142e-06 0.0 5.799665178571428e-06 1.5 5.807477678571428e-06 1.5 5.808035714285714e-06 0.0 5.816964285714285e-06 0.0 5.817522321428571e-06 1.5 5.825334821428571e-06 1.5 5.8258928571428566e-06 0.0 5.834821428571428e-06 0.0 5.835379464285714e-06 1.5 5.843191964285714e-06 1.5 5.84375e-06 0.0 5.852678571428571e-06 0.0 5.853236607142857e-06 1.5 5.861049107142857e-06 1.5 5.861607142857142e-06 0.0 5.870535714285714e-06 0.0 5.87109375e-06 1.5 5.878906249999999e-06 1.5 5.879464285714285e-06 0.0 5.888392857142856e-06 0.0 5.888950892857142e-06 1.5 5.8967633928571425e-06 1.5 5.897321428571428e-06 0.0 5.9062499999999996e-06 0.0 5.9068080357142855e-06 1.5 5.914620535714286e-06 1.5 5.915178571428571e-06 0.0 5.924107142857143e-06 0.0 5.924665178571428e-06 1.5 5.932477678571428e-06 1.5 5.933035714285714e-06 0.0 5.941964285714285e-06 0.0 5.942522321428571e-06 1.5 5.950334821428571e-06 1.5 5.950892857142857e-06 0.0 5.959821428571428e-06 0.0 5.960379464285714e-06 1.5 5.9681919642857135e-06 1.5 5.968749999999999e-06 0.0 5.977678571428571e-06 0.0 5.9782366071428565e-06 1.5 5.986049107142857e-06 1.5 5.9866071428571426e-06 0.0 5.995535714285714e-06 0.0 5.99609375e-06 1.5 6.00390625e-06 1.5 6.004464285714285e-06 0.0 6.013392857142857e-06 0.0 6.013950892857143e-06 1.5 6.022321428571428e-06 1.5 6.022879464285714e-06 0.0 6.030691964285714e-06 0.0 6.031249999999999e-06 1.5 6.040178571428571e-06 1.5 6.040736607142856e-06 0.0 6.0485491071428565e-06 0.0 6.049107142857142e-06 1.5 6.0580357142857135e-06 1.5 6.0585937499999995e-06 0.0 6.06640625e-06 0.0 6.0669642857142856e-06 1.5 6.075892857142857e-06 1.5 6.076450892857143e-06 0.0 6.084263392857143e-06 0.0 6.084821428571428e-06 1.5 6.09375e-06 1.5 6.094308035714285e-06 0.0 6.102120535714285e-06 0.0 6.102678571428571e-06 1.5 6.111607142857142e-06 1.5 6.112165178571428e-06 0.0 6.119977678571428e-06 0.0 6.120535714285714e-06 1.5 6.129464285714285e-06 1.5 6.130022321428571e-06 0.0 6.137834821428571e-06 0.0 6.1383928571428565e-06 1.5 6.1473214285714286e-06 1.5 6.147879464285714e-06 0.0 6.155691964285714e-06 0.0 6.15625e-06 1.5 6.165178571428571e-06 1.5 6.165736607142857e-06 0.0 6.173549107142857e-06 0.0 6.174107142857142e-06 1.5 6.183035714285714e-06 1.5 6.18359375e-06 0.0 6.191406249999999e-06 0.0 6.191964285714285e-06 1.5 6.200892857142856e-06 1.5 6.201450892857142e-06 0.0 6.2092633928571425e-06 0.0 6.209821428571428e-06 1.5 6.2187499999999995e-06 1.5 6.2193080357142854e-06 0.0 6.227120535714286e-06 0.0 6.227678571428571e-06 1.5 6.236607142857143e-06 1.5 6.237165178571428e-06 0.0 6.244977678571428e-06 0.0 6.245535714285714e-06 1.5 6.254464285714285e-06 1.5 6.255022321428571e-06 0.0 6.262834821428571e-06 0.0 6.263392857142857e-06 1.5 6.272321428571428e-06 1.5 6.272879464285714e-06 0.0 6.2806919642857135e-06 0.0 6.281249999999999e-06 1.5 6.290178571428571e-06 1.5 6.2907366071428564e-06 0.0 6.298549107142857e-06 0.0 6.2991071428571425e-06 1.5 6.308035714285714e-06 1.5 6.30859375e-06 0.0 6.31640625e-06 0.0 6.316964285714285e-06 1.5 6.325892857142857e-06 1.5 6.326450892857143e-06 0.0 6.334263392857142e-06 0.0 6.334821428571428e-06 1.5 6.343749999999999e-06 1.5 6.344308035714285e-06 0.0 6.352120535714285e-06 0.0 6.352678571428571e-06 1.5 6.361607142857142e-06 1.5 6.362165178571428e-06 0.0 6.3699776785714285e-06 0.0 6.3705357142857135e-06 1.5 6.3794642857142855e-06 1.5 6.380022321428571e-06 0.0 6.387834821428571e-06 0.0 6.388392857142857e-06 1.5 6.397321428571428e-06 1.5 6.397879464285714e-06 0.0 6.405691964285714e-06 0.0 6.40625e-06 1.5 6.415178571428571e-06 1.5 6.415736607142857e-06 0.0 6.423549107142856e-06 0.0 6.424107142857142e-06 1.5 6.433035714285714e-06 1.5 6.433593749999999e-06 0.0 6.4414062499999994e-06 0.0 6.441964285714285e-06 1.5 6.4508928571428565e-06 1.5 6.4514508928571424e-06 0.0 6.459263392857143e-06 0.0 6.4598214285714285e-06 1.5 6.46875e-06 1.5 6.469308035714286e-06 0.0 6.477120535714285e-06 0.0 6.477678571428571e-06 1.5 6.486607142857142e-06 1.5 6.487165178571428e-06 0.0 6.494977678571428e-06 0.0 6.495535714285714e-06 1.5 6.504464285714285e-06 1.5 6.505022321428571e-06 0.0 6.512834821428571e-06 0.0 6.513392857142856e-06 1.5 6.522321428571428e-06 1.5 6.522879464285713e-06 0.0 6.530691964285714e-06 0.0 6.5312499999999995e-06 1.5 6.540178571428571e-06 1.5 6.540736607142857e-06 0.0 6.548549107142857e-06 0.0 6.549107142857143e-06 1.5 6.558035714285714e-06 1.5 6.55859375e-06 0.0 6.56640625e-06 0.0 6.566964285714285e-06 1.5 6.575892857142857e-06 1.5 6.576450892857142e-06 0.0 6.584263392857142e-06 0.0 6.584821428571428e-06 1.5 6.593749999999999e-06 1.5 6.594308035714285e-06 0.0 6.6021205357142854e-06 0.0 6.602678571428571e-06 1.5 6.6116071428571425e-06 1.5 6.612165178571428e-06 0.0 6.619977678571428e-06 0.0 6.620535714285714e-06 1.5 6.629464285714285e-06 1.5 6.630022321428571e-06 0.0 6.637834821428571e-06 0.0 6.638392857142857e-06 1.5 6.647321428571428e-06 1.5 6.647879464285714e-06 0.0 6.655691964285714e-06 0.0 6.656249999999999e-06 1.5 6.665178571428571e-06 1.5 6.665736607142857e-06 0.0 6.6735491071428564e-06 0.0 6.674107142857142e-06 1.5 6.6830357142857135e-06 1.5 6.683593749999999e-06 0.0 6.690848214285714e-06 0.0 6.69140625e-06 1.5 6.7014508928571426e-06 1.5 6.7020089285714285e-06 0.0 6.708705357142857e-06 0.0 6.709263392857143e-06 1.5 6.719308035714285e-06 1.5 6.719866071428571e-06 0.0 6.726562499999999e-06 0.0 6.727120535714285e-06 1.5 6.737165178571428e-06 1.5 6.737723214285714e-06 0.0 6.744419642857142e-06 0.0 6.744977678571428e-06 1.5 6.755022321428571e-06 1.5 6.755580357142856e-06 0.0 6.7622767857142855e-06 0.0 6.762834821428571e-06 1.5 6.7728794642857136e-06 1.5 6.7734374999999995e-06 0.0 6.780133928571428e-06 0.0 6.780691964285714e-06 1.5 6.790736607142857e-06 1.5 6.791294642857143e-06 0.0 6.797991071428571e-06 0.0 6.798549107142857e-06 1.5 6.80859375e-06 1.5 6.809151785714285e-06 0.0 6.815848214285714e-06 0.0 6.816406249999999e-06 1.5 6.826450892857142e-06 1.5 6.827008928571428e-06 0.0 6.8337053571428565e-06 0.0 6.834263392857142e-06 1.5 6.844308035714285e-06 1.5 6.844866071428571e-06 0.0 6.8515625e-06 0.0 6.852120535714286e-06 1.5 6.862165178571428e-06 1.5 6.862723214285714e-06 0.0 6.869419642857142e-06 0.0 6.869977678571428e-06 1.5 6.880022321428571e-06 1.5 6.880580357142857e-06 0.0 6.887276785714285e-06 0.0 6.887834821428571e-06 1.5 6.897879464285714e-06 1.5 6.898437499999999e-06 0.0 6.905133928571428e-06 0.0 6.905691964285713e-06 1.5 6.915736607142856e-06 1.5 6.916294642857142e-06 0.0 6.922991071428571e-06 0.0 6.9235491071428566e-06 1.5 6.9335937499999996e-06 1.5 6.9341517857142855e-06 0.0 6.940848214285714e-06 0.0 6.94140625e-06 1.5 6.951450892857143e-06 1.5 6.952008928571428e-06 0.0 6.958705357142857e-06 0.0 6.959263392857142e-06 1.5 6.969308035714285e-06 1.5 6.969866071428571e-06 0.0 6.976562499999999e-06 0.0 6.977120535714285e-06 1.5 6.987165178571428e-06 1.5 6.987723214285714e-06 0.0 6.9944196428571425e-06 0.0 6.994977678571428e-06 1.5 7.0050223214285705e-06 1.5 7.0055803571428564e-06 0.0 7.012276785714285e-06 0.0 7.012834821428571e-06 1.5 7.022879464285714e-06 1.5 7.0234375e-06 0.0 7.030133928571428e-06 0.0 7.030691964285714e-06 1.5 7.040736607142857e-06 1.5 7.041294642857142e-06 0.0 7.047991071428571e-06 0.0 7.048549107142856e-06 1.5 7.058593749999999e-06 1.5 7.059151785714285e-06 0.0 7.0658482142857135e-06 0.0 7.066406249999999e-06 1.5 7.076450892857142e-06 1.5 7.077008928571428e-06 0.0 7.083705357142857e-06 0.0 7.0842633928571426e-06 1.5 7.0943080357142855e-06 1.5 7.094866071428571e-06 0.0 7.1015625e-06 0.0 7.102120535714285e-06 1.5 7.112165178571428e-06 1.5 7.112723214285714e-06 0.0 7.119419642857142e-06 0.0 7.119977678571428e-06 1.5 7.130022321428571e-06 1.5 7.130580357142857e-06 0.0 7.137276785714285e-06 0.0 7.137834821428571e-06 1.5 7.147879464285713e-06 1.5 7.148437499999999e-06 0.0 7.155133928571428e-06 0.0 7.1556919642857135e-06 1.5 7.1657366071428565e-06 1.5 7.1662946428571424e-06 0.0 7.172991071428571e-06 0.0 7.173549107142857e-06 1.5 7.18359375e-06 1.5 7.184151785714286e-06 0.0 7.190848214285714e-06 0.0 7.19140625e-06 1.5 7.201450892857142e-06 1.5 7.202008928571428e-06 0.0 7.208705357142856e-06 0.0 7.209263392857142e-06 1.5 7.219308035714285e-06 1.5 7.219866071428571e-06 0.0 7.2265624999999995e-06 0.0 7.227120535714285e-06 1.5 7.237165178571428e-06 1.5 7.2377232142857134e-06 0.0 7.244419642857143e-06 0.0 7.244977678571428e-06 1.5 7.255022321428571e-06 1.5 7.255580357142857e-06 0.0 7.262276785714285e-06 0.0 7.262834821428571e-06 1.5 7.272879464285714e-06 1.5 7.2734375e-06 0.0 7.280133928571428e-06 0.0 7.280691964285714e-06 1.5 7.290736607142857e-06 1.5 7.291294642857142e-06 0.0 7.297991071428571e-06 0.0 7.298549107142856e-06 1.5 7.308593749999999e-06 1.5 7.309151785714285e-06 0.0 7.315848214285714e-06 0.0 7.3164062499999995e-06 1.5 7.3264508928571425e-06 1.5 7.3270089285714284e-06 0.0 7.333705357142857e-06 0.0 7.334263392857143e-06 1.5 7.344308035714285e-06 1.5 7.344866071428571e-06 0.0 7.351562499999999e-06 0.0 7.352120535714285e-06 1.5 7.362165178571428e-06 1.5 7.362723214285714e-06 0.0 7.369419642857142e-06 0.0 7.369977678571428e-06 1.5 7.380022321428571e-06 1.5 7.380580357142856e-06 0.0 7.3872767857142855e-06 0.0 7.3878348214285705e-06 1.5 7.3978794642857135e-06 1.5 7.398437499999999e-06 0.0 7.405133928571428e-06 0.0 7.405691964285714e-06 1.5 7.415736607142857e-06 1.5 7.416294642857143e-06 0.0 7.422991071428571e-06 0.0 7.423549107142857e-06 1.5 7.43359375e-06 1.5 7.434151785714285e-06 0.0 7.440848214285714e-06 0.0 7.441406249999999e-06 1.5 7.451450892857142e-06 1.5 7.452008928571428e-06 0.0 7.4587053571428565e-06 0.0 7.459263392857142e-06 1.5 7.469308035714285e-06 1.5 7.469866071428571e-06 0.0 7.4765625e-06 0.0 7.4771205357142855e-06 1.5 7.487165178571428e-06 1.5 7.4877232142857136e-06 0.0 7.494419642857142e-06 0.0 7.494977678571428e-06 1.5 7.505022321428571e-06 1.5 7.505580357142857e-06 0.0 7.512276785714285e-06 0.0 7.512834821428571e-06 1.5 7.522879464285714e-06 1.5 7.523437499999999e-06 0.0 7.530133928571428e-06 0.0 7.530691964285713e-06 1.5 7.540736607142856e-06 1.5 7.541294642857142e-06 0.0 7.547991071428571e-06 0.0 7.5485491071428565e-06 1.5 7.5585937499999995e-06 1.5 7.559151785714285e-06 0.0 7.565848214285714e-06 0.0 7.56640625e-06 1.5 7.576450892857143e-06 1.5 7.577008928571428e-06 0.0 7.583705357142857e-06 0.0 7.584263392857142e-06 1.5 7.594308035714285e-06 1.5 7.594866071428571e-06 0.0 7.601562499999999e-06 0.0 7.602120535714285e-06 1.5 7.612165178571428e-06 1.5 7.612723214285714e-06 0.0 7.6194196428571424e-06 0.0 7.619977678571428e-06 1.5 7.630022321428571e-06 1.5 7.630580357142856e-06 0.0 7.637276785714286e-06 0.0 7.63783482142857e-06 1.5 7.647879464285714e-06 1.5 7.648437499999999e-06 0.0 7.655133928571428e-06 0.0 7.655691964285713e-06 1.5 7.665736607142856e-06 1.5 7.666294642857143e-06 0.0 7.67299107142857e-06 0.0 7.673549107142857e-06 1.5 7.68359375e-06 1.5 7.684151785714285e-06 0.0 7.690848214285714e-06 0.0 7.69140625e-06 1.5 7.701450892857142e-06 1.5 7.702008928571427e-06 0.0 7.708705357142857e-06 0.0 7.709263392857142e-06 1.5 7.719308035714285e-06 1.5 7.719866071428571e-06 0.0 7.726562499999999e-06 0.0 7.727120535714286e-06 1.5 7.737165178571429e-06 1.5 7.737723214285714e-06 0.0 7.744419642857143e-06 0.0 7.744977678571428e-06 1.5 7.755022321428571e-06 1.5 7.755580357142856e-06 0.0 7.762276785714285e-06 0.0 7.76283482142857e-06 1.5 7.772879464285713e-06 1.5 7.7734375e-06 0.0 7.780133928571428e-06 0.0 7.780691964285714e-06 1.5 7.790736607142857e-06 1.5 7.791294642857142e-06 0.0 7.797991071428572e-06 0.0 7.798549107142857e-06 1.5 7.80859375e-06 1.5 7.809151785714285e-06 0.0 7.815848214285714e-06 0.0 7.816406249999999e-06 1.5 7.826450892857142e-06 1.5 7.827008928571429e-06 0.0 7.833705357142856e-06 0.0 7.834263392857143e-06 1.5 7.844308035714286e-06 1.5 7.844866071428571e-06 0.0 7.8515625e-06 0.0 7.852120535714285e-06 1.5 7.862165178571428e-06 1.5 7.862723214285713e-06 0.0 7.869419642857143e-06 0.0 7.869977678571428e-06 1.5 7.88002232142857e-06 1.5 7.880580357142857e-06 0.0 7.887276785714285e-06 0.0 7.887834821428572e-06 1.5 7.897879464285713e-06 1.5 7.8984375e-06 0.0 7.905133928571427e-06 0.0 7.905691964285714e-06 1.5 7.915736607142857e-06 1.5 7.916294642857142e-06 0.0 7.922991071428571e-06 0.0 7.923549107142856e-06 1.5 7.93359375e-06 1.5 7.934151785714284e-06 0.0 7.940848214285714e-06 0.0 7.941406249999999e-06 1.5 7.951450892857142e-06 1.5 7.952008928571428e-06 0.0 7.958705357142856e-06 0.0 7.959263392857143e-06 1.5 7.969308035714286e-06 1.5 7.96986607142857e-06 0.0 7.9765625e-06 0.0 7.977120535714285e-06 1.5 7.987165178571428e-06 1.5 7.987723214285713e-06 0.0 7.994419642857142e-06 0.0 7.994977678571427e-06 1.5 8.00502232142857e-06 1.5 8.005580357142857e-06 0.0 8.012276785714285e-06 0.0 8.012834821428571e-06 1.5 8.022879464285714e-06 1.5 8.0234375e-06 0.0 8.030133928571429e-06 0.0 8.030691964285714e-06 1.5 8.040736607142857e-06 1.5 8.041294642857142e-06 0.0 8.047991071428571e-06 0.0 8.048549107142856e-06 1.5 8.058593749999999e-06 1.5 8.059151785714286e-06 0.0 8.065848214285713e-06 0.0 8.06640625e-06 1.5 8.076450892857143e-06 1.5 8.077008928571428e-06 0.0 8.083705357142857e-06 0.0 8.084263392857142e-06 1.5 8.094308035714285e-06 1.5 8.09486607142857e-06 0.0 8.1015625e-06 0.0 8.102120535714285e-06 1.5 8.112165178571428e-06 1.5 8.112723214285714e-06 0.0 8.119419642857142e-06 0.0 8.119977678571429e-06 1.5 8.130022321428572e-06 1.5 8.130580357142857e-06 0.0 8.137276785714286e-06 0.0 8.137834821428571e-06 1.5 8.147879464285714e-06 1.5 8.148437499999999e-06 0.0 8.155133928571428e-06 0.0 8.155691964285713e-06 1.5 8.165736607142856e-06 1.5 8.166294642857143e-06 0.0 8.17299107142857e-06 0.0 8.173549107142857e-06 1.5 8.183593749999999e-06 1.5 8.184151785714285e-06 0.0 8.190848214285713e-06 0.0 8.19140625e-06 1.5 8.201450892857143e-06 1.5 8.202008928571428e-06 0.0 8.208705357142857e-06 0.0 8.209263392857142e-06 1.5 8.219308035714285e-06 1.5 8.21986607142857e-06 0.0 8.2265625e-06 0.0 8.227120535714284e-06 1.5 8.237165178571427e-06 1.5 8.237723214285714e-06 0.0 8.244419642857142e-06 0.0 8.244977678571428e-06 1.5 8.255022321428571e-06 1.5 8.255580357142856e-06 0.0 8.262276785714286e-06 0.0 8.26283482142857e-06 1.5 8.272879464285714e-06 1.5 8.273437499999999e-06 0.0 8.280133928571428e-06 0.0 8.280691964285713e-06 1.5 8.290736607142856e-06 1.5 8.291294642857143e-06 0.0 8.29799107142857e-06 0.0 8.298549107142857e-06 1.5 8.30859375e-06 1.5 8.309151785714285e-06 0.0 8.315848214285714e-06 0.0 8.31640625e-06 1.5 8.326450892857142e-06 1.5 8.327008928571427e-06 0.0 8.333705357142857e-06 0.0 8.334263392857142e-06 1.5 8.344308035714285e-06 1.5 8.344866071428571e-06 0.0 8.351562499999999e-06 0.0 8.352120535714286e-06 1.5 8.362165178571429e-06 1.5 8.362723214285714e-06 0.0 8.369419642857143e-06 0.0 8.369977678571428e-06 1.5 8.380022321428571e-06 1.5 8.380580357142856e-06 0.0 8.387276785714285e-06 0.0 8.38783482142857e-06 1.5 8.397879464285713e-06 1.5 8.3984375e-06 0.0 8.405133928571428e-06 0.0 8.405691964285714e-06 1.5 8.415736607142857e-06 1.5 8.416294642857142e-06 0.0 8.422991071428572e-06 0.0 8.423549107142857e-06 1.5 8.43359375e-06 1.5 8.434151785714285e-06 0.0 8.440848214285714e-06 0.0 8.441406249999999e-06 1.5 8.451450892857142e-06 1.5 8.452008928571429e-06 0.0 8.458705357142856e-06 0.0 8.459263392857143e-06 1.5 8.469308035714286e-06 1.5 8.469866071428571e-06 0.0 8.4765625e-06 0.0 8.477120535714285e-06 1.5 8.487165178571428e-06 1.5 8.487723214285713e-06 0.0 8.494419642857143e-06 0.0 8.494977678571428e-06 1.5 8.50502232142857e-06 1.5 8.505580357142857e-06 0.0 8.512276785714285e-06 0.0 8.512834821428572e-06 1.5 8.522879464285713e-06 1.5 8.5234375e-06 0.0 8.530133928571427e-06 0.0 8.530691964285714e-06 1.5 8.540736607142857e-06 1.5 8.541294642857142e-06 0.0 8.547991071428571e-06 0.0 8.548549107142856e-06 1.5 8.55859375e-06 1.5 8.559151785714284e-06 0.0 8.565848214285714e-06 0.0 8.566406249999999e-06 1.5 8.576450892857142e-06 1.5 8.577008928571428e-06 0.0 8.583705357142856e-06 0.0 8.584263392857143e-06 1.5 8.594308035714286e-06 1.5 8.59486607142857e-06 0.0 8.6015625e-06 0.0 8.602120535714285e-06 1.5 8.612165178571428e-06 1.5 8.612723214285713e-06 0.0 8.619419642857142e-06 0.0 8.619977678571427e-06 1.5 8.63002232142857e-06 1.5 8.630580357142857e-06 0.0 8.637276785714285e-06 0.0 8.637834821428571e-06 1.5 8.647879464285714e-06 1.5 8.6484375e-06 0.0 8.655133928571429e-06 0.0 8.655691964285714e-06 1.5 8.665736607142857e-06 1.5 8.666294642857142e-06 0.0 8.672991071428571e-06 0.0 8.673549107142856e-06 1.5 8.683593749999999e-06 1.5 8.684151785714286e-06 0.0 8.690848214285713e-06 0.0 8.69140625e-06 1.5 8.701450892857143e-06 1.5 8.702008928571428e-06 0.0 8.708705357142857e-06 0.0 8.709263392857142e-06 1.5 8.719308035714285e-06 1.5 8.71986607142857e-06 0.0 8.7265625e-06 0.0 8.727120535714285e-06 1.5 8.737165178571428e-06 1.5 8.737723214285714e-06 0.0 8.744419642857142e-06 0.0 8.744977678571429e-06 1.5 8.755022321428572e-06 1.5 8.755580357142857e-06 0.0 8.762276785714286e-06 0.0 8.762834821428571e-06 1.5 8.772879464285714e-06 1.5 8.773437499999999e-06 0.0 8.780133928571428e-06 0.0 8.780691964285713e-06 1.5 8.790736607142856e-06 1.5 8.791294642857143e-06 0.0 8.79799107142857e-06 0.0 8.798549107142857e-06 1.5 8.808593749999999e-06 1.5 8.809151785714285e-06 0.0 8.815848214285713e-06 0.0 8.81640625e-06 1.5 8.826450892857143e-06 1.5 8.827008928571428e-06 0.0 8.833705357142857e-06 0.0 8.834263392857142e-06 1.5 8.844308035714285e-06 1.5 8.844866071428572e-06 0.0 8.8515625e-06 0.0 8.852120535714286e-06 1.5 8.862165178571427e-06 1.5 8.862723214285714e-06 0.0 8.869419642857141e-06 0.0 8.869977678571428e-06 1.5 8.880022321428571e-06 1.5 8.880580357142856e-06 0.0 8.887276785714286e-06 0.0 8.88783482142857e-06 1.5 8.897879464285714e-06 1.5 8.898437499999999e-06 0.0 8.905133928571428e-06 0.0 8.905691964285713e-06 1.5 8.915736607142856e-06 1.5 8.916294642857143e-06 0.0 8.92299107142857e-06 0.0 8.923549107142857e-06 1.5 8.93359375e-06 1.5 8.934151785714285e-06 0.0 8.940848214285714e-06 0.0 8.94140625e-06 1.5 8.951450892857142e-06 1.5 8.952008928571427e-06 0.0 8.958705357142856e-06 0.0 8.959263392857142e-06 1.5 8.969308035714285e-06 1.5 8.969866071428571e-06 0.0 8.976562499999999e-06 0.0 8.977120535714286e-06 1.5 8.987165178571429e-06 1.5 8.987723214285714e-06 0.0 8.994419642857143e-06 0.0 8.994977678571428e-06 1.5 9.005022321428571e-06 1.5 9.005580357142856e-06 0.0 9.012276785714285e-06 0.0 9.01283482142857e-06 1.5 9.022879464285713e-06 1.5 9.0234375e-06 0.0 9.030133928571427e-06 0.0 9.030691964285714e-06 1.5 9.040736607142857e-06 1.5 9.041294642857142e-06 0.0 9.047991071428571e-06 0.0 9.048549107142857e-06 1.5 9.05859375e-06 1.5 9.059151785714285e-06 0.0 9.065848214285714e-06 0.0 9.066406249999999e-06 1.5 9.076450892857142e-06 1.5 9.077008928571429e-06 0.0 9.083705357142856e-06 0.0 9.084263392857143e-06 1.5 9.094308035714286e-06 1.5 9.094866071428571e-06 0.0 9.1015625e-06 0.0 9.102120535714285e-06 1.5 9.112165178571428e-06 1.5 9.112723214285713e-06 0.0 9.119419642857142e-06 0.0 9.119977678571428e-06 1.5 9.13002232142857e-06 1.5 9.130580357142857e-06 0.0 9.137276785714285e-06 0.0 9.137834821428572e-06 1.5 9.147879464285713e-06 1.5 9.1484375e-06 0.0 9.155133928571427e-06 0.0 9.155691964285714e-06 1.5 9.165736607142857e-06 1.5 9.166294642857142e-06 0.0 9.172991071428571e-06 0.0 9.173549107142856e-06 1.5 9.18359375e-06 1.5 9.184151785714284e-06 0.0 9.190848214285713e-06 0.0 9.191406249999999e-06 1.5 9.201450892857142e-06 1.5 9.202008928571428e-06 0.0 9.208705357142856e-06 0.0 9.209263392857143e-06 1.5 9.219308035714286e-06 1.5 9.21986607142857e-06 0.0 9.2265625e-06 0.0 9.227120535714285e-06 1.5 9.237165178571428e-06 1.5 9.237723214285713e-06 0.0 9.244419642857142e-06 0.0 9.244977678571427e-06 1.5 9.25502232142857e-06 1.5 9.255580357142857e-06 0.0 9.262276785714284e-06 0.0 9.262834821428571e-06 1.5 9.272879464285714e-06 1.5 9.2734375e-06 0.0 9.280133928571428e-06 0.0 9.280691964285714e-06 1.5 9.290736607142857e-06 1.5 9.291294642857142e-06 0.0 9.29799107142857e-06 0.0 9.298549107142856e-06 1.5 9.308593749999999e-06 1.5 9.309151785714286e-06 0.0 9.315848214285713e-06 0.0 9.31640625e-06 1.5 9.326450892857143e-06 1.5 9.327008928571428e-06 0.0 9.333705357142857e-06 0.0 9.334263392857142e-06 1.5 9.344308035714285e-06 1.5 9.34486607142857e-06 0.0 9.3515625e-06 0.0 9.352120535714285e-06 1.5 9.362165178571427e-06 1.5 9.362723214285714e-06 0.0 9.369977678571429e-06 0.0 9.370535714285714e-06 1.5 9.379464285714285e-06 1.5 9.380022321428572e-06 0.0 9.387834821428571e-06 0.0 9.388392857142856e-06 1.5 9.397321428571427e-06 1.5 9.397879464285714e-06 0.0 9.405691964285713e-06 0.0 9.40625e-06 1.5 9.415178571428571e-06 1.5 9.415736607142856e-06 0.0 9.423549107142857e-06 0.0 9.424107142857142e-06 1.5 9.433035714285713e-06 1.5 9.433593749999998e-06 0.0 9.44140625e-06 0.0 9.441964285714285e-06 1.5 9.450892857142856e-06 1.5 9.451450892857143e-06 0.0 9.459263392857142e-06 0.0 9.459821428571429e-06 1.5 9.46875e-06 1.5 9.469308035714285e-06 0.0 9.477120535714286e-06 0.0 9.477678571428571e-06 1.5 9.486607142857142e-06 1.5 9.487165178571427e-06 0.0 9.494977678571428e-06 0.0 9.495535714285713e-06 1.5 9.504464285714284e-06 1.5 9.505022321428571e-06 0.0 9.51283482142857e-06 0.0 9.513392857142857e-06 1.5 9.522321428571428e-06 1.5 9.522879464285713e-06 0.0 9.530691964285713e-06 0.0 9.53125e-06 1.5 9.54017857142857e-06 1.5 9.540736607142856e-06 0.0 9.548549107142857e-06 0.0 9.549107142857142e-06 1.5 9.558035714285713e-06 1.5 9.55859375e-06 0.0 9.56640625e-06 0.0 9.566964285714284e-06 1.5 9.575892857142857e-06 1.5 9.576450892857142e-06 0.0 9.584263392857141e-06 0.0 9.584821428571428e-06 1.5 9.59375e-06 1.5 9.594308035714284e-06 0.0 9.602120535714286e-06 0.0 9.60267857142857e-06 1.5 9.611607142857142e-06 1.5 9.612165178571428e-06 0.0 9.619977678571428e-06 0.0 9.620535714285713e-06 1.5 9.629464285714286e-06 1.5 9.63002232142857e-06 0.0 9.63783482142857e-06 0.0 9.638392857142857e-06 1.5 9.647321428571428e-06 1.5 9.647879464285713e-06 0.0 9.655691964285714e-06 0.0 9.65625e-06 1.5 9.66517857142857e-06 1.5 9.665736607142857e-06 0.0 9.673549107142856e-06 0.0 9.674107142857142e-06 1.5 9.683035714285714e-06 1.5 9.68359375e-06 0.0 9.691406249999999e-06 0.0 9.691964285714286e-06 1.5 9.700892857142857e-06 1.5 9.701450892857142e-06 0.0 9.709263392857143e-06 0.0 9.709821428571428e-06 1.5 9.718749999999999e-06 1.5 9.719308035714286e-06 0.0 9.727120535714285e-06 0.0 9.72767857142857e-06 1.5 9.736607142857141e-06 1.5 9.737165178571428e-06 0.0 9.744977678571427e-06 0.0 9.745535714285714e-06 1.5 9.754464285714285e-06 1.5 9.75502232142857e-06 0.0 9.762834821428572e-06 0.0 9.763392857142857e-06 1.5 9.772321428571428e-06 1.5 9.772879464285713e-06 0.0 9.780691964285714e-06 0.0 9.781249999999999e-06 1.5 9.79017857142857e-06 1.5 9.790736607142857e-06 0.0 9.798549107142856e-06 0.0 9.799107142857143e-06 1.5 9.808035714285714e-06 1.5 9.808593749999999e-06 0.0 9.816406249999998e-06 0.0 9.816964285714285e-06 1.5 9.825892857142856e-06 1.5 9.826450892857141e-06 0.0 9.834263392857142e-06 0.0 9.834821428571428e-06 1.5 9.843749999999999e-06 1.5 9.844308035714285e-06 0.0 9.852120535714285e-06 0.0 9.85267857142857e-06 1.5 9.861607142857143e-06 1.5 9.862165178571428e-06 0.0 9.869977678571427e-06 0.0 9.870535714285714e-06 1.5 9.879464285714285e-06 1.5 9.88002232142857e-06 0.0 9.887834821428571e-06 0.0 9.888392857142856e-06 1.5 9.897321428571427e-06 1.5 9.897879464285714e-06 0.0 9.905691964285713e-06 0.0 9.906249999999999e-06 1.5 9.915178571428571e-06 1.5 9.915736607142856e-06 0.0 9.923549107142856e-06 0.0 9.924107142857143e-06 1.5 9.933035714285714e-06 1.5 9.933593749999999e-06 0.0 9.94140625e-06 0.0 9.941964285714285e-06 1.5 9.950892857142856e-06 1.5 9.951450892857143e-06 0.0 9.959263392857142e-06 0.0 9.959821428571427e-06 1.5 9.96875e-06 1.5 9.969308035714285e-06 0.0 9.977120535714284e-06 0.0 9.977678571428571e-06 1.5 9.986607142857142e-06 1.5 9.987165178571427e-06 0.0 9.994977678571428e-06 0.0 9.995535714285714e-06 1.5 1.0004464285714285e-05 1.5 1.0005022321428571e-05 0.0 1.001283482142857e-05 0.0 1.0013392857142856e-05 1.5 1.0022321428571427e-05 1.5 1.0022879464285714e-05 0.0 1.0030691964285713e-05 0.0 1.003125e-05 1.5 1.0039620535714284e-05 1.5 1.0040178571428571e-05 0.0 1.0049107142857142e-05 0.0 1.0049665178571427e-05 1.5 1.0057477678571428e-05 1.5 1.0058035714285713e-05 0.0 1.0066964285714285e-05 0.0 1.0067522321428571e-05 1.5 1.007533482142857e-05 1.5 1.0075892857142856e-05 0.0 1.0084821428571429e-05 0.0 1.0085379464285714e-05 1.5 1.0093191964285713e-05 1.5 1.009375e-05 0.0 1.0102678571428571e-05 0.0 1.0103236607142856e-05 1.5 1.0111049107142857e-05 1.5 1.0111607142857142e-05 0.0 1.0120535714285713e-05 0.0 1.012109375e-05 1.5 1.012890625e-05 1.5 1.0129464285714284e-05 0.0 1.0138392857142857e-05 0.0 1.0138950892857142e-05 1.5 1.0146763392857142e-05 1.5 1.0147321428571428e-05 0.0 1.015625e-05 0.0 1.0156808035714285e-05 1.5 1.0164620535714286e-05 1.5 1.016517857142857e-05 0.0 1.0174107142857142e-05 0.0 1.0174665178571429e-05 1.5 1.0182477678571428e-05 1.5 1.0183035714285713e-05 0.0 1.0191964285714284e-05 0.0 1.0192522321428571e-05 1.5 1.020033482142857e-05 1.5 1.0200892857142857e-05 0.0 1.0209821428571428e-05 0.0 1.0210379464285713e-05 1.5 1.0218191964285714e-05 1.5 1.021875e-05 0.0 1.022767857142857e-05 0.0 1.0228236607142856e-05 1.5 1.0236049107142857e-05 1.5 1.0236607142857142e-05 0.0 1.0245535714285713e-05 0.0 1.024609375e-05 1.5 1.0253906249999999e-05 1.5 1.0254464285714286e-05 0.0 1.0263392857142857e-05 0.0 1.0263950892857142e-05 1.5 1.0271763392857143e-05 1.5 1.0272321428571428e-05 0.0 1.028125e-05 0.0 1.0281808035714284e-05 1.5 1.0289620535714285e-05 1.5 1.029017857142857e-05 0.0 1.0299107142857142e-05 0.0 1.0299665178571428e-05 1.5 1.0307477678571428e-05 1.5 1.0308035714285714e-05 0.0 1.0316964285714286e-05 0.0 1.031752232142857e-05 1.5 1.032533482142857e-05 1.5 1.0325892857142857e-05 0.0 1.0334821428571428e-05 0.0 1.0335379464285713e-05 1.5 1.0343191964285714e-05 1.5 1.0343749999999999e-05 0.0 1.035267857142857e-05 0.0 1.0353236607142857e-05 1.5 1.0361049107142856e-05 1.5 1.0361607142857141e-05 0.0 1.0370535714285714e-05 0.0 1.037109375e-05 1.5 1.0378906249999999e-05 1.5 1.0379464285714285e-05 0.0 1.0388392857142857e-05 0.0 1.0388950892857142e-05 1.5 1.0396763392857143e-05 1.5 1.0397321428571428e-05 0.0 1.0406249999999999e-05 0.0 1.0406808035714286e-05 1.5 1.0414620535714285e-05 1.5 1.041517857142857e-05 0.0 1.0424107142857143e-05 0.0 1.0424665178571428e-05 1.5 1.0432477678571427e-05 1.5 1.0433035714285714e-05 0.0 1.0441964285714285e-05 0.0 1.044252232142857e-05 1.5 1.0450334821428571e-05 1.5 1.0450892857142856e-05 0.0 1.0459821428571427e-05 0.0 1.0460379464285714e-05 1.5 1.0468191964285714e-05 1.5 1.0468749999999999e-05 0.0 1.0477678571428572e-05 0.0 1.0478236607142857e-05 1.5 1.0486049107142856e-05 1.5 1.0486607142857143e-05 0.0 1.0495535714285714e-05 0.0 1.0496093749999999e-05 1.5 1.050390625e-05 1.5 1.0504464285714285e-05 0.0 1.0513392857142856e-05 0.0 1.0513950892857143e-05 1.5 1.0521763392857142e-05 1.5 1.0522321428571427e-05 0.0 1.0531249999999998e-05 0.0 1.0531808035714285e-05 1.5 1.0539620535714285e-05 1.5 1.0540178571428571e-05 0.0 1.0549107142857143e-05 0.0 1.0549665178571428e-05 1.5 1.0557477678571429e-05 1.5 1.0558035714285714e-05 0.0 1.0566964285714285e-05 0.0 1.056752232142857e-05 1.5 1.0575334821428571e-05 1.5 1.0575892857142856e-05 0.0 1.0584821428571427e-05 0.0 1.0585379464285714e-05 1.5 1.0593191964285713e-05 1.5 1.059375e-05 0.0 1.0602678571428571e-05 0.0 1.0603236607142856e-05 1.5 1.0611049107142856e-05 1.5 1.0611607142857142e-05 0.0 1.0620535714285713e-05 0.0 1.0621093749999999e-05 1.5 1.062890625e-05 1.5 1.0629464285714285e-05 0.0 1.0638392857142856e-05 0.0 1.0638950892857143e-05 1.5 1.0646763392857142e-05 1.5 1.0647321428571427e-05 0.0 1.065625e-05 0.0 1.0656808035714285e-05 1.5 1.0664620535714284e-05 1.5 1.0665178571428571e-05 0.0 1.0674107142857142e-05 0.0 1.0674665178571427e-05 1.5 1.0682477678571428e-05 1.5 1.0683035714285713e-05 0.0 1.0691964285714284e-05 0.0 1.0692522321428571e-05 1.5 1.070033482142857e-05 1.5 1.0700892857142856e-05 0.0 1.0710379464285714e-05 0.0 1.0710937499999999e-05 1.5 1.0717633928571428e-05 1.5 1.0718191964285713e-05 0.0 1.0728236607142856e-05 0.0 1.0728794642857143e-05 1.5 1.073549107142857e-05 1.5 1.0736049107142857e-05 0.0 1.074609375e-05 0.0 1.0746651785714285e-05 1.5 1.0753348214285714e-05 1.5 1.075390625e-05 0.0 1.0763950892857142e-05 0.0 1.0764508928571427e-05 1.5 1.0771205357142856e-05 1.5 1.0771763392857142e-05 0.0 1.0781808035714285e-05 0.0 1.0782366071428571e-05 1.5 1.0789062499999999e-05 1.5 1.0789620535714286e-05 0.0 1.0799665178571429e-05 0.0 1.0800223214285714e-05 1.5 1.0806919642857143e-05 1.5 1.0807477678571428e-05 0.0 1.0817522321428571e-05 0.0 1.0818080357142856e-05 1.5 1.0824776785714285e-05 1.5 1.082533482142857e-05 0.0 1.0835379464285713e-05 0.0 1.08359375e-05 1.5 1.0842633928571427e-05 1.5 1.0843191964285714e-05 0.0 1.0853236607142856e-05 0.0 1.0853794642857142e-05 1.5 1.086049107142857e-05 1.5 1.0861049107142857e-05 0.0 1.087109375e-05 0.0 1.0871651785714285e-05 1.5 1.0878348214285714e-05 1.5 1.0878906249999999e-05 0.0 1.0888950892857142e-05 0.0 1.0889508928571429e-05 1.5 1.0896205357142856e-05 1.5 1.0896763392857143e-05 0.0 1.0906808035714284e-05 0.0 1.0907366071428571e-05 1.5 1.0914062499999998e-05 1.5 1.0914620535714285e-05 0.0 1.0924665178571428e-05 0.0 1.0925223214285713e-05 1.5 1.0931919642857142e-05 1.5 1.0932477678571428e-05 0.0 1.094252232142857e-05 0.0 1.0943080357142856e-05 1.5 1.0949776785714285e-05 1.5 1.095033482142857e-05 0.0 1.0960379464285713e-05 0.0 1.09609375e-05 1.5 1.0967633928571427e-05 1.5 1.0968191964285714e-05 0.0 1.0978236607142857e-05 0.0 1.0978794642857142e-05 1.5 1.0985491071428571e-05 1.5 1.0986049107142856e-05 0.0 1.099609375e-05 0.0 1.0996651785714284e-05 1.5 1.1003348214285713e-05 1.5 1.1003906249999999e-05 0.0 1.1013950892857142e-05 0.0 1.1014508928571428e-05 1.5 1.1021205357142856e-05 1.5 1.1021763392857143e-05 0.0 1.1031808035714286e-05 0.0 1.103236607142857e-05 1.5 1.10390625e-05 1.5 1.1039620535714285e-05 0.0 1.1049665178571428e-05 0.0 1.1050223214285713e-05 1.5 1.1056919642857142e-05 1.5 1.1057477678571427e-05 0.0 1.106752232142857e-05 0.0 1.1068080357142857e-05 1.5 1.1074776785714284e-05 1.5 1.1075334821428571e-05 0.0 1.1085379464285714e-05 0.0 1.10859375e-05 1.5 1.1092633928571428e-05 1.5 1.1093191964285714e-05 0.0 1.1103236607142857e-05 0.0 1.1103794642857142e-05 1.5 1.111049107142857e-05 1.5 1.1111049107142856e-05 0.0 1.1121093749999999e-05 0.0 1.1121651785714286e-05 1.5 1.1128348214285713e-05 1.5 1.112890625e-05 0.0 1.1138950892857143e-05 0.0 1.1139508928571428e-05 1.5 1.1146205357142857e-05 1.5 1.1146763392857142e-05 0.0 1.1156808035714285e-05 0.0 1.115736607142857e-05 1.5 1.11640625e-05 1.5 1.1164620535714285e-05 0.0 1.1174665178571428e-05 0.0 1.1175223214285714e-05 1.5 1.1181919642857142e-05 1.5 1.1182477678571429e-05 0.0 1.119252232142857e-05 0.0 1.1193080357142857e-05 1.5 1.1199776785714284e-05 1.5 1.1200334821428571e-05 0.0 1.1210379464285714e-05 0.0 1.1210937499999999e-05 1.5 1.1217633928571428e-05 1.5 1.1218191964285713e-05 0.0 1.1228236607142856e-05 0.0 1.1228794642857141e-05 1.5 1.123549107142857e-05 1.5 1.1236049107142856e-05 0.0 1.1246093749999998e-05 0.0 1.1246651785714285e-05 1.5 1.1253348214285713e-05 1.5 1.125390625e-05 0.0 1.1263950892857143e-05 0.0 1.1264508928571428e-05 1.5 1.1271205357142857e-05 1.5 1.1271763392857142e-05 0.0 1.1281808035714285e-05 0.0 1.128236607142857e-05 1.5 1.1289062499999999e-05 1.5 1.1289620535714284e-05 0.0 1.1299665178571427e-05 0.0 1.1300223214285714e-05 1.5 1.1306919642857141e-05 1.5 1.1307477678571428e-05 0.0 1.1317522321428571e-05 0.0 1.1318080357142856e-05 1.5 1.1324776785714285e-05 1.5 1.132533482142857e-05 0.0 1.1335379464285713e-05 0.0 1.1335937499999999e-05 1.5 1.1342633928571428e-05 1.5 1.1343191964285713e-05 0.0 1.1353236607142856e-05 0.0 1.1353794642857143e-05 1.5 1.136049107142857e-05 1.5 1.1361049107142857e-05 0.0 1.137109375e-05 0.0 1.1371651785714285e-05 1.5 1.1378348214285714e-05 1.5 1.137890625e-05 0.0 1.1388950892857142e-05 0.0 1.1389508928571427e-05 1.5 1.1396205357142856e-05 1.5 1.1396763392857142e-05 0.0 1.1406808035714284e-05 0.0 1.1407366071428571e-05 1.5 1.1414062499999999e-05 1.5 1.1414620535714286e-05 0.0 1.1424665178571429e-05 0.0 1.1425223214285714e-05 1.5 1.1431919642857143e-05 1.5 1.1432477678571428e-05 0.0 1.144252232142857e-05 0.0 1.1443080357142856e-05 1.5 1.1449776785714285e-05 1.5 1.145033482142857e-05 0.0 1.1460379464285713e-05 0.0 1.14609375e-05 1.5 1.1467633928571427e-05 1.5 1.1468191964285714e-05 0.0 1.1478236607142855e-05 0.0 1.1478794642857142e-05 1.5 1.1485491071428571e-05 1.5 1.1486049107142857e-05 0.0 1.149609375e-05 0.0 1.1496651785714285e-05 1.5 1.1503348214285714e-05 1.5 1.1503906249999999e-05 0.0 1.1513950892857142e-05 0.0 1.1514508928571429e-05 1.5 1.1521205357142856e-05 1.5 1.1521763392857143e-05 0.0 1.1531808035714284e-05 0.0 1.1532366071428571e-05 1.5 1.1539062499999998e-05 1.5 1.1539620535714285e-05 0.0 1.1549665178571428e-05 0.0 1.1550223214285713e-05 1.5 1.1556919642857142e-05 1.5 1.1557477678571427e-05 0.0 1.156752232142857e-05 0.0 1.1568080357142856e-05 1.5 1.1574776785714285e-05 1.5 1.157533482142857e-05 0.0 1.1585379464285713e-05 0.0 1.15859375e-05 1.5 1.1592633928571427e-05 1.5 1.1593191964285714e-05 0.0 1.1603236607142857e-05 0.0 1.1603794642857142e-05 1.5 1.1610491071428571e-05 1.5 1.1611049107142856e-05 0.0 1.1621093749999999e-05 0.0 1.1621651785714284e-05 1.5 1.1628348214285713e-05 1.5 1.1628906249999998e-05 0.0 1.1638950892857141e-05 0.0 1.1639508928571428e-05 1.5 1.1646205357142856e-05 1.5 1.1646763392857143e-05 0.0 1.1656808035714285e-05 0.0 1.165736607142857e-05 1.5 1.16640625e-05 1.5 1.1664620535714285e-05 0.0 1.1674665178571428e-05 0.0 1.1675223214285713e-05 1.5 1.1681919642857142e-05 1.5 1.1682477678571427e-05 0.0 1.169252232142857e-05 0.0 1.1693080357142857e-05 1.5 1.1699776785714284e-05 1.5 1.1700334821428571e-05 0.0 1.1710379464285714e-05 0.0 1.17109375e-05 1.5 1.1717633928571428e-05 1.5 1.1718191964285713e-05 0.0 1.1728236607142856e-05 0.0 1.1728794642857142e-05 1.5 1.173549107142857e-05 1.5 1.1736049107142856e-05 0.0 1.1746093749999999e-05 0.0 1.1746651785714286e-05 1.5 1.1753348214285713e-05 1.5 1.175390625e-05 0.0 1.1763950892857143e-05 0.0 1.1764508928571428e-05 1.5 1.1771205357142857e-05 1.5 1.1771763392857142e-05 0.0 1.1781808035714285e-05 0.0 1.178236607142857e-05 1.5 1.17890625e-05 1.5 1.1789620535714284e-05 0.0 1.1799665178571427e-05 0.0 1.1800223214285714e-05 1.5 1.1806919642857142e-05 1.5 1.1807477678571428e-05 0.0 1.181752232142857e-05 0.0 1.1818080357142857e-05 1.5 1.1824776785714284e-05 1.5 1.182533482142857e-05 0.0 1.1835379464285714e-05 0.0 1.1835937499999999e-05 1.5 1.1842633928571428e-05 1.5 1.1843191964285713e-05 0.0 1.1853236607142856e-05 0.0 1.1853794642857141e-05 1.5 1.186049107142857e-05 1.5 1.1861049107142855e-05 0.0 1.1871093749999998e-05 0.0 1.1871651785714285e-05 1.5 1.1878348214285713e-05 1.5 1.187890625e-05 0.0 1.1888950892857142e-05 0.0 1.1889508928571428e-05 1.5 1.1896205357142857e-05 1.5 1.1896763392857142e-05 0.0 1.1906808035714285e-05 0.0 1.190736607142857e-05 1.5 1.1914062499999999e-05 1.5 1.1914620535714284e-05 0.0 1.1924665178571427e-05 0.0 1.1925223214285714e-05 1.5 1.1931919642857141e-05 1.5 1.1932477678571428e-05 0.0 1.1942522321428571e-05 0.0 1.1943080357142856e-05 1.5 1.1949776785714285e-05 1.5 1.195033482142857e-05 0.0 1.1960379464285713e-05 0.0 1.1960937499999999e-05 1.5 1.1967633928571428e-05 1.5 1.1968191964285713e-05 0.0 1.1978236607142856e-05 0.0 1.1978794642857143e-05 1.5 1.198549107142857e-05 1.5 1.1986049107142857e-05 0.0 1.199609375e-05 0.0 1.1996651785714285e-05 1.5 1.2003348214285714e-05 1.5 1.2003906249999999e-05 0.0 1.2013950892857142e-05 0.0 1.2014508928571427e-05 1.5 1.2021205357142856e-05 1.5 1.2021763392857141e-05 0.0 1.2031808035714284e-05 0.0 1.2032366071428571e-05 1.5 1.2039062499999999e-05 1.5 1.2039620535714285e-05 0.0 1.2049665178571428e-05 0.0 1.2050223214285714e-05 1.5 1.2056919642857143e-05 1.5 1.2057477678571428e-05 0.0 1.206752232142857e-05 0.0 1.2068080357142856e-05 1.5 1.2074776785714285e-05 1.5 1.207533482142857e-05 0.0 1.2085379464285713e-05 0.0 1.20859375e-05 1.5 1.2092633928571427e-05 1.5 1.2093191964285714e-05 0.0 1.2103236607142857e-05 0.0 1.2103794642857142e-05 1.5 1.2110491071428571e-05 1.5 1.2111049107142856e-05 0.0 1.212109375e-05 0.0 1.2121651785714284e-05 1.5 1.2128348214285714e-05 1.5 1.2128906249999999e-05 0.0 1.2138950892857142e-05 0.0 1.2139508928571429e-05 1.5 1.2146205357142856e-05 1.5 1.2146763392857143e-05 0.0 1.2156808035714284e-05 0.0 1.215736607142857e-05 1.5 1.2164062499999998e-05 1.5 1.2164620535714285e-05 0.0 1.2174665178571428e-05 0.0 1.2175223214285713e-05 1.5 1.2181919642857142e-05 1.5 1.2182477678571427e-05 0.0 1.219252232142857e-05 0.0 1.2193080357142855e-05 1.5 1.2199776785714285e-05 1.5 1.220033482142857e-05 0.0 1.2210379464285713e-05 0.0 1.22109375e-05 1.5 1.2217633928571427e-05 1.5 1.2218191964285714e-05 0.0 1.2228236607142857e-05 0.0 1.2228794642857142e-05 1.5 1.2235491071428571e-05 1.5 1.2236049107142856e-05 0.0 1.2246093749999999e-05 0.0 1.2246651785714284e-05 1.5 1.2253348214285713e-05 1.5 1.2253906249999998e-05 0.0 1.2263950892857141e-05 0.0 1.2264508928571428e-05 1.5 1.2271205357142856e-05 1.5 1.2271763392857142e-05 0.0 1.2281808035714285e-05 0.0 1.228236607142857e-05 1.5 1.22890625e-05 1.5 1.2289620535714285e-05 0.0 1.2299665178571428e-05 0.0 1.2300223214285713e-05 1.5 1.2306919642857142e-05 1.5 1.2307477678571427e-05 0.0 1.231752232142857e-05 0.0 1.2318080357142857e-05 1.5 1.2324776785714284e-05 1.5 1.2325334821428571e-05 0.0 1.2335379464285714e-05 0.0 1.2335937499999999e-05 1.5 1.2342633928571428e-05 1.5 1.2343191964285713e-05 0.0 1.2353236607142856e-05 0.0 1.2353794642857141e-05 1.5 1.236049107142857e-05 1.5 1.2361049107142856e-05 0.0 1.2371093749999999e-05 0.0 1.2371651785714285e-05 1.5 1.2378348214285713e-05 1.5 1.237890625e-05 0.0 1.2388950892857143e-05 0.0 1.2389508928571428e-05 1.5 1.2396205357142857e-05 1.5 1.2396763392857142e-05 0.0 1.2406808035714285e-05 0.0 1.240736607142857e-05 1.5 1.24140625e-05 1.5 1.2414620535714284e-05 0.0 1.2424665178571427e-05 0.0 1.2425223214285714e-05 1.5 1.2431919642857142e-05 1.5 1.2432477678571428e-05 0.0 1.244252232142857e-05 0.0 1.2443080357142856e-05 1.5 1.2449776785714284e-05 1.5 1.245033482142857e-05 0.0 1.2460379464285714e-05 0.0 1.2460937499999999e-05 1.5 1.2467633928571428e-05 1.5 1.2468191964285713e-05 0.0 1.2478236607142856e-05 0.0 1.2478794642857141e-05 1.5 1.248549107142857e-05 1.5 1.2486049107142855e-05 0.0 1.2496093749999998e-05 0.0 1.2496651785714285e-05 1.5 1.2503348214285713e-05 1.5 1.250390625e-05 0.0 1.2513950892857142e-05 0.0 1.2514508928571427e-05 1.5 1.2521205357142857e-05 1.5 1.2521763392857142e-05 0.0 1.2531808035714285e-05 0.0 1.253236607142857e-05 1.5 1.2539062499999999e-05 1.5 1.2539620535714284e-05 0.0 1.2549665178571427e-05 0.0 1.2550223214285714e-05 1.5 1.2556919642857141e-05 1.5 1.2557477678571428e-05 0.0 1.2567522321428571e-05 0.0 1.2568080357142856e-05 1.5 1.2574776785714285e-05 1.5 1.257533482142857e-05 0.0 1.2585379464285713e-05 0.0 1.2585937499999998e-05 1.5 1.2592633928571428e-05 1.5 1.2593191964285713e-05 0.0 1.2603236607142856e-05 0.0 1.2603794642857142e-05 1.5 1.261049107142857e-05 1.5 1.2611049107142857e-05 0.0 1.262109375e-05 0.0 1.2621651785714285e-05 1.5 1.2628348214285714e-05 1.5 1.2628906249999999e-05 0.0 1.2638950892857142e-05 0.0 1.2639508928571427e-05 1.5 1.2646205357142856e-05 1.5 1.2646763392857141e-05 0.0 1.2656808035714284e-05 0.0 1.2657366071428571e-05 1.5 1.2664062499999999e-05 1.5 1.2664620535714285e-05 0.0 1.2674665178571428e-05 0.0 1.2675223214285713e-05 1.5 1.2681919642857143e-05 1.5 1.2682477678571428e-05 0.0 1.269252232142857e-05 0.0 1.2693080357142856e-05 1.5 1.2699776785714285e-05 1.5 1.270033482142857e-05 0.0 1.2710379464285713e-05 0.0 1.27109375e-05 1.5 1.2717633928571427e-05 1.5 1.2718191964285714e-05 0.0 1.2728236607142857e-05 0.0 1.2728794642857142e-05 1.5 1.2735491071428571e-05 1.5 1.2736049107142856e-05 0.0 1.274609375e-05 0.0 1.2746651785714284e-05 1.5 1.2753348214285714e-05 1.5 1.2753906249999999e-05 0.0 1.2763950892857142e-05 0.0 1.2764508928571428e-05 1.5 1.2771205357142856e-05 1.5 1.2771763392857143e-05 0.0 1.2781808035714284e-05 0.0 1.278236607142857e-05 1.5 1.2789062499999998e-05 1.5 1.2789620535714285e-05 0.0 1.2799665178571428e-05 0.0 1.2800223214285713e-05 1.5 1.2806919642857142e-05 1.5 1.2807477678571427e-05 0.0 1.281752232142857e-05 0.0 1.2818080357142855e-05 1.5 1.2824776785714285e-05 1.5 1.282533482142857e-05 0.0 1.2835379464285713e-05 0.0 1.28359375e-05 1.5 1.2842633928571427e-05 1.5 1.2843191964285714e-05 0.0 1.2853236607142857e-05 0.0 1.2853794642857142e-05 1.5 1.2860491071428571e-05 1.5 1.2861049107142856e-05 0.0 1.2871093749999999e-05 0.0 1.2871651785714284e-05 1.5 1.2878348214285713e-05 1.5 1.2878906249999998e-05 0.0 1.2888950892857141e-05 0.0 1.2889508928571428e-05 1.5 1.2896205357142856e-05 1.5 1.2896763392857142e-05 0.0 1.2906808035714285e-05 0.0 1.290736607142857e-05 1.5 1.29140625e-05 1.5 1.2914620535714285e-05 0.0 1.2924665178571428e-05 0.0 1.2925223214285713e-05 1.5 1.2931919642857142e-05 1.5 1.2932477678571427e-05 0.0 1.294252232142857e-05 0.0 1.2943080357142857e-05 1.5 1.2949776785714284e-05 1.5 1.2950334821428571e-05 0.0 1.2960379464285714e-05 0.0 1.2960937499999999e-05 1.5 1.2967633928571428e-05 1.5 1.2968191964285713e-05 0.0 1.2978236607142856e-05 0.0 1.2978794642857141e-05 1.5 1.298549107142857e-05 1.5 1.2986049107142856e-05 0.0 1.2996093749999999e-05 0.0 1.2996651785714285e-05 1.5 1.3003348214285713e-05 1.5 1.300390625e-05 0.0 1.3013950892857143e-05 0.0 1.3014508928571428e-05 1.5 1.3021205357142857e-05 1.5 1.3021763392857142e-05 0.0 1.3031808035714285e-05 0.0 1.303236607142857e-05 1.5 1.30390625e-05 1.5 1.3039620535714284e-05 0.0 1.3049665178571427e-05 0.0 1.3050223214285714e-05 1.5 1.3056919642857142e-05 1.5 1.3057477678571428e-05 0.0 1.306752232142857e-05 0.0 1.3068080357142856e-05 1.5 1.3074776785714284e-05 1.5 1.307533482142857e-05 0.0 1.3085379464285714e-05 0.0 1.3085937499999999e-05 1.5 1.3092633928571428e-05 1.5 1.3093191964285713e-05 0.0 1.3103236607142856e-05 0.0 1.3103794642857141e-05 1.5 1.311049107142857e-05 1.5 1.3111049107142857e-05 0.0 1.3121093749999998e-05 0.0 1.3121651785714285e-05 1.5 1.3128348214285713e-05 1.5 1.312890625e-05 0.0 1.3138950892857142e-05 0.0 1.3139508928571427e-05 1.5 1.3146205357142857e-05 1.5 1.3146763392857142e-05 0.0 1.3156808035714285e-05 0.0 1.315736607142857e-05 1.5 1.3164062499999999e-05 1.5 1.3164620535714284e-05 0.0 1.3174665178571427e-05 0.0 1.3175223214285714e-05 1.5 1.3181919642857141e-05 1.5 1.3182477678571428e-05 0.0 1.3192522321428571e-05 0.0 1.3193080357142856e-05 1.5 1.3199776785714285e-05 1.5 1.320033482142857e-05 0.0 1.3210379464285713e-05 0.0 1.3210937499999998e-05 1.5 1.3217633928571428e-05 1.5 1.3218191964285713e-05 0.0 1.3228236607142856e-05 0.0 1.3228794642857142e-05 1.5 1.323549107142857e-05 1.5 1.3236049107142857e-05 0.0 1.324609375e-05 0.0 1.3246651785714285e-05 1.5 1.3253348214285714e-05 1.5 1.3253906249999999e-05 0.0 1.3263950892857142e-05 0.0 1.3264508928571427e-05 1.5 1.3271205357142856e-05 1.5 1.3271763392857141e-05 0.0 1.3281808035714284e-05 0.0 1.3282366071428571e-05 1.5 1.3289062499999999e-05 1.5 1.3289620535714285e-05 0.0 1.3299665178571428e-05 0.0 1.3300223214285713e-05 1.5 1.3306919642857143e-05 1.5 1.3307477678571428e-05 0.0 1.331752232142857e-05 0.0 1.3318080357142856e-05 1.5 1.3324776785714285e-05 1.5 1.332533482142857e-05 0.0 1.3335379464285713e-05 0.0 1.33359375e-05 1.5 1.3342633928571427e-05 1.5 1.3343191964285714e-05 0.0 1.3353236607142857e-05 0.0 1.3353794642857142e-05 1.5 1.3360491071428571e-05 1.5 1.3361049107142856e-05 0.0 1.337109375e-05 0.0 1.3371651785714284e-05 1.5 1.3378906249999999e-05 1.5 1.3379464285714285e-05 0.0 1.3388392857142857e-05 0.0 1.3388950892857142e-05 1.5 1.3396763392857143e-05 1.5 1.3397321428571428e-05 0.0 1.3406249999999999e-05 0.0 1.3406808035714284e-05 1.5 1.3414620535714285e-05 1.5 1.341517857142857e-05 0.0 1.3424107142857141e-05 0.0 1.3424665178571428e-05 1.5 1.3432477678571427e-05 1.5 1.3433035714285714e-05 0.0 1.3441964285714285e-05 0.0 1.344252232142857e-05 1.5 1.345033482142857e-05 1.5 1.3450892857142856e-05 0.0 1.3459821428571428e-05 0.0 1.3460379464285713e-05 1.5 1.3468191964285714e-05 1.5 1.3468749999999999e-05 0.0 1.347767857142857e-05 0.0 1.3478236607142857e-05 1.5 1.3486049107142856e-05 1.5 1.3486607142857141e-05 0.0 1.3495535714285714e-05 0.0 1.3496093749999999e-05 1.5 1.3503906249999998e-05 1.5 1.3504464285714285e-05 0.0 1.3513392857142856e-05 0.0 1.3513950892857141e-05 1.5 1.3521763392857142e-05 1.5 1.3522321428571427e-05 0.0 1.3531249999999999e-05 0.0 1.3531808035714285e-05 1.5 1.3539620535714285e-05 1.5 1.354017857142857e-05 0.0 1.3549107142857143e-05 0.0 1.3549665178571428e-05 1.5 1.3557477678571427e-05 1.5 1.3558035714285714e-05 0.0 1.3566964285714285e-05 0.0 1.356752232142857e-05 1.5 1.3575334821428571e-05 1.5 1.3575892857142856e-05 0.0 1.3584821428571427e-05 0.0 1.3585379464285714e-05 1.5 1.3593191964285713e-05 1.5 1.3593749999999998e-05 0.0 1.3602678571428571e-05 0.0 1.3603236607142856e-05 1.5 1.3611049107142856e-05 1.5 1.3611607142857142e-05 0.0 1.3620535714285714e-05 0.0 1.3621093749999999e-05 1.5 1.362890625e-05 1.5 1.3629464285714285e-05 0.0 1.3638392857142856e-05 0.0 1.3638950892857143e-05 1.5 1.3646763392857142e-05 1.5 1.3647321428571427e-05 0.0 1.3656249999999998e-05 0.0 1.3656808035714285e-05 1.5 1.3664620535714284e-05 1.5 1.3665178571428571e-05 0.0 1.3674107142857142e-05 0.0 1.3674665178571427e-05 1.5 1.3682477678571428e-05 1.5 1.3683035714285713e-05 0.0 1.3691964285714285e-05 0.0 1.369252232142857e-05 1.5 1.370033482142857e-05 1.5 1.3700892857142856e-05 0.0 1.3709821428571427e-05 0.0 1.3710379464285714e-05 1.5 1.3718191964285713e-05 1.5 1.371875e-05 0.0 1.3727678571428571e-05 0.0 1.3728236607142856e-05 1.5 1.3736049107142857e-05 1.5 1.3736607142857142e-05 0.0 1.3745535714285713e-05 0.0 1.3746093749999998e-05 1.5 1.375390625e-05 1.5 1.3754464285714284e-05 0.0 1.3763392857142856e-05 0.0 1.3763950892857142e-05 1.5 1.3771763392857142e-05 1.5 1.3772321428571428e-05 0.0 1.378125e-05 0.0 1.3781808035714285e-05 1.5 1.3789620535714284e-05 1.5 1.379017857142857e-05 0.0 1.3799107142857142e-05 0.0 1.3799665178571427e-05 1.5 1.3807477678571428e-05 1.5 1.3808035714285713e-05 0.0 1.3816964285714284e-05 0.0 1.3817522321428571e-05 1.5 1.382533482142857e-05 1.5 1.3825892857142855e-05 0.0 1.3834821428571428e-05 0.0 1.3835379464285713e-05 1.5 1.3843191964285713e-05 1.5 1.384375e-05 0.0 1.385267857142857e-05 0.0 1.3853236607142856e-05 1.5 1.3861049107142857e-05 1.5 1.3861607142857142e-05 0.0 1.3870535714285713e-05 0.0 1.387109375e-05 1.5 1.3878906249999999e-05 1.5 1.3879464285714284e-05 0.0 1.3888392857142857e-05 0.0 1.3888950892857142e-05 1.5 1.3896763392857141e-05 1.5 1.3897321428571428e-05 0.0 1.390625e-05 0.0 1.3906808035714284e-05 1.5 1.3914620535714285e-05 1.5 1.391517857142857e-05 0.0 1.3924107142857142e-05 0.0 1.3924665178571428e-05 1.5 1.3932477678571428e-05 1.5 1.3933035714285713e-05 0.0 1.3941964285714286e-05 0.0 1.394252232142857e-05 1.5 1.395033482142857e-05 1.5 1.3950892857142857e-05 0.0 1.3959821428571428e-05 0.0 1.3960379464285713e-05 1.5 1.3968191964285714e-05 1.5 1.3968749999999999e-05 0.0 1.397767857142857e-05 0.0 1.3978236607142857e-05 1.5 1.3986049107142856e-05 1.5 1.3986607142857141e-05 0.0 1.3995535714285713e-05 0.0 1.399609375e-05 1.5 1.4003906249999999e-05 1.5 1.4004464285714285e-05 0.0 1.4013392857142857e-05 0.0 1.4013950892857142e-05 1.5 1.4021763392857143e-05 1.5 1.4022321428571428e-05 0.0 1.4031249999999999e-05 0.0 1.4031808035714284e-05 1.5 1.4039620535714285e-05 1.5 1.404017857142857e-05 0.0 1.4048549107142856e-05 0.0 1.4049107142857141e-05 1.5 1.4058035714285714e-05 1.5 1.4058593749999999e-05 0.0 1.4066406249999998e-05 0.0 1.4066964285714285e-05 1.5 1.4075892857142856e-05 1.5 1.4076450892857141e-05 0.0 1.4084263392857142e-05 0.0 1.4084821428571428e-05 1.5 1.4093749999999999e-05 1.5 1.4094308035714285e-05 0.0 1.4102120535714285e-05 0.0 1.410267857142857e-05 1.5 1.4111607142857141e-05 1.5 1.4112165178571428e-05 0.0 1.4119977678571427e-05 0.0 1.4120535714285714e-05 1.5 1.4129464285714285e-05 1.5 1.413002232142857e-05 0.0 1.4137834821428571e-05 0.0 1.4138392857142856e-05 1.5 1.4147321428571427e-05 1.5 1.4147879464285714e-05 0.0 1.4155691964285713e-05 0.0 1.4156249999999999e-05 1.5 1.416517857142857e-05 1.5 1.4165736607142856e-05 0.0 1.4173549107142856e-05 0.0 1.4174107142857143e-05 1.5 1.4183035714285714e-05 1.5 1.4183593749999999e-05 0.0 1.419140625e-05 0.0 1.4191964285714285e-05 1.5 1.4200892857142856e-05 1.5 1.4201450892857141e-05 0.0 1.4209263392857142e-05 0.0 1.4209821428571427e-05 1.5 1.4218749999999998e-05 1.5 1.4219308035714285e-05 0.0 1.4227120535714284e-05 0.0 1.4227678571428571e-05 1.5 1.4236607142857142e-05 1.5 1.4237165178571427e-05 0.0 1.4244977678571427e-05 0.0 1.4245535714285714e-05 1.5 1.4254464285714285e-05 1.5 1.425502232142857e-05 0.0 1.426283482142857e-05 0.0 1.4263392857142856e-05 1.5 1.4272321428571427e-05 1.5 1.4272879464285714e-05 0.0 1.4280691964285713e-05 0.0 1.4281249999999998e-05 1.5 1.4290178571428571e-05 1.5 1.4290736607142856e-05 0.0 1.4298549107142855e-05 0.0 1.4299107142857142e-05 1.5 1.4308035714285713e-05 1.5 1.4308593749999998e-05 0.0 1.431640625e-05 0.0 1.4316964285714284e-05 1.5 1.4325892857142856e-05 1.5 1.4326450892857142e-05 0.0 1.4334263392857142e-05 0.0 1.4334821428571427e-05 1.5 1.434375e-05 1.5 1.4344308035714285e-05 0.0 1.4352120535714284e-05 0.0 1.435267857142857e-05 1.5 1.4361607142857142e-05 1.5 1.4362165178571427e-05 0.0 1.4369977678571428e-05 0.0 1.4370535714285713e-05 1.5 1.4379464285714284e-05 1.5 1.4380022321428571e-05 0.0 1.438783482142857e-05 0.0 1.4388392857142855e-05 1.5 1.4397321428571428e-05 1.5 1.4397879464285713e-05 0.0 1.4405691964285713e-05 0.0 1.440625e-05 1.5 1.441517857142857e-05 1.5 1.4415736607142856e-05 0.0 1.4423549107142857e-05 0.0 1.4424107142857142e-05 1.5 1.4433035714285713e-05 1.5 1.443359375e-05 0.0 1.4441406249999999e-05 0.0 1.4441964285714284e-05 1.5 1.4450892857142855e-05 1.5 1.4451450892857142e-05 0.0 1.4459263392857141e-05 0.0 1.4459821428571428e-05 1.5 1.446875e-05 1.5 1.4469308035714284e-05 0.0 1.4477120535714285e-05 0.0 1.447767857142857e-05 1.5 1.4486607142857142e-05 1.5 1.4487165178571427e-05 0.0 1.4494977678571428e-05 0.0 1.4495535714285713e-05 1.5 1.4504464285714284e-05 1.5 1.450502232142857e-05 0.0 1.451283482142857e-05 0.0 1.4513392857142857e-05 1.5 1.4522321428571428e-05 1.5 1.4522879464285713e-05 0.0 1.4530691964285714e-05 0.0 1.4531249999999999e-05 1.5 1.454017857142857e-05 1.5 1.4540736607142855e-05 0.0 1.4548549107142856e-05 0.0 1.4549107142857141e-05 1.5 1.4558035714285713e-05 1.5 1.455859375e-05 0.0 1.4566406249999999e-05 0.0 1.4566964285714285e-05 1.5 1.4575892857142857e-05 1.5 1.4576450892857142e-05 0.0 1.4584263392857141e-05 0.0 1.4584821428571428e-05 1.5 1.4593749999999999e-05 1.5 1.4594308035714284e-05 0.0 1.4602120535714285e-05 0.0 1.460267857142857e-05 1.5 1.4611607142857141e-05 1.5 1.4612165178571428e-05 0.0 1.4619977678571427e-05 0.0 1.4620535714285712e-05 1.5 1.4629464285714285e-05 1.5 1.463002232142857e-05 0.0 1.463783482142857e-05 0.0 1.4638392857142856e-05 1.5 1.4647321428571428e-05 1.5 1.4647879464285713e-05 0.0 1.4655691964285714e-05 0.0 1.4656249999999999e-05 1.5 1.466517857142857e-05 1.5 1.4665736607142857e-05 0.0 1.4673549107142856e-05 0.0 1.4674107142857141e-05 1.5 1.4683035714285714e-05 1.5 1.4683593749999999e-05 0.0 1.4691406249999998e-05 0.0 1.4691964285714285e-05 1.5 1.4700892857142856e-05 1.5 1.4701450892857141e-05 0.0 1.4709263392857142e-05 0.0 1.4709821428571427e-05 1.5 1.4719308035714285e-05 1.5 1.471986607142857e-05 0.0 1.47265625e-05 0.0 1.4727120535714285e-05 1.5 1.4737165178571428e-05 1.5 1.4737723214285713e-05 0.0 1.4744419642857142e-05 0.0 1.4744977678571427e-05 1.5 1.475502232142857e-05 1.5 1.4755580357142857e-05 0.0 1.4762276785714284e-05 0.0 1.4762834821428571e-05 1.5 1.4772879464285714e-05 1.5 1.4773437499999999e-05 0.0 1.4780133928571428e-05 0.0 1.4780691964285713e-05 1.5 1.4790736607142856e-05 1.5 1.4791294642857141e-05 0.0 1.479799107142857e-05 0.0 1.4798549107142856e-05 1.5 1.4808593749999999e-05 1.5 1.4809151785714285e-05 0.0 1.4815848214285713e-05 0.0 1.481640625e-05 1.5 1.4826450892857141e-05 1.5 1.4827008928571428e-05 0.0 1.4833705357142855e-05 0.0 1.4834263392857142e-05 1.5 1.4844308035714285e-05 1.5 1.484486607142857e-05 0.0 1.48515625e-05 0.0 1.4852120535714284e-05 1.5 1.4862165178571427e-05 1.5 1.4862723214285712e-05 0.0 1.4869419642857142e-05 0.0 1.4869977678571427e-05 1.5 1.488002232142857e-05 1.5 1.4880580357142856e-05 0.0 1.4887276785714284e-05 0.0 1.488783482142857e-05 1.5 1.4897879464285714e-05 1.5 1.4898437499999999e-05 0.0 1.4905133928571428e-05 0.0 1.4905691964285713e-05 1.5 1.4915736607142856e-05 1.5 1.4916294642857141e-05 0.0 1.492299107142857e-05 0.0 1.4923549107142855e-05 1.5 1.4933593749999998e-05 1.5 1.4934151785714285e-05 0.0 1.4940848214285713e-05 0.0 1.494140625e-05 1.5 1.4951450892857142e-05 1.5 1.4952008928571427e-05 0.0 1.4958705357142857e-05 0.0 1.4959263392857142e-05 1.5 1.4969308035714285e-05 1.5 1.496986607142857e-05 0.0 1.4976562499999999e-05 0.0 1.4977120535714284e-05 1.5 1.4987165178571427e-05 1.5 1.4987723214285714e-05 0.0 1.4994419642857141e-05 0.0 1.4994977678571428e-05 1.5 1.5005022321428571e-05 1.5 1.5005580357142856e-05 0.0 1.5012276785714285e-05 0.0 1.501283482142857e-05 1.5 1.5022879464285713e-05 1.5 1.5023437499999998e-05 0.0 1.5030133928571428e-05 0.0 1.5030691964285713e-05 1.5 1.5040736607142856e-05 1.5 1.5041294642857142e-05 0.0 1.504799107142857e-05 0.0 1.5048549107142857e-05 1.5 1.505859375e-05 1.5 1.5059151785714285e-05 0.0 1.5065848214285714e-05 0.0 1.5066406249999999e-05 1.5 1.5076450892857142e-05 1.5 1.5077008928571427e-05 0.0 1.5083705357142856e-05 0.0 1.5084263392857141e-05 1.5 1.5094308035714284e-05 1.5 1.5094866071428571e-05 0.0 1.5101562499999999e-05 0.0 1.5102120535714285e-05 1.5 1.5112165178571427e-05 1.5 1.5112723214285713e-05 0.0 1.5119419642857141e-05 0.0 1.5119977678571428e-05 1.5 1.513002232142857e-05 1.5 1.5130580357142856e-05 0.0 1.5137276785714285e-05 0.0 1.513783482142857e-05 1.5 1.5147879464285713e-05 1.5 1.51484375e-05 0.0 1.5155133928571427e-05 0.0 1.5155691964285714e-05 1.5 1.5165736607142855e-05 1.5 1.5166294642857142e-05 0.0 1.517299107142857e-05 0.0 1.5173549107142856e-05 1.5 1.518359375e-05 1.5 1.5184151785714284e-05 0.0 1.5190848214285714e-05 0.0 1.5191406249999999e-05 1.5 1.5201450892857142e-05 1.5 1.5202008928571427e-05 0.0 1.5208705357142856e-05 0.0 1.5209263392857141e-05 1.5 1.5219308035714284e-05 1.5 1.521986607142857e-05 0.0 1.5226562499999998e-05 0.0 1.5227120535714285e-05 1.5 1.5237165178571428e-05 1.5 1.5237723214285713e-05 0.0 1.5244419642857142e-05 0.0 1.5244977678571427e-05 1.5 1.525502232142857e-05 1.5 1.5255580357142855e-05 0.0 1.5262276785714286e-05 0.0 1.526283482142857e-05 1.5 1.5272879464285714e-05 1.5 1.5273437499999998e-05 0.0 1.528013392857143e-05 0.0 1.5280691964285712e-05 1.5 1.5290736607142857e-05 1.5 1.5291294642857143e-05 0.0 1.529799107142857e-05 0.0 1.5298549107142858e-05 1.5 1.530859375e-05 1.5 1.5309151785714286e-05 0.0 1.5315848214285713e-05 0.0 1.531640625e-05 1.5 1.532645089285714e-05 1.5 1.5327008928571428e-05 0.0 1.5333705357142856e-05 0.0 1.5334263392857142e-05 1.5 1.5344308035714284e-05 1.5 1.534486607142857e-05 0.0 1.5351562499999998e-05 0.0 1.5352120535714285e-05 1.5 1.5362165178571426e-05 1.5 1.5362723214285713e-05 0.0 1.536941964285714e-05 0.0 1.5369977678571427e-05 1.5 1.538002232142857e-05 1.5 1.5380580357142855e-05 0.0 1.5387276785714286e-05 0.0 1.538783482142857e-05 1.5 1.5397879464285714e-05 1.5 1.5398437499999997e-05 0.0 1.5405133928571428e-05 0.0 1.540569196428571e-05 1.5 1.5415736607142856e-05 1.5 1.5416294642857143e-05 0.0 1.542299107142857e-05 0.0 1.5423549107142857e-05 1.5 1.543359375e-05 1.5 1.5434151785714285e-05 0.0 1.5440848214285713e-05 0.0 1.544140625e-05 1.5 1.545145089285714e-05 1.5 1.5452008928571428e-05 0.0 1.5458705357142855e-05 0.0 1.5459263392857142e-05 1.5 1.5469308035714283e-05 1.5 1.546986607142857e-05 0.0 1.5476562499999998e-05 0.0 1.5477120535714284e-05 1.5 1.548716517857143e-05 1.5 1.5487723214285712e-05 0.0 1.5494419642857143e-05 0.0 1.5494977678571427e-05 1.5 1.550502232142857e-05 1.5 1.5505580357142855e-05 0.0 1.5512276785714286e-05 0.0 1.551283482142857e-05 1.5 1.5522879464285714e-05 1.5 1.55234375e-05 0.0 1.5530133928571428e-05 0.0 1.5530691964285715e-05 1.5 1.5540736607142856e-05 1.5 1.5541294642857143e-05 0.0 1.554799107142857e-05 0.0 1.5548549107142857e-05 1.5 1.5558593749999998e-05 1.5 1.5559151785714285e-05 0.0 1.5565848214285713e-05 0.0 1.556640625e-05 1.5 1.557645089285714e-05 1.5 1.5577008928571427e-05 0.0 1.5583705357142855e-05 0.0 1.558426339285714e-05 1.5 1.5594308035714283e-05 1.5 1.559486607142857e-05 0.0 1.5601562499999997e-05 0.0 1.5602120535714284e-05 1.5 1.561216517857143e-05 1.5 1.5612723214285712e-05 0.0 1.5619419642857143e-05 0.0 1.5619977678571426e-05 1.5 1.563002232142857e-05 1.5 1.5630580357142854e-05 0.0 1.5637276785714285e-05 0.0 1.563783482142857e-05 1.5 1.5647879464285713e-05 1.5 1.56484375e-05 0.0 1.5655133928571428e-05 0.0 1.5655691964285714e-05 1.5 1.5665736607142856e-05 1.5 1.5666294642857142e-05 0.0 1.567299107142857e-05 0.0 1.5673549107142857e-05 1.5 1.5683593749999998e-05 1.5 1.5684151785714285e-05 0.0 1.5690848214285712e-05 0.0 1.569140625e-05 1.5 1.570145089285714e-05 1.5 1.5702008928571427e-05 0.0 1.5708705357142855e-05 0.0 1.570926339285714e-05 1.5 1.5719308035714286e-05 1.5 1.571986607142857e-05 0.0 1.57265625e-05 0.0 1.5727120535714284e-05 1.5 1.5737165178571428e-05 1.5 1.573772321428571e-05 0.0 1.5744419642857143e-05 0.0 1.5744977678571426e-05 1.5 1.575502232142857e-05 1.5 1.5755580357142857e-05 0.0 1.5762276785714285e-05 0.0 1.576283482142857e-05 1.5 1.5772879464285713e-05 1.5 1.57734375e-05 0.0 1.5780133928571427e-05 0.0 1.5780691964285714e-05 1.5 1.5790736607142855e-05 1.5 1.5791294642857142e-05 0.0 1.579799107142857e-05 0.0 1.5798549107142856e-05 1.5 1.5808593749999998e-05 1.5 1.5809151785714284e-05 0.0 1.5815848214285712e-05 0.0 1.581640625e-05 1.5 1.5826450892857143e-05 1.5 1.5827008928571427e-05 0.0 1.5833705357142858e-05 0.0 1.583426339285714e-05 1.5 1.5844308035714286e-05 1.5 1.584486607142857e-05 0.0 1.58515625e-05 0.0 1.5852120535714283e-05 1.5 1.5862165178571428e-05 1.5 1.5862723214285715e-05 0.0 1.5869419642857142e-05 0.0 1.586997767857143e-05 1.5 1.588002232142857e-05 1.5 1.5880580357142857e-05 0.0 1.5887276785714285e-05 0.0 1.588783482142857e-05 1.5 1.5897879464285713e-05 1.5 1.58984375e-05 0.0 1.5905133928571427e-05 0.0 1.5905691964285714e-05 1.5 1.5915736607142855e-05 1.5 1.591629464285714e-05 0.0 1.592299107142857e-05 0.0 1.5923549107142856e-05 1.5 1.5933593749999997e-05 1.5 1.5934151785714284e-05 0.0 1.594084821428571e-05 0.0 1.5941406249999998e-05 1.5 1.5951450892857143e-05 1.5 1.5952008928571426e-05 0.0 1.5958705357142857e-05 0.0 1.595926339285714e-05 1.5 1.5969308035714285e-05 1.5 1.596986607142857e-05 0.0 1.59765625e-05 0.0 1.5977120535714283e-05 1.5 1.5987165178571428e-05 1.5 1.5987723214285714e-05 0.0 1.5994419642857142e-05 0.0 1.599497767857143e-05 1.5 1.600502232142857e-05 1.5 1.6005580357142857e-05 0.0 1.6012276785714284e-05 0.0 1.601283482142857e-05 1.5 1.6022879464285712e-05 1.5 1.60234375e-05 0.0 1.6030133928571427e-05 0.0 1.6030691964285713e-05 1.5 1.6040736607142855e-05 1.5 1.604129464285714e-05 0.0 1.604799107142857e-05 0.0 1.6048549107142856e-05 1.5 1.605859375e-05 1.5 1.6059151785714284e-05 0.0 1.6065848214285715e-05 0.0 1.6066406249999998e-05 1.5 1.6076450892857143e-05 1.5 1.6077008928571426e-05 0.0 1.6083705357142857e-05 0.0 1.608426339285714e-05 1.5 1.6094308035714285e-05 1.5 1.609486607142857e-05 0.0 1.61015625e-05 0.0 1.6102120535714286e-05 1.5 1.6112165178571427e-05 1.5 1.6112723214285714e-05 0.0 1.611941964285714e-05 0.0 1.6119977678571428e-05 1.5 1.613002232142857e-05 1.5 1.6130580357142856e-05 0.0 1.6137276785714284e-05 0.0 1.613783482142857e-05 1.5 1.6147879464285712e-05 1.5 1.61484375e-05 0.0 1.6155133928571426e-05 0.0 1.6155691964285713e-05 1.5 1.6165736607142858e-05 1.5 1.616629464285714e-05 0.0 1.6172991071428572e-05 0.0 1.6173549107142855e-05 1.5 1.618359375e-05 1.5 1.6184151785714283e-05 0.0 1.6190848214285714e-05 0.0 1.6191406249999998e-05 1.5 1.6201450892857142e-05 1.5 1.620200892857143e-05 0.0 1.6208705357142857e-05 0.0 1.6209263392857143e-05 1.5 1.6219308035714285e-05 1.5 1.621986607142857e-05 0.0 1.62265625e-05 0.0 1.6227120535714286e-05 1.5 1.6237165178571427e-05 1.5 1.6237723214285714e-05 0.0 1.624441964285714e-05 0.0 1.6244977678571428e-05 1.5 1.625502232142857e-05 1.5 1.6255580357142856e-05 0.0 1.6262276785714284e-05 0.0 1.626283482142857e-05 1.5 1.627287946428571e-05 1.5 1.6273437499999998e-05 0.0 1.6280133928571426e-05 0.0 1.6280691964285713e-05 1.5 1.6290736607142857e-05 1.5 1.629129464285714e-05 0.0 1.629799107142857e-05 0.0 1.6298549107142855e-05 1.5 1.630859375e-05 1.5 1.6309151785714283e-05 0.0 1.6315848214285714e-05 0.0 1.6316406249999997e-05 1.5 1.6326450892857142e-05 1.5 1.632700892857143e-05 0.0 1.6333705357142856e-05 0.0 1.6334263392857143e-05 1.5 1.6344308035714284e-05 1.5 1.634486607142857e-05 0.0 1.63515625e-05 0.0 1.6352120535714285e-05 1.5 1.6362165178571427e-05 1.5 1.6362723214285713e-05 0.0 1.636941964285714e-05 0.0 1.6369977678571428e-05 1.5 1.638002232142857e-05 1.5 1.6380580357142856e-05 0.0 1.6387276785714283e-05 0.0 1.638783482142857e-05 1.5 1.6397879464285715e-05 1.5 1.6398437499999998e-05 0.0 1.640513392857143e-05 0.0 1.6405691964285712e-05 1.5 1.6415736607142857e-05 1.5 1.641629464285714e-05 0.0 1.642299107142857e-05 0.0 1.6423549107142855e-05 1.5 1.643359375e-05 1.5 1.6434151785714286e-05 0.0 1.6440848214285714e-05 0.0 1.644140625e-05 1.5 1.645145089285714e-05 1.5 1.645200892857143e-05 0.0 1.6458705357142856e-05 0.0 1.6459263392857143e-05 1.5 1.6469308035714284e-05 1.5 1.646986607142857e-05 0.0 1.6476562499999998e-05 0.0 1.6477120535714285e-05 1.5 1.6487165178571426e-05 1.5 1.6487723214285713e-05 0.0 1.649441964285714e-05 0.0 1.6494977678571427e-05 1.5 1.6505022321428572e-05 1.5 1.6505580357142855e-05 0.0 1.6512276785714286e-05 0.0 1.651283482142857e-05 1.5 1.6522879464285714e-05 1.5 1.6523437499999998e-05 0.0 1.653013392857143e-05 0.0 1.6530691964285712e-05 1.5 1.6540736607142857e-05 1.5 1.6541294642857143e-05 0.0 1.654799107142857e-05 0.0 1.6548549107142858e-05 1.5 1.655859375e-05 1.5 1.6559151785714286e-05 0.0 1.6565848214285713e-05 0.0 1.656640625e-05 1.5 1.657645089285714e-05 1.5 1.6577008928571428e-05 0.0 1.6583705357142855e-05 0.0 1.6584263392857142e-05 1.5 1.6594308035714284e-05 1.5 1.659486607142857e-05 0.0 1.6601562499999998e-05 0.0 1.6602120535714285e-05 1.5 1.6612165178571426e-05 1.5 1.6612723214285713e-05 0.0 1.661941964285714e-05 0.0 1.6619977678571427e-05 1.5 1.663002232142857e-05 1.5 1.6630580357142855e-05 0.0 1.6637276785714286e-05 0.0 1.663783482142857e-05 1.5 1.6647879464285714e-05 1.5 1.6648437499999997e-05 0.0 1.6655133928571428e-05 0.0 1.665569196428571e-05 1.5 1.6665736607142856e-05 1.5 1.6666294642857143e-05 0.0 1.667299107142857e-05 0.0 1.6673549107142857e-05 1.5 1.668359375e-05 1.5 1.6684151785714285e-05 0.0 1.6690848214285713e-05 0.0 1.669140625e-05 1.5 1.670145089285714e-05 1.5 1.6702008928571428e-05 0.0 1.6708705357142855e-05 0.0 1.6709263392857142e-05 1.5 1.6719308035714283e-05 1.5 1.671986607142857e-05 0.0 1.6726562499999997e-05 0.0 1.6727120535714284e-05 1.5 1.673716517857143e-05 1.5 1.6737723214285712e-05 0.0 1.6744419642857143e-05 0.0 1.6744977678571427e-05 1.5 1.675502232142857e-05 1.5 1.6755580357142855e-05 0.0 1.6762276785714285e-05 0.0 1.676283482142857e-05 1.5 1.6772879464285714e-05 1.5 1.67734375e-05 0.0 1.6780133928571428e-05 0.0 1.6780691964285715e-05 1.5 1.6790736607142856e-05 1.5 1.6791294642857143e-05 0.0 1.679799107142857e-05 0.0 1.6798549107142857e-05 1.5 1.6808593749999998e-05 1.5 1.6809151785714285e-05 0.0 1.6815848214285712e-05 0.0 1.681640625e-05 1.5 1.682645089285714e-05 1.5 1.6827008928571427e-05 0.0 1.6833705357142855e-05 0.0 1.683426339285714e-05 1.5 1.6844308035714283e-05 1.5 1.684486607142857e-05 0.0 1.6851562499999997e-05 0.0 1.6852120535714284e-05 1.5 1.686216517857143e-05 1.5 1.6862723214285712e-05 0.0 1.6869419642857143e-05 0.0 1.6869977678571426e-05 1.5 1.688002232142857e-05 1.5 1.6880580357142858e-05 0.0 1.6887276785714285e-05 0.0 1.6887834821428572e-05 1.5 1.6897879464285713e-05 1.5 1.68984375e-05 0.0 1.6905133928571427e-05 0.0 1.6905691964285714e-05 1.5 1.6915736607142856e-05 1.5 1.6916294642857142e-05 0.0 1.692299107142857e-05 0.0 1.6923549107142857e-05 1.5 1.6933593749999998e-05 1.5 1.6934151785714285e-05 0.0 1.6940848214285712e-05 0.0 1.694140625e-05 1.5 1.695145089285714e-05 1.5 1.6952008928571427e-05 0.0 1.6958705357142854e-05 0.0 1.695926339285714e-05 1.5 1.6969308035714286e-05 1.5 1.696986607142857e-05 0.0 1.69765625e-05 0.0 1.6977120535714284e-05 1.5 1.6987165178571428e-05 1.5 1.698772321428571e-05 0.0 1.6994419642857142e-05 0.0 1.6994977678571426e-05 1.5 1.700502232142857e-05 1.5 1.7005580357142857e-05 0.0 1.7012276785714285e-05 0.0 1.701283482142857e-05 1.5 1.7022879464285713e-05 1.5 1.70234375e-05 0.0 1.7030133928571427e-05 0.0 1.7030691964285714e-05 1.5 1.7040736607142855e-05 1.5 1.7041294642857142e-05 0.0 1.704799107142857e-05 0.0 1.7048549107142856e-05 1.5 1.7058593749999997e-05 1.5 1.7059151785714284e-05 0.0 1.7065848214285712e-05 0.0 1.706640625e-05 1.5 1.7076450892857143e-05 1.5 1.7077008928571427e-05 0.0 1.7083705357142857e-05 0.0 1.708426339285714e-05 1.5 1.7094308035714286e-05 1.5 1.709486607142857e-05 0.0 1.71015625e-05 0.0 1.7102120535714283e-05 1.5 1.7112165178571428e-05 1.5 1.7112723214285715e-05 0.0 1.7119419642857142e-05 0.0 1.711997767857143e-05 1.5 1.713002232142857e-05 1.5 1.7130580357142857e-05 0.0 1.7137276785714284e-05 0.0 1.713783482142857e-05 1.5 1.7147879464285712e-05 1.5 1.71484375e-05 0.0 1.7155133928571427e-05 0.0 1.7155691964285714e-05 1.5 1.7165736607142855e-05 1.5 1.716629464285714e-05 0.0 1.717299107142857e-05 0.0 1.7173549107142856e-05 1.5 1.7183593749999997e-05 1.5 1.7184151785714284e-05 0.0 1.719084821428571e-05 0.0 1.7191406249999998e-05 1.5 1.7201450892857143e-05 1.5 1.7202008928571426e-05 0.0 1.7208705357142857e-05 0.0 1.720926339285714e-05 1.5 1.7219308035714285e-05 1.5 1.721986607142857e-05 0.0 1.72265625e-05 0.0 1.7227120535714283e-05 1.5 1.7237165178571427e-05 1.5 1.7237723214285714e-05 0.0 1.7244419642857142e-05 0.0 1.724497767857143e-05 1.5 1.725502232142857e-05 1.5 1.7255580357142857e-05 0.0 1.7262276785714284e-05 0.0 1.726283482142857e-05 1.5 1.7272879464285712e-05 1.5 1.72734375e-05 0.0 1.7280133928571426e-05 0.0 1.7280691964285713e-05 1.5 1.7290736607142854e-05 1.5 1.729129464285714e-05 0.0 1.729799107142857e-05 0.0 1.7298549107142855e-05 1.5 1.730859375e-05 1.5 1.7309151785714284e-05 0.0 1.7315848214285714e-05 0.0 1.7316406249999998e-05 1.5 1.7326450892857142e-05 1.5 1.7327008928571426e-05 0.0 1.7333705357142857e-05 0.0 1.733426339285714e-05 1.5 1.7344308035714285e-05 1.5 1.734486607142857e-05 0.0 1.73515625e-05 0.0 1.7352120535714286e-05 1.5 1.7362165178571427e-05 1.5 1.7362723214285714e-05 0.0 1.736941964285714e-05 0.0 1.7369977678571428e-05 1.5 1.738002232142857e-05 1.5 1.7380580357142856e-05 0.0 1.7387276785714284e-05 0.0 1.738783482142857e-05 1.5 1.739732142857143e-05 1.5 1.7397879464285712e-05 0.0 1.7405691964285713e-05 0.0 1.740625e-05 1.5 1.741517857142857e-05 1.5 1.7415736607142857e-05 0.0 1.7423549107142855e-05 0.0 1.7424107142857142e-05 1.5 1.7433035714285713e-05 1.5 1.743359375e-05 0.0 1.7441406249999997e-05 0.0 1.7441964285714284e-05 1.5 1.7450892857142855e-05 1.5 1.7451450892857142e-05 0.0 1.7459263392857143e-05 0.0 1.7459821428571427e-05 1.5 1.7468749999999998e-05 1.5 1.7469308035714284e-05 0.0 1.7477120535714286e-05 0.0 1.747767857142857e-05 1.5 1.748660714285714e-05 1.5 1.7487165178571427e-05 0.0 1.7494977678571428e-05 0.0 1.7495535714285715e-05 1.5 1.7504464285714286e-05 1.5 1.750502232142857e-05 0.0 1.751283482142857e-05 0.0 1.7513392857142857e-05 1.5 1.7522321428571428e-05 1.5 1.752287946428571e-05 0.0 1.7530691964285712e-05 0.0 1.753125e-05 1.5 1.754017857142857e-05 1.5 1.7540736607142857e-05 0.0 1.7548549107142855e-05 0.0 1.754910714285714e-05 1.5 1.7558035714285713e-05 1.5 1.755859375e-05 0.0 1.7566406249999997e-05 0.0 1.7566964285714284e-05 1.5 1.7575892857142855e-05 1.5 1.7576450892857142e-05 0.0 1.7584263392857143e-05 0.0 1.7584821428571426e-05 1.5 1.7593749999999997e-05 1.5 1.7594308035714284e-05 0.0 1.7602120535714285e-05 0.0 1.760267857142857e-05 1.5 1.7611607142857143e-05 1.5 1.7612165178571426e-05 0.0 1.7619977678571427e-05 0.0 1.7620535714285714e-05 1.5 1.7629464285714285e-05 1.5 1.763002232142857e-05 0.0 1.763783482142857e-05 0.0 1.7638392857142857e-05 1.5 1.7647321428571428e-05 1.5 1.7647879464285714e-05 0.0 1.7655691964285712e-05 0.0 1.765625e-05 1.5 1.766517857142857e-05 1.5 1.7665736607142857e-05 0.0 1.7673549107142854e-05 0.0 1.767410714285714e-05 1.5 1.7683035714285712e-05 1.5 1.768359375e-05 0.0 1.769140625e-05 0.0 1.7691964285714284e-05 1.5 1.7700892857142855e-05 1.5 1.770145089285714e-05 0.0 1.7709263392857142e-05 0.0 1.7709821428571426e-05 1.5 1.771875e-05 1.5 1.7719308035714284e-05 0.0 1.7727120535714285e-05 0.0 1.772767857142857e-05 1.5 1.7736607142857143e-05 1.5 1.7737165178571426e-05 0.0 1.7744977678571427e-05 0.0 1.7745535714285714e-05 1.5 1.7754464285714285e-05 1.5 1.7755022321428572e-05 0.0 1.776283482142857e-05 0.0 1.7763392857142856e-05 1.5 1.7772321428571427e-05 1.5 1.7772879464285714e-05 0.0 1.7780691964285712e-05 0.0 1.778125e-05 1.5 1.779017857142857e-05 1.5 1.7790736607142856e-05 0.0 1.7798549107142857e-05 0.0 1.779910714285714e-05 1.5 1.7808035714285712e-05 1.5 1.780859375e-05 0.0 1.781640625e-05 0.0 1.7816964285714283e-05 1.5 1.7825892857142854e-05 1.5 1.782645089285714e-05 0.0 1.7834263392857142e-05 0.0 1.783482142857143e-05 1.5 1.784375e-05 1.5 1.7844308035714283e-05 0.0 1.7852120535714284e-05 0.0 1.785267857142857e-05 1.5 1.7861607142857142e-05 1.5 1.7862165178571426e-05 0.0 1.7869977678571427e-05 0.0 1.7870535714285714e-05 1.5 1.7879464285714285e-05 1.5 1.788002232142857e-05 0.0 1.788783482142857e-05 0.0 1.7888392857142856e-05 1.5 1.7897321428571427e-05 1.5 1.7897879464285714e-05 0.0 1.790569196428571e-05 0.0 1.7906249999999998e-05 1.5 1.791517857142857e-05 1.5 1.7915736607142856e-05 0.0 1.7923549107142857e-05 0.0 1.792410714285714e-05 1.5 1.793303571428571e-05 1.5 1.793359375e-05 0.0 1.794140625e-05 0.0 1.7941964285714283e-05 1.5 1.7950892857142857e-05 1.5 1.795145089285714e-05 0.0 1.7959263392857142e-05 0.0 1.795982142857143e-05 1.5 1.796875e-05 1.5 1.7969308035714283e-05 0.0 1.7977120535714284e-05 0.0 1.797767857142857e-05 1.5 1.7986607142857142e-05 1.5 1.798716517857143e-05 0.0 1.7994977678571426e-05 0.0 1.7995535714285713e-05 1.5 1.8004464285714284e-05 1.5 1.800502232142857e-05 0.0 1.801283482142857e-05 0.0 1.8013392857142856e-05 1.5 1.8022321428571427e-05 1.5 1.8022879464285713e-05 0.0 1.8030691964285714e-05 0.0 1.8031249999999998e-05 1.5 1.804017857142857e-05 1.5 1.8040736607142856e-05 0.0 1.8048549107142857e-05 0.0 1.804910714285714e-05 1.5 1.8057477678571428e-05 1.5 1.805803571428571e-05 0.0 1.8066964285714286e-05 0.0 1.806752232142857e-05 1.5 1.807533482142857e-05 1.5 1.8075892857142857e-05 0.0 1.8084821428571428e-05 0.0 1.808537946428571e-05 1.5 1.8093191964285713e-05 1.5 1.809375e-05 0.0 1.810267857142857e-05 0.0 1.8103236607142857e-05 1.5 1.8111049107142855e-05 1.5 1.811160714285714e-05 0.0 1.8120535714285713e-05 0.0 1.812109375e-05 1.5 1.8128906249999997e-05 1.5 1.8129464285714284e-05 0.0 1.8138392857142855e-05 0.0 1.8138950892857142e-05 1.5 1.8146763392857143e-05 1.5 1.8147321428571426e-05 0.0 1.8156249999999997e-05 0.0 1.8156808035714284e-05 1.5 1.8164620535714285e-05 1.5 1.816517857142857e-05 0.0 1.8174107142857143e-05 0.0 1.8174665178571427e-05 1.5 1.8182477678571428e-05 1.5 1.8183035714285714e-05 0.0 1.8191964285714286e-05 0.0 1.819252232142857e-05 1.5 1.820033482142857e-05 1.5 1.8200892857142857e-05 0.0 1.8209821428571428e-05 0.0 1.8210379464285715e-05 1.5 1.8218191964285712e-05 1.5 1.821875e-05 0.0 1.822767857142857e-05 0.0 1.8228236607142857e-05 1.5 1.8236049107142855e-05 1.5 1.823660714285714e-05 0.0 1.8245535714285712e-05 0.0 1.824609375e-05 1.5 1.825390625e-05 1.5 1.8254464285714284e-05 0.0 1.8263392857142855e-05 0.0 1.826395089285714e-05 1.5 1.8271763392857143e-05 1.5 1.8272321428571426e-05 0.0 1.8281249999999997e-05 0.0 1.8281808035714284e-05 1.5 1.8289620535714285e-05 1.5 1.829017857142857e-05 0.0 1.8299107142857143e-05 0.0 1.8299665178571426e-05 1.5 1.8307477678571427e-05 1.5 1.8308035714285714e-05 0.0 1.8316964285714285e-05 0.0 1.831752232142857e-05 1.5 1.832533482142857e-05 1.5 1.8325892857142856e-05 0.0 1.8334821428571427e-05 0.0 1.8335379464285714e-05 1.5 1.8343191964285712e-05 1.5 1.834375e-05 0.0 1.835267857142857e-05 0.0 1.8353236607142857e-05 1.5 1.8361049107142854e-05 1.5 1.836160714285714e-05 0.0 1.8370535714285712e-05 0.0 1.837109375e-05 1.5 1.837890625e-05 1.5 1.8379464285714283e-05 0.0 1.8388392857142854e-05 0.0 1.838895089285714e-05 1.5 1.8396763392857142e-05 1.5 1.8397321428571426e-05 0.0 1.840625e-05 0.0 1.8406808035714284e-05 1.5 1.8414620535714285e-05 1.5 1.841517857142857e-05 0.0 1.8424107142857142e-05 0.0 1.8424665178571426e-05 1.5 1.8432477678571427e-05 1.5 1.8433035714285714e-05 0.0 1.8441964285714285e-05 0.0 1.844252232142857e-05 1.5 1.845033482142857e-05 1.5 1.8450892857142856e-05 0.0 1.8459821428571427e-05 0.0 1.8460379464285714e-05 1.5 1.846819196428571e-05 1.5 1.8468749999999998e-05 0.0 1.847767857142857e-05 0.0 1.8478236607142856e-05 1.5 1.8486049107142857e-05 1.5 1.848660714285714e-05 0.0 1.8495535714285712e-05 0.0 1.849609375e-05 1.5 1.850390625e-05 1.5 1.8504464285714283e-05 0.0 1.8513392857142857e-05 0.0 1.851395089285714e-05 1.5 1.8521763392857142e-05 1.5 1.852232142857143e-05 0.0 1.853125e-05 0.0 1.8531808035714283e-05 1.5 1.8539620535714284e-05 1.5 1.854017857142857e-05 0.0 1.8549107142857142e-05 0.0 1.854966517857143e-05 1.5 1.8557477678571427e-05 1.5 1.8558035714285713e-05 0.0 1.8566964285714284e-05 0.0 1.856752232142857e-05 1.5 1.857533482142857e-05 1.5 1.8575892857142856e-05 0.0 1.8584821428571427e-05 0.0 1.8585379464285714e-05 1.5 1.8593191964285715e-05 1.5 1.8593749999999998e-05 0.0 1.860267857142857e-05 0.0 1.8603236607142856e-05 1.5 1.8611049107142857e-05 1.5 1.861160714285714e-05 0.0 1.862053571428571e-05 0.0 1.8621093749999998e-05 1.5 1.862890625e-05 1.5 1.8629464285714286e-05 0.0 1.8638392857142857e-05 0.0 1.863895089285714e-05 1.5 1.864676339285714e-05 1.5 1.8647321428571428e-05 0.0 1.865625e-05 0.0 1.8656808035714283e-05 1.5 1.8664620535714284e-05 1.5 1.866517857142857e-05 0.0 1.8674107142857142e-05 0.0 1.867466517857143e-05 1.5 1.8682477678571426e-05 1.5 1.8683035714285713e-05 0.0 1.8691964285714284e-05 0.0 1.869252232142857e-05 1.5 1.870033482142857e-05 1.5 1.8700892857142855e-05 0.0 1.8709821428571426e-05 0.0 1.8710379464285713e-05 1.5 1.8718191964285714e-05 1.5 1.8718749999999998e-05 0.0 1.8728236607142856e-05 0.0 1.8728794642857142e-05 1.5 1.873549107142857e-05 1.5 1.8736049107142857e-05 0.0 1.8746093749999998e-05 0.0 1.8746651785714285e-05 1.5 1.8753348214285712e-05 1.5 1.875390625e-05 0.0 1.876395089285714e-05 0.0 1.8764508928571427e-05 1.5 1.8771205357142854e-05 1.5 1.877176339285714e-05 0.0 1.8781808035714286e-05 0.0 1.878236607142857e-05 1.5 1.87890625e-05 1.5 1.8789620535714284e-05 0.0 1.8799665178571428e-05 0.0 1.880022321428571e-05 1.5 1.8806919642857142e-05 1.5 1.8807477678571426e-05 0.0 1.881752232142857e-05 0.0 1.8818080357142857e-05 1.5 1.8824776785714285e-05 1.5 1.882533482142857e-05 0.0 1.8835379464285713e-05 0.0 1.88359375e-05 1.5 1.8842633928571427e-05 1.5 1.8843191964285714e-05 0.0 1.8853236607142855e-05 0.0 1.8853794642857142e-05 1.5 1.886049107142857e-05 1.5 1.8861049107142856e-05 0.0 1.8871093749999997e-05 0.0 1.8871651785714284e-05 1.5 1.8878348214285712e-05 1.5 1.887890625e-05 0.0 1.888895089285714e-05 0.0 1.8889508928571427e-05 1.5 1.8896205357142857e-05 1.5 1.889676339285714e-05 0.0 1.8906808035714286e-05 0.0 1.890736607142857e-05 1.5 1.89140625e-05 1.5 1.8914620535714283e-05 0.0 1.8924665178571428e-05 0.0 1.8925223214285715e-05 1.5 1.8931919642857142e-05 1.5 1.893247767857143e-05 0.0 1.894252232142857e-05 0.0 1.8943080357142857e-05 1.5 1.8949776785714284e-05 1.5 1.895033482142857e-05 0.0 1.8960379464285712e-05 0.0 1.89609375e-05 1.5 1.8967633928571427e-05 1.5 1.8968191964285714e-05 0.0 1.8978236607142855e-05 0.0 1.897879464285714e-05 1.5 1.898549107142857e-05 1.5 1.8986049107142856e-05 0.0 1.8996093749999997e-05 0.0 1.8996651785714284e-05 1.5 1.900334821428571e-05 1.5 1.9003906249999998e-05 0.0 1.9013950892857143e-05 0.0 1.9014508928571426e-05 1.5 1.9021205357142857e-05 1.5 1.902176339285714e-05 0.0 1.9031808035714285e-05 0.0 1.903236607142857e-05 1.5 1.90390625e-05 1.5 1.9039620535714283e-05 0.0 1.9049665178571427e-05 0.0 1.9050223214285714e-05 1.5 1.9056919642857142e-05 1.5 1.905747767857143e-05 0.0 1.906752232142857e-05 0.0 1.9068080357142857e-05 1.5 1.9074776785714284e-05 1.5 1.907533482142857e-05 0.0 1.9085379464285712e-05 0.0 1.90859375e-05 1.5 1.9092633928571426e-05 1.5 1.9093191964285713e-05 0.0 1.9103236607142854e-05 0.0 1.910379464285714e-05 1.5 1.911049107142857e-05 1.5 1.9111049107142856e-05 0.0 1.912109375e-05 0.0 1.9121651785714284e-05 1.5 1.9128348214285714e-05 1.5 1.9128906249999998e-05 0.0 1.9138950892857143e-05 0.0 1.9139508928571426e-05 1.5 1.9146205357142857e-05 1.5 1.914676339285714e-05 0.0 1.9156808035714285e-05 0.0 1.915736607142857e-05 1.5 1.91640625e-05 1.5 1.9164620535714286e-05 0.0 1.9174665178571427e-05 0.0 1.9175223214285714e-05 1.5 1.918191964285714e-05 1.5 1.9182477678571428e-05 0.0 1.919252232142857e-05 0.0 1.9193080357142856e-05 1.5 1.9199776785714284e-05 1.5 1.920033482142857e-05 0.0 1.9210379464285712e-05 0.0 1.92109375e-05 1.5 1.9217633928571426e-05 1.5 1.9218191964285713e-05 0.0 1.9228236607142854e-05 0.0 1.922879464285714e-05 1.5 1.923549107142857e-05 1.5 1.9236049107142855e-05 0.0 1.924609375e-05 0.0 1.9246651785714283e-05 1.5 1.9253348214285714e-05 1.5 1.9253906249999997e-05 0.0 1.9263950892857142e-05 0.0 1.9264508928571426e-05 1.5 1.9271205357142856e-05 1.5 1.927176339285714e-05 0.0 1.9281808035714284e-05 0.0 1.928236607142857e-05 1.5 1.92890625e-05 1.5 1.9289620535714286e-05 0.0 1.9299665178571427e-05 0.0 1.9300223214285714e-05 1.5 1.930691964285714e-05 1.5 1.9307477678571428e-05 0.0 1.931752232142857e-05 0.0 1.9318080357142856e-05 1.5 1.9324776785714283e-05 1.5 1.932533482142857e-05 0.0 1.933537946428571e-05 0.0 1.9335937499999998e-05 1.5 1.9342633928571426e-05 1.5 1.9343191964285712e-05 0.0 1.9353236607142857e-05 0.0 1.935379464285714e-05 1.5 1.936049107142857e-05 1.5 1.9361049107142855e-05 0.0 1.937109375e-05 0.0 1.9371651785714283e-05 1.5 1.9378348214285714e-05 1.5 1.9378906249999997e-05 0.0 1.9388950892857142e-05 0.0 1.938950892857143e-05 1.5 1.9396205357142856e-05 1.5 1.9396763392857143e-05 0.0 1.9406808035714284e-05 0.0 1.940736607142857e-05 1.5 1.94140625e-05 1.5 1.9414620535714285e-05 0.0 1.9424665178571426e-05 0.0 1.9425223214285713e-05 1.5 1.943191964285714e-05 1.5 1.9432477678571427e-05 0.0 1.944252232142857e-05 0.0 1.9443080357142856e-05 1.5 1.9449776785714283e-05 1.5 1.945033482142857e-05 0.0 1.9460379464285714e-05 0.0 1.9460937499999998e-05 1.5 1.946763392857143e-05 1.5 1.9468191964285712e-05 0.0 1.9478236607142857e-05 0.0 1.947879464285714e-05 1.5 1.948549107142857e-05 1.5 1.9486049107142854e-05 0.0 1.949609375e-05 0.0 1.9496651785714286e-05 1.5 1.9503348214285713e-05 1.5 1.950390625e-05 0.0 1.951395089285714e-05 0.0 1.9514508928571428e-05 1.5 1.9521205357142856e-05 1.5 1.9521763392857142e-05 0.0 1.9531808035714284e-05 0.0 1.953236607142857e-05 1.5 1.9539062499999998e-05 1.5 1.9539620535714285e-05 0.0 1.9549665178571426e-05 0.0 1.9550223214285713e-05 1.5 1.955691964285714e-05 1.5 1.9557477678571427e-05 0.0 1.956752232142857e-05 0.0 1.9568080357142855e-05 1.5 1.9574776785714283e-05 1.5 1.957533482142857e-05 0.0 1.9585379464285714e-05 0.0 1.9585937499999998e-05 1.5 1.959263392857143e-05 1.5 1.9593191964285712e-05 0.0 1.9603236607142856e-05 0.0 1.960379464285714e-05 1.5 1.961049107142857e-05 1.5 1.9611049107142854e-05 0.0 1.962109375e-05 0.0 1.9621651785714286e-05 1.5 1.9628348214285713e-05 1.5 1.962890625e-05 0.0 1.963895089285714e-05 0.0 1.9639508928571428e-05 1.5 1.9646205357142855e-05 1.5 1.9646763392857142e-05 0.0 1.9656808035714283e-05 0.0 1.965736607142857e-05 1.5 1.9664062499999998e-05 1.5 1.9664620535714284e-05 0.0 1.9674665178571426e-05 0.0 1.9675223214285713e-05 1.5 1.968191964285714e-05 1.5 1.9682477678571427e-05 0.0 1.969252232142857e-05 0.0 1.9693080357142855e-05 1.5 1.9699776785714286e-05 1.5 1.970033482142857e-05 0.0 1.9710379464285714e-05 0.0 1.9710937499999997e-05 1.5 1.9717633928571428e-05 1.5 1.971819196428571e-05 0.0 1.9728236607142856e-05 0.0 1.9728794642857143e-05 1.5 1.973549107142857e-05 1.5 1.9736049107142857e-05 0.0 1.974609375e-05 0.0 1.9746651785714285e-05 1.5 1.9753348214285713e-05 1.5 1.975390625e-05 0.0 1.976395089285714e-05 0.0 1.9764508928571428e-05 1.5 1.9771205357142855e-05 1.5 1.9771763392857142e-05 0.0 1.9781808035714283e-05 0.0 1.978236607142857e-05 1.5 1.9789062499999997e-05 1.5 1.9789620535714284e-05 0.0 1.979966517857143e-05 0.0 1.9800223214285712e-05 1.5 1.9806919642857143e-05 1.5 1.9807477678571426e-05 0.0 1.981752232142857e-05 0.0 1.9818080357142854e-05 1.5 1.9824776785714285e-05 1.5 1.982533482142857e-05 0.0 1.9835379464285713e-05 0.0 1.98359375e-05 1.5 1.9842633928571428e-05 1.5 1.9843191964285714e-05 0.0 1.9853236607142856e-05 0.0 1.9853794642857143e-05 1.5 1.986049107142857e-05 1.5 1.9861049107142857e-05 0.0 1.9871093749999998e-05 0.0 1.9871651785714285e-05 1.5 1.9878348214285712e-05 1.5 1.987890625e-05 0.0 1.988895089285714e-05 0.0 1.9889508928571427e-05 1.5 1.9896205357142855e-05 1.5 1.989676339285714e-05 0.0 1.9906808035714283e-05 0.0 1.990736607142857e-05 1.5 1.9914062499999997e-05 1.5 1.9914620535714284e-05 0.0 1.992466517857143e-05 0.0 1.9925223214285712e-05 1.5 1.9931919642857143e-05 1.5 1.9932477678571426e-05 0.0 1.994252232142857e-05 0.0 1.9943080357142854e-05 1.5 1.9949776785714285e-05 1.5 1.995033482142857e-05 0.0 1.9960379464285713e-05 0.0 1.99609375e-05 1.5 1.9967633928571427e-05 1.5 1.9968191964285714e-05 0.0 1.9978236607142855e-05 0.0 1.9978794642857142e-05 1.5 1.998549107142857e-05 1.5 1.9986049107142856e-05 0.0 1.9996093749999998e-05 0.0 1.9996651785714284e-05 1.5 2.0003348214285712e-05 1.5 2.000390625e-05 0.0 2.001395089285714e-05 0.0 2.0014508928571427e-05 1.5 2.0021205357142854e-05 1.5 2.002176339285714e-05 0.0 2.0031808035714286e-05 0.0 2.003236607142857e-05 1.5 2.00390625e-05 1.5 2.0039620535714283e-05 0.0 2.0049665178571428e-05 0.0 2.005022321428571e-05 1.5 2.0056919642857142e-05 1.5 2.0057477678571426e-05 0.0 2.006752232142857e-05 0.0 2.0068080357142857e-05 1.5 2.0074776785714285e-05 1.5 2.007533482142857e-05 0.0 2.0085379464285713e-05 0.0 2.00859375e-05 1.5 2.0092633928571427e-05 1.5 2.0093191964285714e-05 0.0 2.0103236607142855e-05 0.0 2.0103794642857142e-05 1.5 2.011049107142857e-05 1.5 2.0111049107142856e-05 0.0 2.0121093749999997e-05 0.0 2.0121651785714284e-05 1.5 2.012834821428571e-05 1.5 2.012890625e-05 0.0 2.0138950892857143e-05 0.0 2.0139508928571426e-05 1.5 2.0146205357142857e-05 1.5 2.014676339285714e-05 0.0 2.0156808035714285e-05 0.0 2.015736607142857e-05 1.5 2.01640625e-05 1.5 2.0164620535714283e-05 0.0 2.0174665178571428e-05 0.0 2.0175223214285714e-05 1.5 2.0181919642857142e-05 1.5 2.018247767857143e-05 0.0 2.019252232142857e-05 0.0 2.0193080357142857e-05 1.5 2.0199776785714284e-05 1.5 2.020033482142857e-05 0.0 2.0210379464285712e-05 0.0 2.02109375e-05 1.5 2.0217633928571427e-05 1.5 2.0218191964285713e-05 0.0 2.0228236607142855e-05 0.0 2.022879464285714e-05 1.5 2.023549107142857e-05 1.5 2.0236049107142856e-05 0.0 2.0246093749999997e-05 0.0 2.0246651785714284e-05 1.5 2.025334821428571e-05 1.5 2.0253906249999998e-05 0.0 2.0263950892857143e-05 0.0 2.0264508928571426e-05 1.5 2.0271205357142857e-05 1.5 2.027176339285714e-05 0.0 2.0281808035714285e-05 0.0 2.028236607142857e-05 1.5 2.02890625e-05 1.5 2.0289620535714283e-05 0.0 2.0299665178571427e-05 0.0 2.0300223214285714e-05 1.5 2.030691964285714e-05 1.5 2.030747767857143e-05 0.0 2.031752232142857e-05 0.0 2.0318080357142856e-05 1.5 2.0324776785714284e-05 1.5 2.032533482142857e-05 0.0 2.0335379464285712e-05 0.0 2.03359375e-05 1.5 2.0342633928571426e-05 1.5 2.0343191964285713e-05 0.0 2.0353236607142854e-05 0.0 2.035379464285714e-05 1.5 2.036049107142857e-05 1.5 2.0361049107142855e-05 0.0 2.037109375e-05 0.0 2.0371651785714283e-05 1.5 2.0378348214285714e-05 1.5 2.0378906249999998e-05 0.0 2.0388950892857142e-05 0.0 2.0389508928571426e-05 1.5 2.0396205357142857e-05 1.5 2.039676339285714e-05 0.0 2.0406808035714285e-05 0.0 2.040736607142857e-05 1.5 2.04140625e-05 1.5 2.0414620535714286e-05 0.0 2.0424665178571427e-05 0.0 2.0425223214285714e-05 1.5 2.043191964285714e-05 1.5 2.0432477678571428e-05 0.0 2.044252232142857e-05 0.0 2.0443080357142856e-05 1.5 2.0449776785714284e-05 1.5 2.045033482142857e-05 0.0 2.046037946428571e-05 0.0 2.04609375e-05 1.5 2.0467633928571426e-05 1.5 2.0468191964285713e-05 0.0 2.0478236607142854e-05 0.0 2.047879464285714e-05 1.5 2.0485491071428568e-05 1.5 2.0486049107142855e-05 0.0 2.049609375e-05 0.0 2.0496651785714283e-05 1.5 2.0503348214285714e-05 1.5 2.0503906249999997e-05 0.0 2.0513950892857142e-05 0.0 2.0514508928571425e-05 1.5 2.0521205357142856e-05 1.5 2.0521763392857143e-05 0.0 2.0531808035714284e-05 0.0 2.053236607142857e-05 1.5 2.05390625e-05 1.5 2.0539620535714285e-05 0.0 2.0549665178571427e-05 0.0 2.0550223214285713e-05 1.5 2.055691964285714e-05 1.5 2.0557477678571428e-05 0.0 2.056752232142857e-05 0.0 2.0568080357142856e-05 1.5 2.0574776785714283e-05 1.5 2.057533482142857e-05 0.0 2.058537946428571e-05 0.0 2.0585937499999998e-05 1.5 2.0592633928571426e-05 1.5 2.0593191964285712e-05 0.0 2.0603236607142857e-05 0.0 2.060379464285714e-05 1.5 2.061049107142857e-05 1.5 2.0611049107142855e-05 0.0 2.062109375e-05 0.0 2.0621651785714283e-05 1.5 2.0628348214285714e-05 1.5 2.0628906249999997e-05 0.0 2.063895089285714e-05 0.0 2.063950892857143e-05 1.5 2.0646205357142856e-05 1.5 2.0646763392857143e-05 0.0 2.0656808035714284e-05 0.0 2.065736607142857e-05 1.5 2.0664062499999998e-05 1.5 2.0664620535714285e-05 0.0 2.0674665178571426e-05 0.0 2.0675223214285713e-05 1.5 2.068191964285714e-05 1.5 2.0682477678571427e-05 0.0 2.069252232142857e-05 0.0 2.0693080357142855e-05 1.5 2.0699776785714283e-05 1.5 2.070033482142857e-05 0.0 2.0710379464285714e-05 0.0 2.0710937499999998e-05 1.5 2.071763392857143e-05 1.5 2.0718191964285712e-05 0.0 2.0728236607142857e-05 0.0 2.072879464285714e-05 1.5 2.073549107142857e-05 1.5 2.0736049107142854e-05 0.0 2.074609375e-05 0.0 2.0746651785714286e-05 1.5 2.0753348214285713e-05 1.5 2.075390625e-05 0.0 2.076395089285714e-05 0.0 2.0764508928571428e-05 1.5 2.0771205357142856e-05 1.5 2.0771763392857142e-05 0.0 2.0781808035714284e-05 0.0 2.078236607142857e-05 1.5 2.0789062499999998e-05 1.5 2.0789620535714285e-05 0.0 2.0799665178571426e-05 0.0 2.0800223214285713e-05 1.5 2.080691964285714e-05 1.5 2.0807477678571427e-05 0.0 2.081752232142857e-05 0.0 2.0818080357142855e-05 1.5 2.0824776785714283e-05 1.5 2.082533482142857e-05 0.0 2.0835379464285714e-05 0.0 2.0835937499999997e-05 1.5 2.0842633928571428e-05 1.5 2.084319196428571e-05 0.0 2.0853236607142856e-05 0.0 2.085379464285714e-05 1.5 2.086049107142857e-05 1.5 2.0861049107142854e-05 0.0 2.087109375e-05 0.0 2.0871651785714285e-05 1.5 2.0878348214285713e-05 1.5 2.087890625e-05 0.0 2.088895089285714e-05 0.0 2.0889508928571428e-05 1.5 2.0896205357142855e-05 1.5 2.0896763392857142e-05 0.0 2.0906808035714283e-05 0.0 2.090736607142857e-05 1.5 2.0914062499999998e-05 1.5 2.0914620535714284e-05 0.0 2.0924665178571426e-05 0.0 2.0925223214285712e-05 1.5 2.093191964285714e-05 1.5 2.0932477678571427e-05 0.0 2.094252232142857e-05 0.0 2.0943080357142855e-05 1.5 2.0949776785714286e-05 1.5 2.095033482142857e-05 0.0 2.0960379464285714e-05 0.0 2.0960937499999997e-05 1.5 2.0967633928571428e-05 1.5 2.096819196428571e-05 0.0 2.0978236607142856e-05 0.0 2.0978794642857143e-05 1.5 2.098549107142857e-05 1.5 2.0986049107142857e-05 0.0 2.099609375e-05 0.0 2.0996651785714285e-05 1.5 2.1003348214285713e-05 1.5 2.100390625e-05 0.0 2.101395089285714e-05 0.0 2.1014508928571427e-05 1.5 2.1021205357142855e-05 1.5 2.102176339285714e-05 0.0 2.1031808035714283e-05 0.0 2.103236607142857e-05 1.5 2.1039062499999997e-05 1.5 2.1039620535714284e-05 0.0 2.104966517857143e-05 0.0 2.1050223214285712e-05 1.5 2.1056919642857143e-05 1.5 2.1057477678571426e-05 0.0 2.106752232142857e-05 0.0 2.1068080357142854e-05 1.5 2.1074776785714285e-05 1.5 2.107533482142857e-05 0.0 2.1085379464285713e-05 0.0 2.10859375e-05 1.5 2.1092633928571428e-05 1.5 2.1093191964285714e-05 0.0 2.1103236607142856e-05 0.0 2.1103794642857142e-05 1.5 2.111049107142857e-05 1.5 2.1111049107142857e-05 0.0 2.1121093749999998e-05 0.0 2.1121651785714285e-05 1.5 2.1128348214285712e-05 1.5 2.112890625e-05 0.0 2.113895089285714e-05 0.0 2.1139508928571427e-05 1.5 2.1146205357142855e-05 1.5 2.114676339285714e-05 0.0 2.1156808035714283e-05 0.0 2.115736607142857e-05 1.5 2.1164062499999997e-05 1.5 2.1164620535714284e-05 0.0 2.117466517857143e-05 0.0 2.1175223214285712e-05 1.5 2.1181919642857143e-05 1.5 2.1182477678571426e-05 0.0 2.119252232142857e-05 0.0 2.1193080357142854e-05 1.5 2.1199776785714285e-05 1.5 2.1200334821428568e-05 0.0 2.1210379464285713e-05 0.0 2.12109375e-05 1.5 2.1217633928571427e-05 1.5 2.1218191964285714e-05 0.0 2.1228236607142855e-05 0.0 2.1228794642857142e-05 1.5 2.123549107142857e-05 1.5 2.1236049107142856e-05 0.0 2.1246093749999998e-05 0.0 2.1246651785714284e-05 1.5 2.1253348214285712e-05 1.5 2.125390625e-05 0.0 2.126395089285714e-05 0.0 2.1264508928571427e-05 1.5 2.1271205357142854e-05 1.5 2.127176339285714e-05 0.0 2.1281808035714286e-05 0.0 2.128236607142857e-05 1.5 2.12890625e-05 1.5 2.1289620535714283e-05 0.0 2.1299665178571428e-05 0.0 2.130022321428571e-05 1.5 2.1306919642857142e-05 1.5 2.1307477678571426e-05 0.0 2.131752232142857e-05 0.0 2.1318080357142857e-05 1.5 2.1324776785714285e-05 1.5 2.132533482142857e-05 0.0 2.1335379464285713e-05 0.0 2.13359375e-05 1.5 2.1342633928571427e-05 1.5 2.1343191964285714e-05 0.0 2.1353236607142855e-05 0.0 2.1353794642857142e-05 1.5 2.136049107142857e-05 1.5 2.1361049107142856e-05 0.0 2.1371093749999997e-05 0.0 2.1371651785714284e-05 1.5 2.137834821428571e-05 1.5 2.137890625e-05 0.0 2.1388950892857143e-05 0.0 2.1389508928571426e-05 1.5 2.1396205357142857e-05 1.5 2.139676339285714e-05 0.0 2.140625e-05 0.0 2.1406808035714285e-05 1.5 2.1414620535714283e-05 1.5 2.141517857142857e-05 0.0 2.142410714285714e-05 0.0 2.1424665178571428e-05 1.5 2.143247767857143e-05 1.5 2.1433035714285712e-05 0.0 2.1441964285714283e-05 0.0 2.144252232142857e-05 1.5 2.145033482142857e-05 1.5 2.1450892857142854e-05 0.0 2.1459821428571426e-05 0.0 2.1460379464285712e-05 1.5 2.1468191964285713e-05 1.5 2.146875e-05 0.0 2.147767857142857e-05 0.0 2.1478236607142855e-05 1.5 2.1486049107142856e-05 1.5 2.1486607142857142e-05 0.0 2.1495535714285714e-05 0.0 2.1496093749999997e-05 1.5 2.1503906249999998e-05 1.5 2.1504464285714285e-05 0.0 2.1513392857142856e-05 0.0 2.1513950892857143e-05 1.5 2.152176339285714e-05 1.5 2.1522321428571427e-05 0.0 2.1531249999999998e-05 0.0 2.1531808035714285e-05 1.5 2.1539620535714283e-05 1.5 2.154017857142857e-05 0.0 2.154910714285714e-05 0.0 2.1549665178571427e-05 1.5 2.155747767857143e-05 1.5 2.155803571428571e-05 0.0 2.1566964285714283e-05 0.0 2.156752232142857e-05 1.5 2.157533482142857e-05 1.5 2.1575892857142854e-05 0.0 2.158482142857143e-05 0.0 2.1585379464285712e-05 1.5 2.1593191964285713e-05 1.5 2.159375e-05 0.0 2.160267857142857e-05 0.0 2.1603236607142854e-05 1.5 2.1611049107142855e-05 1.5 2.1611607142857142e-05 0.0 2.1620535714285713e-05 0.0 2.162109375e-05 1.5 2.1628906249999998e-05 1.5 2.1629464285714284e-05 0.0 2.1638392857142856e-05 0.0 2.1638950892857142e-05 1.5 2.164676339285714e-05 1.5 2.1647321428571427e-05 0.0 2.1656249999999998e-05 0.0 2.1656808035714285e-05 1.5 2.1664620535714286e-05 1.5 2.166517857142857e-05 0.0 2.167410714285714e-05 0.0 2.1674665178571427e-05 1.5 2.1682477678571428e-05 1.5 2.168303571428571e-05 0.0 2.1691964285714282e-05 0.0 2.169252232142857e-05 1.5 2.170033482142857e-05 1.5 2.1700892857142857e-05 0.0 2.1709821428571428e-05 0.0 2.171037946428571e-05 1.5 2.1718191964285713e-05 1.5 2.171875e-05 0.0 2.172767857142857e-05 0.0 2.1728236607142854e-05 1.5 2.1736049107142855e-05 1.5 2.173660714285714e-05 0.0 2.1745535714285713e-05 0.0 2.174609375e-05 1.5 2.1753906249999997e-05 1.5 2.1754464285714284e-05 0.0 2.1763392857142855e-05 0.0 2.1763950892857142e-05 1.5 2.1771763392857143e-05 1.5 2.1772321428571426e-05 0.0 2.1781249999999997e-05 0.0 2.1781808035714284e-05 1.5 2.1789620535714285e-05 1.5 2.179017857142857e-05 0.0 2.179910714285714e-05 0.0 2.1799665178571427e-05 1.5 2.1807477678571428e-05 1.5 2.1808035714285714e-05 0.0 2.1816964285714286e-05 0.0 2.181752232142857e-05 1.5 2.182533482142857e-05 1.5 2.1825892857142857e-05 0.0 2.1834821428571428e-05 0.0 2.183537946428571e-05 1.5 2.1843191964285712e-05 1.5 2.184375e-05 0.0 2.185267857142857e-05 0.0 2.1853236607142857e-05 1.5 2.1861049107142855e-05 1.5 2.186160714285714e-05 0.0 2.1870535714285713e-05 0.0 2.187109375e-05 1.5 2.1878906249999997e-05 1.5 2.1879464285714284e-05 0.0 2.1888392857142855e-05 0.0 2.188895089285714e-05 1.5 2.1896763392857143e-05 1.5 2.1897321428571426e-05 0.0 2.1906249999999997e-05 0.0 2.1906808035714284e-05 1.5 2.1914620535714285e-05 1.5 2.191517857142857e-05 0.0 2.1924107142857143e-05 0.0 2.1924665178571426e-05 1.5 2.1932477678571427e-05 1.5 2.1933035714285714e-05 0.0 2.1941964285714285e-05 0.0 2.194252232142857e-05 1.5 2.195033482142857e-05 1.5 2.1950892857142856e-05 0.0 2.1959821428571428e-05 0.0 2.1960379464285714e-05 1.5 2.1968191964285712e-05 1.5 2.196875e-05 0.0 2.197767857142857e-05 0.0 2.1978236607142857e-05 1.5 2.1986049107142854e-05 1.5 2.198660714285714e-05 0.0 2.1995535714285712e-05 0.0 2.199609375e-05 1.5 2.200390625e-05 1.5 2.2004464285714283e-05 0.0 2.2013392857142854e-05 0.0 2.201395089285714e-05 1.5 2.2021763392857142e-05 1.5 2.2022321428571426e-05 0.0 2.2031249999999997e-05 0.0 2.2031808035714284e-05 1.5 2.2039620535714285e-05 1.5 2.204017857142857e-05 0.0 2.2049107142857143e-05 0.0 2.2049665178571426e-05 1.5 2.2057477678571427e-05 1.5 2.2058035714285714e-05 0.0 2.2066964285714285e-05 0.0 2.2067522321428568e-05 1.5 2.2075892857142856e-05 1.5 2.2076450892857143e-05 0.0 2.208426339285714e-05 0.0 2.2084821428571427e-05 1.5 2.209375e-05 1.5 2.2094308035714285e-05 0.0 2.2102120535714283e-05 0.0 2.210267857142857e-05 1.5 2.211160714285714e-05 1.5 2.2112165178571427e-05 0.0 2.211997767857143e-05 0.0 2.2120535714285712e-05 1.5 2.2129464285714283e-05 1.5 2.213002232142857e-05 0.0 2.213783482142857e-05 0.0 2.2138392857142854e-05 1.5 2.214732142857143e-05 1.5 2.2147879464285712e-05 0.0 2.2155691964285713e-05 0.0 2.215625e-05 1.5 2.216517857142857e-05 1.5 2.2165736607142854e-05 0.0 2.2173549107142855e-05 0.0 2.2174107142857142e-05 1.5 2.2183035714285713e-05 1.5 2.218359375e-05 0.0 2.2191406249999998e-05 0.0 2.2191964285714284e-05 1.5 2.2200892857142856e-05 1.5 2.2201450892857142e-05 0.0 2.220926339285714e-05 0.0 2.2209821428571427e-05 1.5 2.2218749999999998e-05 1.5 2.2219308035714285e-05 0.0 2.2227120535714286e-05 0.0 2.222767857142857e-05 1.5 2.223660714285714e-05 1.5 2.2237165178571427e-05 0.0 2.2244977678571428e-05 0.0 2.224553571428571e-05 1.5 2.2254464285714283e-05 1.5 2.225502232142857e-05 0.0 2.226283482142857e-05 0.0 2.2263392857142857e-05 1.5 2.227232142857143e-05 1.5 2.2272879464285712e-05 0.0 2.2280691964285713e-05 0.0 2.228125e-05 1.5 2.229017857142857e-05 1.5 2.2290736607142854e-05 0.0 2.2298549107142855e-05 0.0 2.2299107142857142e-05 1.5 2.2308035714285713e-05 1.5 2.230859375e-05 0.0 2.2316406249999997e-05 0.0 2.2316964285714284e-05 1.5 2.2325892857142855e-05 1.5 2.2326450892857142e-05 0.0 2.233426339285714e-05 0.0 2.2334821428571426e-05 1.5 2.2343749999999998e-05 1.5 2.2344308035714284e-05 0.0 2.2352120535714285e-05 0.0 2.235267857142857e-05 1.5 2.236160714285714e-05 1.5 2.2362165178571427e-05 0.0 2.2369977678571428e-05 0.0 2.237053571428571e-05 1.5 2.2379464285714286e-05 1.5 2.238002232142857e-05 0.0 2.238783482142857e-05 0.0 2.2388392857142857e-05 1.5 2.2397321428571428e-05 1.5 2.239787946428571e-05 0.0 2.2405691964285712e-05 0.0 2.240625e-05 1.5 2.241517857142857e-05 1.5 2.2415736607142857e-05 0.0 2.2423549107142855e-05 0.0 2.242410714285714e-05 1.5 2.2433035714285713e-05 1.5 2.243359375e-05 0.0 2.2441406249999997e-05 0.0 2.2441964285714284e-05 1.5 2.2450892857142855e-05 1.5 2.2451450892857142e-05 0.0 2.2459263392857143e-05 0.0 2.2459821428571426e-05 1.5 2.2468749999999997e-05 1.5 2.2469308035714284e-05 0.0 2.2477120535714285e-05 0.0 2.247767857142857e-05 1.5 2.248660714285714e-05 1.5 2.2487165178571426e-05 0.0 2.2494977678571427e-05 0.0 2.2495535714285714e-05 1.5 2.2504464285714285e-05 1.5 2.250502232142857e-05 0.0 2.251283482142857e-05 0.0 2.2513392857142856e-05 1.5 2.2522321428571428e-05 1.5 2.252287946428571e-05 0.0 2.2530691964285712e-05 0.0 2.253125e-05 1.5 2.254017857142857e-05 1.5 2.2540736607142857e-05 0.0 2.2548549107142854e-05 0.0 2.254910714285714e-05 1.5 2.2558035714285712e-05 1.5 2.255859375e-05 0.0 2.256640625e-05 0.0 2.2566964285714283e-05 1.5 2.2575892857142855e-05 1.5 2.257645089285714e-05 0.0 2.2584263392857142e-05 0.0 2.2584821428571426e-05 1.5 2.2593749999999997e-05 1.5 2.2594308035714284e-05 0.0 2.2602120535714285e-05 0.0 2.260267857142857e-05 1.5 2.2611607142857143e-05 1.5 2.2612165178571426e-05 0.0 2.2619977678571427e-05 0.0 2.2620535714285714e-05 1.5 2.2629464285714285e-05 1.5 2.263002232142857e-05 0.0 2.263783482142857e-05 0.0 2.2638392857142856e-05 1.5 2.2647321428571427e-05 1.5 2.2647879464285714e-05 0.0 2.265569196428571e-05 0.0 2.265625e-05 1.5 2.266517857142857e-05 1.5 2.2665736607142856e-05 0.0 2.2673549107142854e-05 0.0 2.267410714285714e-05 1.5 2.2683035714285712e-05 1.5 2.268359375e-05 0.0 2.269140625e-05 0.0 2.2691964285714283e-05 1.5 2.2700892857142854e-05 1.5 2.270145089285714e-05 0.0 2.2709263392857142e-05 0.0 2.2709821428571425e-05 1.5 2.271875e-05 1.5 2.2719308035714283e-05 0.0 2.2727120535714284e-05 0.0 2.272767857142857e-05 1.5 2.2736607142857142e-05 1.5 2.2737165178571426e-05 0.0 2.274441964285714e-05 0.0 2.2744977678571427e-05 1.5 2.275502232142857e-05 1.5 2.2755580357142855e-05 0.0 2.2762276785714286e-05 0.0 2.276283482142857e-05 1.5 2.2772879464285714e-05 1.5 2.2773437499999997e-05 0.0 2.2780133928571428e-05 0.0 2.278069196428571e-05 1.5 2.2790736607142856e-05 1.5 2.2791294642857143e-05 0.0 2.279799107142857e-05 0.0 2.2798549107142857e-05 1.5 2.280859375e-05 1.5 2.2809151785714285e-05 0.0 2.2815848214285713e-05 0.0 2.281640625e-05 1.5 2.282645089285714e-05 1.5 2.2827008928571427e-05 0.0 2.2833705357142855e-05 0.0 2.283426339285714e-05 1.5 2.2844308035714283e-05 1.5 2.284486607142857e-05 0.0 2.2851562499999997e-05 0.0 2.2852120535714284e-05 1.5 2.2862165178571425e-05 1.5 2.2862723214285712e-05 0.0 2.286941964285714e-05 0.0 2.2869977678571426e-05 1.5 2.288002232142857e-05 1.5 2.2880580357142854e-05 0.0 2.2887276785714285e-05 0.0 2.288783482142857e-05 1.5 2.2897879464285713e-05 1.5 2.2898437499999997e-05 0.0 2.2905133928571428e-05 0.0 2.290569196428571e-05 1.5 2.2915736607142856e-05 1.5 2.2916294642857142e-05 0.0 2.292299107142857e-05 0.0 2.2923549107142857e-05 1.5 2.2933593749999998e-05 1.5 2.2934151785714285e-05 0.0 2.2940848214285712e-05 0.0 2.294140625e-05 1.5 2.295145089285714e-05 1.5 2.2952008928571427e-05 0.0 2.2958705357142855e-05 0.0 2.295926339285714e-05 1.5 2.2969308035714283e-05 1.5 2.296986607142857e-05 0.0 2.2976562499999997e-05 0.0 2.2977120535714284e-05 1.5 2.298716517857143e-05 1.5 2.2987723214285712e-05 0.0 2.2994419642857143e-05 0.0 2.2994977678571426e-05 1.5 2.300502232142857e-05 1.5 2.3005580357142854e-05 0.0 2.3012276785714285e-05 0.0 2.301283482142857e-05 1.5 2.3022879464285713e-05 1.5 2.30234375e-05 0.0 2.3030133928571427e-05 0.0 2.3030691964285714e-05 1.5 2.3040736607142855e-05 1.5 2.3041294642857142e-05 0.0 2.304799107142857e-05 0.0 2.3048549107142856e-05 1.5 2.3058593749999998e-05 1.5 2.3059151785714284e-05 0.0 2.3065848214285712e-05 0.0 2.306640625e-05 1.5 2.307645089285714e-05 1.5 2.3077008928571427e-05 0.0 2.3083705357142854e-05 0.0 2.308426339285714e-05 1.5 2.3094308035714286e-05 1.5 2.309486607142857e-05 0.0 2.31015625e-05 0.0 2.3102120535714283e-05 1.5 2.3112165178571428e-05 1.5 2.311272321428571e-05 0.0 2.3119419642857142e-05 0.0 2.3119977678571426e-05 1.5 2.313002232142857e-05 1.5 2.3130580357142857e-05 0.0 2.3137276785714285e-05 0.0 2.313783482142857e-05 1.5 2.3147879464285713e-05 1.5 2.31484375e-05 0.0 2.3155133928571427e-05 0.0 2.3155691964285714e-05 1.5 2.3165736607142855e-05 1.5 2.3166294642857142e-05 0.0 2.317299107142857e-05 0.0 2.3173549107142856e-05 1.5 2.3183593749999997e-05 1.5 2.3184151785714284e-05 0.0 2.319084821428571e-05 0.0 2.319140625e-05 1.5 2.320145089285714e-05 1.5 2.3202008928571426e-05 0.0 2.3208705357142854e-05 0.0 2.320926339285714e-05 1.5 2.3219308035714285e-05 1.5 2.321986607142857e-05 0.0 2.32265625e-05 0.0 2.3227120535714283e-05 1.5 2.3237165178571428e-05 1.5 2.323772321428571e-05 0.0 2.3244419642857142e-05 0.0 2.3244977678571425e-05 1.5 2.325502232142857e-05 1.5 2.3255580357142857e-05 0.0 2.3262276785714284e-05 0.0 2.326283482142857e-05 1.5 2.3272879464285712e-05 1.5 2.32734375e-05 0.0 2.3280133928571427e-05 0.0 2.3280691964285713e-05 1.5 2.3290736607142855e-05 1.5 2.329129464285714e-05 0.0 2.329799107142857e-05 0.0 2.3298549107142856e-05 1.5 2.3308593749999997e-05 1.5 2.3309151785714284e-05 0.0 2.331584821428571e-05 0.0 2.3316406249999998e-05 1.5 2.3326450892857143e-05 1.5 2.3327008928571426e-05 0.0 2.3333705357142857e-05 0.0 2.333426339285714e-05 1.5 2.3344308035714285e-05 1.5 2.334486607142857e-05 0.0 2.33515625e-05 0.0 2.3352120535714283e-05 1.5 2.3362165178571427e-05 1.5 2.3362723214285714e-05 0.0 2.336941964285714e-05 0.0 2.336997767857143e-05 1.5 2.338002232142857e-05 1.5 2.3380580357142856e-05 0.0 2.3387276785714284e-05 0.0 2.338783482142857e-05 1.5 2.3397879464285712e-05 1.5 2.33984375e-05 0.0 2.3405133928571426e-05 0.0 2.3405691964285713e-05 1.5 2.3415736607142854e-05 1.5 2.341629464285714e-05 0.0 2.342299107142857e-05 0.0 2.3423549107142855e-05 1.5 2.343359375e-05 1.5 2.3434151785714283e-05 0.0 2.3440848214285714e-05 0.0 2.3441406249999998e-05 1.5 2.3451450892857142e-05 1.5 2.3452008928571426e-05 0.0 2.3458705357142857e-05 0.0 2.345926339285714e-05 1.5 2.3469308035714285e-05 1.5 2.346986607142857e-05 0.0 2.34765625e-05 0.0 2.3477120535714286e-05 1.5 2.3487165178571427e-05 1.5 2.3487723214285714e-05 0.0 2.349441964285714e-05 0.0 2.3494977678571428e-05 1.5 2.350502232142857e-05 1.5 2.3505580357142856e-05 0.0 2.3512276785714284e-05 0.0 2.351283482142857e-05 1.5 2.352287946428571e-05 1.5 2.35234375e-05 0.0 2.3530133928571426e-05 0.0 2.3530691964285713e-05 1.5 2.3540736607142854e-05 1.5 2.354129464285714e-05 0.0 2.3547991071428568e-05 0.0 2.3548549107142855e-05 1.5 2.355859375e-05 1.5 2.3559151785714283e-05 0.0 2.3565848214285714e-05 0.0 2.3566406249999997e-05 1.5 2.3576450892857142e-05 1.5 2.3577008928571425e-05 0.0 2.3583705357142856e-05 0.0 2.358426339285714e-05 1.5 2.3594308035714284e-05 1.5 2.359486607142857e-05 0.0 2.36015625e-05 0.0 2.3602120535714285e-05 1.5 2.3612165178571427e-05 1.5 2.3612723214285713e-05 0.0 2.361941964285714e-05 0.0 2.3619977678571428e-05 1.5 2.363002232142857e-05 1.5 2.3630580357142856e-05 0.0 2.3637276785714283e-05 0.0 2.363783482142857e-05 1.5 2.364787946428571e-05 1.5 2.3648437499999998e-05 0.0 2.3655133928571426e-05 0.0 2.3655691964285712e-05 1.5 2.3665736607142857e-05 1.5 2.366629464285714e-05 0.0 2.367299107142857e-05 0.0 2.3673549107142855e-05 1.5 2.368359375e-05 1.5 2.3684151785714283e-05 0.0 2.3690848214285714e-05 0.0 2.3691406249999997e-05 1.5 2.370145089285714e-05 1.5 2.370200892857143e-05 0.0 2.3708705357142856e-05 0.0 2.3709263392857143e-05 1.5 2.3719308035714284e-05 1.5 2.371986607142857e-05 0.0 2.3726562499999998e-05 0.0 2.3727120535714285e-05 1.5 2.3737165178571426e-05 1.5 2.3737723214285713e-05 0.0 2.374441964285714e-05 0.0 2.3744977678571427e-05 1.5 2.375502232142857e-05 1.5 2.3755580357142855e-05 0.0 2.3762276785714283e-05 0.0 2.376283482142857e-05 1.5 2.3772879464285714e-05 1.5 2.3773437499999998e-05 0.0 2.378013392857143e-05 0.0 2.3780691964285712e-05 1.5 2.3790736607142857e-05 1.5 2.379129464285714e-05 0.0 2.379799107142857e-05 0.0 2.3798549107142854e-05 1.5 2.380859375e-05 1.5 2.3809151785714286e-05 0.0 2.3815848214285713e-05 0.0 2.381640625e-05 1.5 2.382645089285714e-05 1.5 2.3827008928571428e-05 0.0 2.3833705357142856e-05 0.0 2.3834263392857142e-05 1.5 2.3844308035714284e-05 1.5 2.384486607142857e-05 0.0 2.3851562499999998e-05 0.0 2.3852120535714285e-05 1.5 2.3862165178571426e-05 1.5 2.3862723214285713e-05 0.0 2.386941964285714e-05 0.0 2.3869977678571427e-05 1.5 2.3880022321428568e-05 1.5 2.3880580357142855e-05 0.0 2.3887276785714282e-05 0.0 2.388783482142857e-05 1.5 2.3897879464285714e-05 1.5 2.3898437499999997e-05 0.0 2.3905133928571428e-05 0.0 2.390569196428571e-05 1.5 2.3915736607142856e-05 1.5 2.391629464285714e-05 0.0 2.392299107142857e-05 0.0 2.3923549107142854e-05 1.5 2.393359375e-05 1.5 2.3934151785714285e-05 0.0 2.3940848214285713e-05 0.0 2.394140625e-05 1.5 2.395145089285714e-05 1.5 2.3952008928571428e-05 0.0 2.3958705357142855e-05 0.0 2.3959263392857142e-05 1.5 2.3969308035714283e-05 1.5 2.396986607142857e-05 0.0 2.3976562499999997e-05 0.0 2.3977120535714284e-05 1.5 2.3987165178571426e-05 1.5 2.3987723214285712e-05 0.0 2.399441964285714e-05 0.0 2.3994977678571427e-05 1.5 2.400502232142857e-05 1.5 2.4005580357142855e-05 0.0 2.4012276785714286e-05 0.0 2.401283482142857e-05 1.5 2.4022879464285714e-05 1.5 2.4023437499999997e-05 0.0 2.4030133928571428e-05 0.0 2.403069196428571e-05 1.5 2.4040736607142856e-05 1.5 2.4041294642857143e-05 0.0 2.404799107142857e-05 0.0 2.4048549107142857e-05 1.5 2.4058593749999998e-05 1.5 2.4059151785714285e-05 0.0 2.4065848214285713e-05 0.0 2.406640625e-05 1.5 2.407645089285714e-05 1.5 2.4077008928571427e-05 0.0 2.4083705357142855e-05 0.0 2.408426339285714e-05 1.5 2.4094308035714283e-05 1.5 2.409486607142857e-05 0.0 2.4101562499999997e-05 0.0 2.4102120535714284e-05 1.5 2.4112165178571425e-05 1.5 2.4112723214285712e-05 0.0 2.411941964285714e-05 0.0 2.4119977678571426e-05 1.5 2.413002232142857e-05 1.5 2.4130580357142854e-05 0.0 2.4137276785714285e-05 0.0 2.413783482142857e-05 1.5 2.4147879464285713e-05 1.5 2.4148437499999997e-05 0.0 2.4155133928571428e-05 0.0 2.415569196428571e-05 1.5 2.4165736607142856e-05 1.5 2.4166294642857142e-05 0.0 2.417299107142857e-05 0.0 2.4173549107142857e-05 1.5 2.4183593749999998e-05 1.5 2.4184151785714285e-05 0.0 2.4190848214285712e-05 0.0 2.419140625e-05 1.5 2.420145089285714e-05 1.5 2.4202008928571427e-05 0.0 2.4208705357142854e-05 0.0 2.420926339285714e-05 1.5 2.4219308035714283e-05 1.5 2.421986607142857e-05 0.0 2.4226562499999997e-05 0.0 2.4227120535714284e-05 1.5 2.4237165178571428e-05 1.5 2.423772321428571e-05 0.0 2.4244419642857143e-05 0.0 2.4244977678571426e-05 1.5 2.425502232142857e-05 1.5 2.4255580357142854e-05 0.0 2.4262276785714285e-05 0.0 2.4262834821428568e-05 1.5 2.4272879464285713e-05 1.5 2.42734375e-05 0.0 2.4280133928571427e-05 0.0 2.4280691964285714e-05 1.5 2.4290736607142855e-05 1.5 2.4291294642857142e-05 0.0 2.429799107142857e-05 0.0 2.4298549107142856e-05 1.5 2.4308593749999998e-05 1.5 2.4309151785714284e-05 0.0 2.4315848214285712e-05 0.0 2.431640625e-05 1.5 2.432645089285714e-05 1.5 2.4327008928571427e-05 0.0 2.4333705357142854e-05 0.0 2.433426339285714e-05 1.5 2.4344308035714286e-05 1.5 2.434486607142857e-05 0.0 2.43515625e-05 0.0 2.4352120535714283e-05 1.5 2.4362165178571428e-05 1.5 2.436272321428571e-05 0.0 2.4369419642857142e-05 0.0 2.4369977678571426e-05 1.5 2.438002232142857e-05 1.5 2.4380580357142857e-05 0.0 2.4387276785714284e-05 0.0 2.438783482142857e-05 1.5 2.4397879464285713e-05 1.5 2.43984375e-05 0.0 2.4405133928571427e-05 0.0 2.4405691964285714e-05 1.5 2.4415736607142855e-05 1.5 2.441629464285714e-05 0.0 2.442299107142857e-05 0.0 2.4423549107142856e-05 1.5 2.4433593749999997e-05 1.5 2.4434151785714284e-05 0.0 2.444084821428571e-05 0.0 2.4441406249999998e-05 1.5 2.445145089285714e-05 1.5 2.4452008928571426e-05 0.0 2.4458705357142854e-05 0.0 2.445926339285714e-05 1.5 2.4469308035714285e-05 1.5 2.446986607142857e-05 0.0 2.44765625e-05 0.0 2.4477120535714283e-05 1.5 2.4487165178571428e-05 1.5 2.448772321428571e-05 0.0 2.4494419642857142e-05 0.0 2.4494977678571425e-05 1.5 2.450502232142857e-05 1.5 2.4505580357142857e-05 0.0 2.4512276785714284e-05 0.0 2.451283482142857e-05 1.5 2.4522879464285712e-05 1.5 2.45234375e-05 0.0 2.4530133928571426e-05 0.0 2.4530691964285713e-05 1.5 2.4540736607142854e-05 1.5 2.454129464285714e-05 0.0 2.454799107142857e-05 0.0 2.4548549107142856e-05 1.5 2.4558593749999997e-05 1.5 2.4559151785714284e-05 0.0 2.456584821428571e-05 0.0 2.4566406249999998e-05 1.5 2.4576450892857143e-05 1.5 2.4577008928571426e-05 0.0 2.4583705357142857e-05 0.0 2.458426339285714e-05 1.5 2.4594308035714285e-05 1.5 2.4594866071428568e-05 0.0 2.46015625e-05 0.0 2.4602120535714283e-05 1.5 2.4612165178571427e-05 1.5 2.4612723214285714e-05 0.0 2.461941964285714e-05 0.0 2.4619977678571428e-05 1.5 2.463002232142857e-05 1.5 2.4630580357142856e-05 0.0 2.4637276785714284e-05 0.0 2.463783482142857e-05 1.5 2.4647879464285712e-05 1.5 2.46484375e-05 0.0 2.4655133928571426e-05 0.0 2.4655691964285713e-05 1.5 2.4665736607142854e-05 1.5 2.466629464285714e-05 0.0 2.467299107142857e-05 0.0 2.4673549107142855e-05 1.5 2.468359375e-05 1.5 2.4684151785714283e-05 0.0 2.4690848214285714e-05 0.0 2.4691406249999998e-05 1.5 2.4701450892857142e-05 1.5 2.4702008928571426e-05 0.0 2.4708705357142856e-05 0.0 2.470926339285714e-05 1.5 2.4719308035714285e-05 1.5 2.471986607142857e-05 0.0 2.47265625e-05 0.0 2.4727120535714286e-05 1.5 2.4737165178571427e-05 1.5 2.4737723214285714e-05 0.0 2.474441964285714e-05 0.0 2.4744977678571428e-05 1.5 2.475502232142857e-05 1.5 2.4755580357142856e-05 0.0 2.4762276785714283e-05 0.0 2.476283482142857e-05 1.5 2.477287946428571e-05 1.5 2.4773437499999998e-05 0.0 2.4780133928571426e-05 0.0 2.4780691964285713e-05 1.5 2.4790736607142854e-05 1.5 2.479129464285714e-05 0.0 2.4797991071428568e-05 0.0 2.4798549107142855e-05 1.5 2.480859375e-05 1.5 2.4809151785714283e-05 0.0 2.4815848214285714e-05 0.0 2.4816406249999997e-05 1.5 2.4826450892857142e-05 1.5 2.4827008928571425e-05 0.0 2.4833705357142856e-05 0.0 2.483426339285714e-05 1.5 2.4844308035714284e-05 1.5 2.484486607142857e-05 0.0 2.48515625e-05 0.0 2.4852120535714285e-05 1.5 2.4862165178571426e-05 1.5 2.4862723214285713e-05 0.0 2.486941964285714e-05 0.0 2.4869977678571428e-05 1.5 2.488002232142857e-05 1.5 2.4880580357142856e-05 0.0 2.4887276785714283e-05 0.0 2.488783482142857e-05 1.5 2.489787946428571e-05 1.5 2.4898437499999998e-05 0.0 2.4905133928571425e-05 0.0 2.4905691964285712e-05 1.5 2.4915736607142857e-05 1.5 2.491629464285714e-05 0.0 2.492299107142857e-05 0.0 2.4923549107142854e-05 1.5 2.493359375e-05 1.5 2.4934151785714283e-05 0.0 2.4940848214285713e-05 0.0 2.4941406249999997e-05 1.5 2.495145089285714e-05 1.5 2.4952008928571428e-05 0.0 2.4958705357142856e-05 0.0 2.4959263392857143e-05 1.5 2.4969308035714284e-05 1.5 2.496986607142857e-05 0.0 2.4976562499999998e-05 0.0 2.4977120535714285e-05 1.5 2.4987165178571426e-05 1.5 2.4987723214285713e-05 0.0 2.499441964285714e-05 0.0 2.4994977678571427e-05 1.5 2.500502232142857e-05 1.5 2.5005580357142855e-05 0.0 2.5012276785714283e-05 0.0 2.501283482142857e-05 1.5 2.5022879464285714e-05 1.5 2.5023437499999998e-05 0.0 2.503013392857143e-05 0.0 2.5030691964285712e-05 1.5 2.5040736607142856e-05 1.5 2.504129464285714e-05 0.0 2.504799107142857e-05 0.0 2.5048549107142854e-05 1.5 2.505859375e-05 1.5 2.5059151785714286e-05 0.0 2.5065848214285713e-05 0.0 2.506640625e-05 1.5 2.507645089285714e-05 1.5 2.5077008928571428e-05 0.0 2.5083705357142855e-05 0.0 2.5084263392857142e-05 1.5 2.5094308035714283e-05 1.5 2.509486607142857e-05 0.0 2.5101562499999998e-05 0.0 2.5102120535714284e-05 1.5 2.5112165178571426e-05 1.5 2.5112723214285713e-05 0.0 2.511941964285714e-05 0.0 2.5119977678571427e-05 1.5 2.5130022321428568e-05 1.5 2.5130580357142855e-05 0.0 2.5137276785714282e-05 0.0 2.513783482142857e-05 1.5 2.5147879464285714e-05 1.5 2.5148437499999997e-05 0.0 2.5155133928571428e-05 0.0 2.515569196428571e-05 1.5 2.5165736607142856e-05 1.5 2.516629464285714e-05 0.0 2.517299107142857e-05 0.0 2.5173549107142854e-05 1.5 2.518359375e-05 1.5 2.5184151785714285e-05 0.0 2.5190848214285713e-05 0.0 2.519140625e-05 1.5 2.520145089285714e-05 1.5 2.5202008928571428e-05 0.0 2.5208705357142855e-05 0.0 2.5209263392857142e-05 1.5 2.5219308035714283e-05 1.5 2.521986607142857e-05 0.0 2.5226562499999997e-05 0.0 2.5227120535714284e-05 1.5 2.5237165178571425e-05 1.5 2.5237723214285712e-05 0.0 2.524441964285714e-05 0.0 2.5244977678571426e-05 1.5 2.525502232142857e-05 1.5 2.5255580357142855e-05 0.0 2.5262276785714285e-05 0.0 2.526283482142857e-05 1.5 2.5272879464285713e-05 1.5 2.5273437499999997e-05 0.0 2.5280133928571428e-05 0.0 2.528069196428571e-05 1.5 2.5290736607142856e-05 1.5 2.5291294642857143e-05 0.0 2.529799107142857e-05 0.0 2.5298549107142857e-05 1.5 2.5308593749999998e-05 1.5 2.5309151785714285e-05 0.0 2.5315848214285712e-05 0.0 2.531640625e-05 1.5 2.532645089285714e-05 1.5 2.5327008928571427e-05 0.0 2.5333705357142855e-05 0.0 2.533426339285714e-05 1.5 2.5344308035714283e-05 1.5 2.534486607142857e-05 0.0 2.5351562499999997e-05 0.0 2.5352120535714284e-05 1.5 2.5362165178571425e-05 1.5 2.5362723214285712e-05 0.0 2.536941964285714e-05 0.0 2.5369977678571426e-05 1.5 2.538002232142857e-05 1.5 2.5380580357142854e-05 0.0 2.5387276785714285e-05 0.0 2.538783482142857e-05 1.5 2.5397879464285713e-05 1.5 2.53984375e-05 0.0 2.5405133928571427e-05 0.0 2.5405691964285714e-05 1.5 2.541517857142857e-05 1.5 2.5415736607142855e-05 0.0 2.5423549107142856e-05 0.0 2.542410714285714e-05 1.5 2.543303571428571e-05 1.5 2.5433593749999998e-05 0.0 2.544140625e-05 0.0 2.5441964285714286e-05 1.5 2.5450892857142857e-05 1.5 2.545145089285714e-05 0.0 2.545926339285714e-05 0.0 2.5459821428571428e-05 1.5 2.546875e-05 1.5 2.5469308035714282e-05 0.0 2.5477120535714283e-05 0.0 2.547767857142857e-05 1.5 2.548660714285714e-05 1.5 2.5487165178571428e-05 0.0 2.5494977678571426e-05 0.0 2.5495535714285713e-05 1.5 2.5504464285714284e-05 1.5 2.550502232142857e-05 0.0 2.5512834821428568e-05 0.0 2.5513392857142855e-05 1.5 2.5522321428571426e-05 1.5 2.5522879464285713e-05 0.0 2.5530691964285714e-05 0.0 2.5531249999999997e-05 1.5 2.554017857142857e-05 1.5 2.5540736607142855e-05 0.0 2.5548549107142856e-05 0.0 2.554910714285714e-05 1.5 2.5558035714285714e-05 1.5 2.5558593749999997e-05 0.0 2.556640625e-05 0.0 2.5566964285714285e-05 1.5 2.5575892857142856e-05 1.5 2.557645089285714e-05 0.0 2.558426339285714e-05 0.0 2.5584821428571428e-05 1.5 2.559375e-05 1.5 2.5594308035714285e-05 0.0 2.5602120535714283e-05 0.0 2.560267857142857e-05 1.5 2.561160714285714e-05 1.5 2.5612165178571428e-05 0.0 2.5619977678571425e-05 0.0 2.5620535714285712e-05 1.5 2.5629464285714283e-05 1.5 2.563002232142857e-05 0.0 2.563783482142857e-05 0.0 2.5638392857142854e-05 1.5 2.5647321428571426e-05 1.5 2.5647879464285712e-05 0.0 2.5655691964285713e-05 0.0 2.5656249999999997e-05 1.5 2.5665178571428568e-05 1.5 2.5665736607142855e-05 0.0 2.5673549107142856e-05 0.0 2.5674107142857143e-05 1.5 2.5683035714285714e-05 1.5 2.5683593749999997e-05 0.0 2.5691406249999998e-05 0.0 2.5691964285714285e-05 1.5 2.5700892857142856e-05 1.5 2.570145089285714e-05 0.0 2.570926339285714e-05 0.0 2.5709821428571427e-05 1.5 2.571875e-05 1.5 2.5719308035714285e-05 0.0 2.5727120535714283e-05 0.0 2.572767857142857e-05 1.5 2.573660714285714e-05 1.5 2.5737165178571427e-05 0.0 2.5744977678571425e-05 0.0 2.5745535714285712e-05 1.5 2.5754464285714283e-05 1.5 2.575502232142857e-05 0.0 2.576283482142857e-05 0.0 2.5763392857142854e-05 1.5 2.5772321428571425e-05 1.5 2.5772879464285712e-05 0.0 2.5780691964285713e-05 0.0 2.5781249999999996e-05 1.5 2.579017857142857e-05 1.5 2.5790736607142854e-05 0.0 2.5798549107142855e-05 0.0 2.5799107142857142e-05 1.5 2.5808035714285713e-05 1.5 2.5808593749999997e-05 0.0 2.5816406249999998e-05 0.0 2.5816964285714285e-05 1.5 2.5825892857142856e-05 1.5 2.5826450892857142e-05 0.0 2.583426339285714e-05 0.0 2.5834821428571427e-05 1.5 2.5843749999999998e-05 1.5 2.5844308035714285e-05 0.0 2.5852120535714282e-05 0.0 2.585267857142857e-05 1.5 2.586160714285714e-05 1.5 2.5862165178571427e-05 0.0 2.5869977678571428e-05 0.0 2.587053571428571e-05 1.5 2.5879464285714283e-05 1.5 2.588002232142857e-05 0.0 2.588783482142857e-05 0.0 2.5888392857142854e-05 1.5 2.589732142857143e-05 1.5 2.5897879464285712e-05 0.0 2.5905691964285713e-05 0.0 2.590625e-05 1.5 2.591517857142857e-05 1.5 2.5915736607142854e-05 0.0 2.5923549107142855e-05 0.0 2.5924107142857142e-05 1.5 2.5933035714285713e-05 1.5 2.593359375e-05 0.0 2.5941406249999997e-05 0.0 2.5941964285714284e-05 1.5 2.5950892857142855e-05 1.5 2.5951450892857142e-05 0.0 2.595926339285714e-05 0.0 2.5959821428571426e-05 1.5 2.5968749999999998e-05 1.5 2.5969308035714284e-05 0.0 2.5977120535714285e-05 0.0 2.597767857142857e-05 1.5 2.598660714285714e-05 1.5 2.5987165178571427e-05 0.0 2.5994977678571428e-05 0.0 2.599553571428571e-05 1.5 2.6004464285714282e-05 1.5 2.600502232142857e-05 0.0 2.601283482142857e-05 0.0 2.6013392857142857e-05 1.5 2.6022321428571428e-05 1.5 2.602287946428571e-05 0.0 2.6030691964285712e-05 0.0 2.603125e-05 1.5 2.604017857142857e-05 1.5 2.6040736607142854e-05 0.0 2.6048549107142855e-05 0.0 2.604910714285714e-05 1.5 2.6058035714285713e-05 1.5 2.605859375e-05 0.0 2.6066406249999997e-05 0.0 2.6066964285714284e-05 1.5 2.6075892857142855e-05 1.5 2.6076450892857142e-05 0.0 2.6084821428571426e-05 0.0 2.6085379464285713e-05 1.5 2.6093191964285714e-05 1.5 2.6093749999999997e-05 0.0 2.610267857142857e-05 0.0 2.6103236607142855e-05 1.5 2.6111049107142856e-05 1.5 2.611160714285714e-05 0.0 2.612053571428571e-05 0.0 2.6121093749999998e-05 1.5 2.612890625e-05 1.5 2.6129464285714285e-05 0.0 2.6138392857142856e-05 0.0 2.613895089285714e-05 1.5 2.614676339285714e-05 1.5 2.6147321428571428e-05 0.0 2.615625e-05 0.0 2.6156808035714282e-05 1.5 2.6164620535714283e-05 1.5 2.616517857142857e-05 0.0 2.617410714285714e-05 0.0 2.6174665178571428e-05 1.5 2.6182477678571426e-05 1.5 2.6183035714285712e-05 0.0 2.6191964285714283e-05 0.0 2.619252232142857e-05 1.5 2.6200334821428568e-05 1.5 2.6200892857142855e-05 0.0 2.6209821428571426e-05 0.0 2.6210379464285713e-05 1.5 2.6218191964285714e-05 1.5 2.6218749999999997e-05 0.0 2.6227678571428568e-05 0.0 2.6228236607142855e-05 1.5 2.6236049107142856e-05 1.5 2.6236607142857143e-05 0.0 2.6245535714285714e-05 0.0 2.6246093749999997e-05 1.5 2.6253906249999998e-05 1.5 2.6254464285714285e-05 0.0 2.6263392857142856e-05 0.0 2.626395089285714e-05 1.5 2.627176339285714e-05 1.5 2.6272321428571427e-05 0.0 2.628125e-05 0.0 2.6281808035714285e-05 1.5 2.6289620535714283e-05 1.5 2.629017857142857e-05 0.0 2.629910714285714e-05 0.0 2.6299665178571428e-05 1.5 2.6307477678571425e-05 1.5 2.6308035714285712e-05 0.0 2.6316964285714283e-05 0.0 2.631752232142857e-05 1.5 2.632533482142857e-05 1.5 2.6325892857142854e-05 0.0 2.6334821428571425e-05 0.0 2.6335379464285712e-05 1.5 2.6343191964285713e-05 1.5 2.6343749999999997e-05 0.0 2.635267857142857e-05 0.0 2.6353236607142855e-05 1.5 2.6361049107142856e-05 1.5 2.6361607142857142e-05 0.0 2.6370535714285713e-05 0.0 2.6371093749999997e-05 1.5 2.6378906249999998e-05 1.5 2.6379464285714285e-05 0.0 2.6388392857142856e-05 0.0 2.6388950892857143e-05 1.5 2.639676339285714e-05 1.5 2.6397321428571427e-05 0.0 2.6406249999999998e-05 0.0 2.6406808035714285e-05 1.5 2.6414620535714283e-05 1.5 2.641517857142857e-05 0.0 2.642410714285714e-05 0.0 2.6424665178571427e-05 1.5 2.6432477678571428e-05 1.5 2.643303571428571e-05 0.0 2.6441964285714283e-05 0.0 2.644252232142857e-05 1.5 2.645033482142857e-05 1.5 2.6450892857142854e-05 0.0 2.6459821428571425e-05 0.0 2.6460379464285712e-05 1.5 2.6468191964285713e-05 1.5 2.646875e-05 0.0 2.647767857142857e-05 0.0 2.6478236607142854e-05 1.5 2.6486049107142855e-05 1.5 2.6486607142857142e-05 0.0 2.6495535714285713e-05 0.0 2.6496093749999996e-05 1.5 2.6503906249999998e-05 1.5 2.6504464285714284e-05 0.0 2.6513392857142855e-05 0.0 2.6513950892857142e-05 1.5 2.652176339285714e-05 1.5 2.6522321428571427e-05 0.0 2.6531249999999998e-05 0.0 2.6531808035714285e-05 1.5 2.6539620535714282e-05 1.5 2.654017857142857e-05 0.0 2.654910714285714e-05 0.0 2.6549665178571427e-05 1.5 2.6557477678571428e-05 1.5 2.655803571428571e-05 0.0 2.6566964285714282e-05 0.0 2.656752232142857e-05 1.5 2.657533482142857e-05 1.5 2.6575892857142854e-05 0.0 2.6584821428571428e-05 0.0 2.658537946428571e-05 1.5 2.6593191964285713e-05 1.5 2.659375e-05 0.0 2.660267857142857e-05 0.0 2.6603236607142854e-05 1.5 2.6611049107142855e-05 1.5 2.661160714285714e-05 0.0 2.6620535714285713e-05 0.0 2.662109375e-05 1.5 2.6628906249999997e-05 1.5 2.6629464285714284e-05 0.0 2.6638392857142855e-05 0.0 2.6638950892857142e-05 1.5 2.664676339285714e-05 1.5 2.6647321428571426e-05 0.0 2.6656249999999997e-05 0.0 2.6656808035714284e-05 1.5 2.6664620535714285e-05 1.5 2.666517857142857e-05 0.0 2.667410714285714e-05 0.0 2.6674665178571426e-05 1.5 2.6682477678571428e-05 1.5 2.668303571428571e-05 0.0 2.6691964285714285e-05 0.0 2.669252232142857e-05 1.5 2.670033482142857e-05 1.5 2.6700892857142857e-05 0.0 2.6709821428571428e-05 0.0 2.671037946428571e-05 1.5 2.6718191964285712e-05 1.5 2.671875e-05 0.0 2.672767857142857e-05 0.0 2.6728236607142857e-05 1.5 2.6736049107142854e-05 1.5 2.673660714285714e-05 0.0 2.6745535714285712e-05 0.0 2.674609375e-05 1.5 2.6753348214285713e-05 1.5 2.6753906249999997e-05 0.0 2.676395089285714e-05 0.0 2.6764508928571428e-05 1.5 2.6771205357142856e-05 1.5 2.6771763392857143e-05 0.0 2.6781808035714284e-05 0.0 2.678236607142857e-05 1.5 2.6789062499999998e-05 1.5 2.6789620535714285e-05 0.0 2.6799665178571426e-05 0.0 2.6800223214285713e-05 1.5 2.680691964285714e-05 1.5 2.6807477678571427e-05 0.0 2.681752232142857e-05 0.0 2.6818080357142855e-05 1.5 2.6824776785714283e-05 1.5 2.682533482142857e-05 0.0 2.683537946428571e-05 0.0 2.6835937499999998e-05 1.5 2.6842633928571425e-05 1.5 2.6843191964285712e-05 0.0 2.6853236607142856e-05 0.0 2.685379464285714e-05 1.5 2.686049107142857e-05 1.5 2.6861049107142854e-05 0.0 2.687109375e-05 0.0 2.6871651785714282e-05 1.5 2.6878348214285713e-05 1.5 2.6878906249999996e-05 0.0 2.688895089285714e-05 0.0 2.6889508928571428e-05 1.5 2.6896205357142855e-05 1.5 2.6896763392857142e-05 0.0 2.6906808035714283e-05 0.0 2.690736607142857e-05 1.5 2.6914062499999998e-05 1.5 2.6914620535714285e-05 0.0 2.6924665178571426e-05 0.0 2.6925223214285713e-05 1.5 2.693191964285714e-05 1.5 2.6932477678571427e-05 0.0 2.6942522321428568e-05 0.0 2.6943080357142855e-05 1.5 2.6949776785714282e-05 1.5 2.695033482142857e-05 0.0 2.6960379464285714e-05 0.0 2.6960937499999997e-05 1.5 2.6967633928571428e-05 1.5 2.696819196428571e-05 0.0 2.6978236607142856e-05 0.0 2.697879464285714e-05 1.5 2.698549107142857e-05 1.5 2.6986049107142854e-05 0.0 2.699609375e-05 0.0 2.6996651785714285e-05 1.5 2.7003348214285713e-05 1.5 2.700390625e-05 0.0 2.701395089285714e-05 0.0 2.7014508928571428e-05 1.5 2.7021205357142855e-05 1.5 2.7021763392857142e-05 0.0 2.7031808035714283e-05 0.0 2.703236607142857e-05 1.5 2.7039062499999997e-05 1.5 2.7039620535714284e-05 0.0 2.7049665178571425e-05 0.0 2.7050223214285712e-05 1.5 2.705691964285714e-05 1.5 2.7057477678571426e-05 0.0 2.706752232142857e-05 0.0 2.7068080357142855e-05 1.5 2.7074776785714285e-05 1.5 2.707533482142857e-05 0.0 2.7085379464285713e-05 0.0 2.7085937499999997e-05 1.5 2.7092633928571428e-05 1.5 2.709319196428571e-05 0.0 2.7103236607142856e-05 0.0 2.7103794642857143e-05 1.5 2.711049107142857e-05 1.5 2.7111049107142857e-05 0.0 2.7121093749999998e-05 0.0 2.7121651785714285e-05 1.5 2.7128348214285712e-05 1.5 2.712890625e-05 0.0 2.713895089285714e-05 0.0 2.7139508928571427e-05 1.5 2.7146205357142855e-05 1.5 2.714676339285714e-05 0.0 2.7156808035714283e-05 0.0 2.715736607142857e-05 1.5 2.7164062499999997e-05 1.5 2.7164620535714284e-05 0.0 2.7174665178571425e-05 0.0 2.7175223214285712e-05 1.5 2.718191964285714e-05 1.5 2.7182477678571426e-05 0.0 2.719252232142857e-05 0.0 2.7193080357142854e-05 1.5 2.7199776785714285e-05 1.5 2.720033482142857e-05 0.0 2.7210379464285713e-05 0.0 2.7210937499999996e-05 1.5 2.7217633928571427e-05 1.5 2.721819196428571e-05 0.0 2.7228236607142855e-05 0.0 2.7228794642857142e-05 1.5 2.723549107142857e-05 1.5 2.7236049107142856e-05 0.0 2.7246093749999998e-05 0.0 2.7246651785714285e-05 1.5 2.7253348214285712e-05 1.5 2.725390625e-05 0.0 2.726395089285714e-05 0.0 2.7264508928571427e-05 1.5 2.7271205357142854e-05 1.5 2.727176339285714e-05 0.0 2.7281808035714282e-05 0.0 2.728236607142857e-05 1.5 2.7289062499999997e-05 1.5 2.7289620535714283e-05 0.0 2.7299665178571428e-05 0.0 2.730022321428571e-05 1.5 2.7306919642857142e-05 1.5 2.7307477678571426e-05 0.0 2.731752232142857e-05 0.0 2.7318080357142854e-05 1.5 2.7324776785714285e-05 1.5 2.7325334821428568e-05 0.0 2.7335379464285713e-05 0.0 2.73359375e-05 1.5 2.7342633928571427e-05 1.5 2.7343191964285714e-05 0.0 2.7353236607142855e-05 0.0 2.7353794642857142e-05 1.5 2.736049107142857e-05 1.5 2.7361049107142856e-05 0.0 2.7371093749999997e-05 0.0 2.7371651785714284e-05 1.5 2.7378348214285712e-05 1.5 2.737890625e-05 0.0 2.738895089285714e-05 0.0 2.7389508928571427e-05 1.5 2.7396205357142854e-05 1.5 2.739676339285714e-05 0.0 2.7406808035714282e-05 0.0 2.740736607142857e-05 1.5 2.7414062499999996e-05 1.5 2.7414620535714283e-05 0.0 2.7424665178571428e-05 0.0 2.742522321428571e-05 1.5 2.7431919642857142e-05 1.5 2.7432477678571425e-05 0.0 2.744252232142857e-05 0.0 2.7443080357142857e-05 1.5 2.7449776785714284e-05 1.5 2.745033482142857e-05 0.0 2.7460379464285712e-05 0.0 2.74609375e-05 1.5 2.7467633928571427e-05 1.5 2.7468191964285713e-05 0.0 2.7478236607142855e-05 0.0 2.747879464285714e-05 1.5 2.748549107142857e-05 1.5 2.7486049107142856e-05 0.0 2.7496093749999997e-05 0.0 2.7496651785714284e-05 1.5 2.750334821428571e-05 1.5 2.7503906249999998e-05 0.0 2.751395089285714e-05 0.0 2.7514508928571426e-05 1.5 2.7521205357142854e-05 1.5 2.752176339285714e-05 0.0 2.7531808035714285e-05 0.0 2.753236607142857e-05 1.5 2.75390625e-05 1.5 2.7539620535714283e-05 0.0 2.7549665178571427e-05 0.0 2.755022321428571e-05 1.5 2.7556919642857142e-05 1.5 2.7557477678571425e-05 0.0 2.756752232142857e-05 0.0 2.7568080357142857e-05 1.5 2.7574776785714284e-05 1.5 2.757533482142857e-05 0.0 2.7585379464285712e-05 0.0 2.75859375e-05 1.5 2.7592633928571426e-05 1.5 2.7593191964285713e-05 0.0 2.7603236607142854e-05 0.0 2.760379464285714e-05 1.5 2.761049107142857e-05 1.5 2.7611049107142855e-05 0.0 2.7621093749999997e-05 0.0 2.7621651785714283e-05 1.5 2.762834821428571e-05 1.5 2.7628906249999998e-05 0.0 2.7638950892857142e-05 0.0 2.7639508928571426e-05 1.5 2.7646205357142857e-05 1.5 2.764676339285714e-05 0.0 2.7656808035714285e-05 0.0 2.7657366071428568e-05 1.5 2.76640625e-05 1.5 2.7664620535714282e-05 0.0 2.7674665178571427e-05 0.0 2.7675223214285714e-05 1.5 2.768191964285714e-05 1.5 2.7682477678571428e-05 0.0 2.769252232142857e-05 0.0 2.7693080357142856e-05 1.5 2.7699776785714284e-05 1.5 2.770033482142857e-05 0.0 2.7710379464285712e-05 0.0 2.77109375e-05 1.5 2.7717633928571426e-05 1.5 2.7718191964285713e-05 0.0 2.7728236607142854e-05 0.0 2.772879464285714e-05 1.5 2.773549107142857e-05 1.5 2.7736049107142855e-05 0.0 2.7746093749999996e-05 0.0 2.7746651785714283e-05 1.5 2.775334821428571e-05 1.5 2.7753906249999997e-05 0.0 2.7763950892857142e-05 0.0 2.7764508928571425e-05 1.5 2.7771205357142856e-05 1.5 2.777176339285714e-05 0.0 2.7781808035714284e-05 0.0 2.7782366071428568e-05 1.5 2.77890625e-05 1.5 2.7789620535714282e-05 0.0 2.7799665178571427e-05 0.0 2.7800223214285713e-05 1.5 2.780691964285714e-05 1.5 2.7807477678571428e-05 0.0 2.781752232142857e-05 0.0 2.7818080357142856e-05 1.5 2.7824776785714283e-05 1.5 2.782533482142857e-05 0.0 2.783537946428571e-05 0.0 2.7835937499999998e-05 1.5 2.7842633928571426e-05 1.5 2.7843191964285712e-05 0.0 2.7853236607142854e-05 0.0 2.785379464285714e-05 1.5 2.7860491071428568e-05 1.5 2.7861049107142855e-05 0.0 2.787109375e-05 0.0 2.7871651785714283e-05 1.5 2.7878348214285714e-05 1.5 2.7878906249999997e-05 0.0 2.7888950892857142e-05 0.0 2.7889508928571425e-05 1.5 2.7896205357142856e-05 1.5 2.789676339285714e-05 0.0 2.7906808035714284e-05 0.0 2.790736607142857e-05 1.5 2.79140625e-05 1.5 2.7914620535714285e-05 0.0 2.7924665178571426e-05 0.0 2.7925223214285713e-05 1.5 2.793191964285714e-05 1.5 2.7932477678571427e-05 0.0 2.794252232142857e-05 0.0 2.7943080357142855e-05 1.5 2.7949776785714283e-05 1.5 2.795033482142857e-05 0.0 2.796037946428571e-05 0.0 2.7960937499999998e-05 1.5 2.7967633928571425e-05 1.5 2.7968191964285712e-05 0.0 2.7978236607142857e-05 0.0 2.797879464285714e-05 1.5 2.798549107142857e-05 1.5 2.7986049107142854e-05 0.0 2.799609375e-05 0.0 2.7996651785714282e-05 1.5 2.8003348214285713e-05 1.5 2.8003906249999997e-05 0.0 2.801395089285714e-05 0.0 2.8014508928571428e-05 1.5 2.8021205357142856e-05 1.5 2.8021763392857142e-05 0.0 2.8031808035714284e-05 0.0 2.803236607142857e-05 1.5 2.8039062499999998e-05 1.5 2.8039620535714285e-05 0.0 2.8049665178571426e-05 0.0 2.8050223214285713e-05 1.5 2.805691964285714e-05 1.5 2.8057477678571427e-05 0.0 2.806752232142857e-05 0.0 2.8068080357142855e-05 1.5 2.8074776785714283e-05 1.5 2.807533482142857e-05 0.0 2.808537946428571e-05 0.0 2.8085937499999997e-05 1.5 2.8092633928571425e-05 1.5 2.8093191964285712e-05 0.0 2.8103236607142856e-05 0.0 2.810379464285714e-05 1.5 2.811049107142857e-05 1.5 2.8111049107142854e-05 0.0 2.812109375e-05 0.0 2.8121651785714282e-05 1.5 2.8128348214285713e-05 1.5 2.8128906249999996e-05 0.0 2.813895089285714e-05 0.0 2.8139508928571428e-05 1.5 2.8146205357142855e-05 1.5 2.8146763392857142e-05 0.0 2.8156808035714283e-05 0.0 2.815736607142857e-05 1.5 2.8164062499999998e-05 1.5 2.8164620535714284e-05 0.0 2.8174665178571426e-05 0.0 2.8175223214285712e-05 1.5 2.818191964285714e-05 1.5 2.8182477678571427e-05 0.0 2.8192522321428568e-05 0.0 2.8193080357142855e-05 1.5 2.8199776785714282e-05 1.5 2.820033482142857e-05 0.0 2.8210379464285714e-05 0.0 2.8210937499999997e-05 1.5 2.8217633928571428e-05 1.5 2.821819196428571e-05 0.0 2.8228236607142856e-05 0.0 2.822879464285714e-05 1.5 2.823549107142857e-05 1.5 2.8236049107142854e-05 0.0 2.824609375e-05 0.0 2.8246651785714285e-05 1.5 2.8253348214285713e-05 1.5 2.825390625e-05 0.0 2.826395089285714e-05 0.0 2.8264508928571427e-05 1.5 2.8271205357142855e-05 1.5 2.8271763392857142e-05 0.0 2.8281808035714283e-05 0.0 2.828236607142857e-05 1.5 2.8289062499999997e-05 1.5 2.8289620535714284e-05 0.0 2.8299665178571425e-05 0.0 2.8300223214285712e-05 1.5 2.830691964285714e-05 1.5 2.8307477678571426e-05 0.0 2.831752232142857e-05 0.0 2.8318080357142854e-05 1.5 2.8324776785714285e-05 1.5 2.832533482142857e-05 0.0 2.8335379464285713e-05 0.0 2.8335937499999997e-05 1.5 2.8342633928571428e-05 1.5 2.834319196428571e-05 0.0 2.8353236607142856e-05 0.0 2.8353794642857142e-05 1.5 2.836049107142857e-05 1.5 2.8361049107142857e-05 0.0 2.8371093749999998e-05 0.0 2.8371651785714285e-05 1.5 2.8378348214285712e-05 1.5 2.837890625e-05 0.0 2.838895089285714e-05 0.0 2.8389508928571427e-05 1.5 2.8396205357142855e-05 1.5 2.839676339285714e-05 0.0 2.8406808035714283e-05 0.0 2.840736607142857e-05 1.5 2.8414062499999997e-05 1.5 2.8414620535714284e-05 0.0 2.8424665178571425e-05 0.0 2.8425223214285712e-05 1.5 2.843191964285714e-05 1.5 2.8432477678571426e-05 0.0 2.844252232142857e-05 0.0 2.8443080357142854e-05 1.5 2.8449776785714285e-05 1.5 2.845033482142857e-05 0.0 2.8460379464285713e-05 0.0 2.8460937499999996e-05 1.5 2.8467633928571427e-05 1.5 2.846819196428571e-05 0.0 2.8478236607142855e-05 0.0 2.8478794642857142e-05 1.5 2.848549107142857e-05 1.5 2.8486049107142856e-05 0.0 2.8496093749999998e-05 0.0 2.8496651785714284e-05 1.5 2.8503348214285712e-05 1.5 2.850390625e-05 0.0 2.851395089285714e-05 0.0 2.8514508928571427e-05 1.5 2.8521205357142854e-05 1.5 2.852176339285714e-05 0.0 2.8531808035714282e-05 0.0 2.853236607142857e-05 1.5 2.8539062499999997e-05 1.5 2.8539620535714283e-05 0.0 2.8549665178571428e-05 0.0 2.855022321428571e-05 1.5 2.8556919642857142e-05 1.5 2.8557477678571426e-05 0.0 2.856752232142857e-05 0.0 2.8568080357142854e-05 1.5 2.8574776785714285e-05 1.5 2.8575334821428568e-05 0.0 2.8585379464285713e-05 0.0 2.85859375e-05 1.5 2.8592633928571427e-05 1.5 2.8593191964285714e-05 0.0 2.8603236607142855e-05 0.0 2.8603794642857142e-05 1.5 2.861049107142857e-05 1.5 2.8611049107142856e-05 0.0 2.8621093749999997e-05 0.0 2.8621651785714284e-05 1.5 2.862834821428571e-05 1.5 2.862890625e-05 0.0 2.863895089285714e-05 0.0 2.8639508928571426e-05 1.5 2.8646205357142854e-05 1.5 2.864676339285714e-05 0.0 2.8656808035714285e-05 0.0 2.865736607142857e-05 1.5 2.86640625e-05 1.5 2.8664620535714283e-05 0.0 2.8674665178571428e-05 0.0 2.867522321428571e-05 1.5 2.8681919642857142e-05 1.5 2.8682477678571425e-05 0.0 2.869252232142857e-05 0.0 2.8693080357142857e-05 1.5 2.8699776785714284e-05 1.5 2.870033482142857e-05 0.0 2.8710379464285712e-05 0.0 2.87109375e-05 1.5 2.8717633928571427e-05 1.5 2.8718191964285713e-05 0.0 2.8728236607142855e-05 0.0 2.872879464285714e-05 1.5 2.873549107142857e-05 1.5 2.8736049107142856e-05 0.0 2.8746093749999997e-05 0.0 2.8746651785714284e-05 1.5 2.875334821428571e-05 1.5 2.8753906249999998e-05 0.0 2.876395089285714e-05 0.0 2.8764508928571426e-05 1.5 2.8771205357142854e-05 1.5 2.877176339285714e-05 0.0 2.8781808035714285e-05 0.0 2.878236607142857e-05 1.5 2.87890625e-05 1.5 2.8789620535714283e-05 0.0 2.8799665178571427e-05 0.0 2.880022321428571e-05 1.5 2.880691964285714e-05 1.5 2.8807477678571425e-05 0.0 2.881752232142857e-05 0.0 2.8818080357142856e-05 1.5 2.8824776785714284e-05 1.5 2.882533482142857e-05 0.0 2.8835379464285712e-05 0.0 2.88359375e-05 1.5 2.8842633928571426e-05 1.5 2.8843191964285713e-05 0.0 2.8853236607142854e-05 0.0 2.885379464285714e-05 1.5 2.886049107142857e-05 1.5 2.8861049107142855e-05 0.0 2.8871093749999997e-05 0.0 2.8871651785714283e-05 1.5 2.887834821428571e-05 1.5 2.8878906249999998e-05 0.0 2.8888950892857142e-05 0.0 2.8889508928571426e-05 1.5 2.8896205357142857e-05 1.5 2.889676339285714e-05 0.0 2.8906808035714285e-05 0.0 2.8907366071428568e-05 1.5 2.89140625e-05 1.5 2.8914620535714282e-05 0.0 2.8924665178571427e-05 0.0 2.8925223214285714e-05 1.5 2.893191964285714e-05 1.5 2.8932477678571428e-05 0.0 2.894252232142857e-05 0.0 2.8943080357142856e-05 1.5 2.8949776785714284e-05 1.5 2.895033482142857e-05 0.0 2.896037946428571e-05 0.0 2.89609375e-05 1.5 2.8967633928571426e-05 1.5 2.8968191964285713e-05 0.0 2.8978236607142854e-05 0.0 2.897879464285714e-05 1.5 2.8985491071428568e-05 1.5 2.8986049107142855e-05 0.0 2.8996093749999996e-05 0.0 2.8996651785714283e-05 1.5 2.900334821428571e-05 1.5 2.9003906249999997e-05 0.0 2.9013950892857142e-05 0.0 2.9014508928571425e-05 1.5 2.9021205357142856e-05 1.5 2.902176339285714e-05 0.0 2.9031808035714284e-05 0.0 2.9032366071428568e-05 1.5 2.90390625e-05 1.5 2.9039620535714282e-05 0.0 2.9049665178571427e-05 0.0 2.9050223214285713e-05 1.5 2.905691964285714e-05 1.5 2.9057477678571428e-05 0.0 2.906752232142857e-05 0.0 2.9068080357142856e-05 1.5 2.9074776785714283e-05 1.5 2.907533482142857e-05 0.0 2.908537946428571e-05 0.0 2.9085937499999998e-05 1.5 2.9092633928571426e-05 1.5 2.9093191964285712e-05 0.0 2.9103236607142854e-05 0.0 2.910379464285714e-05 1.5 2.9110491071428568e-05 1.5 2.9111049107142855e-05 0.0 2.912109375e-05 0.0 2.9121651785714283e-05 1.5 2.9128348214285714e-05 1.5 2.9128906249999997e-05 0.0 2.913895089285714e-05 0.0 2.9139508928571425e-05 1.5 2.9146205357142856e-05 1.5 2.914676339285714e-05 0.0 2.9156808035714284e-05 0.0 2.915736607142857e-05 1.5 2.9164062499999998e-05 1.5 2.9164620535714285e-05 0.0 2.9174665178571426e-05 0.0 2.9175223214285713e-05 1.5 2.918191964285714e-05 1.5 2.9182477678571427e-05 0.0 2.919252232142857e-05 0.0 2.9193080357142855e-05 1.5 2.9199776785714283e-05 1.5 2.920033482142857e-05 0.0 2.921037946428571e-05 0.0 2.9210937499999998e-05 1.5 2.9217633928571425e-05 1.5 2.9218191964285712e-05 0.0 2.9228236607142857e-05 0.0 2.922879464285714e-05 1.5 2.923549107142857e-05 1.5 2.9236049107142854e-05 0.0 2.924609375e-05 0.0 2.9246651785714282e-05 1.5 2.9253348214285713e-05 1.5 2.9253906249999997e-05 0.0 2.926395089285714e-05 0.0 2.9264508928571428e-05 1.5 2.9271205357142856e-05 1.5 2.9271763392857142e-05 0.0 2.9281808035714284e-05 0.0 2.928236607142857e-05 1.5 2.9289062499999998e-05 1.5 2.9289620535714285e-05 0.0 2.9299665178571426e-05 0.0 2.9300223214285713e-05 1.5 2.930691964285714e-05 1.5 2.9307477678571427e-05 0.0 2.9317522321428568e-05 0.0 2.9318080357142855e-05 1.5 2.9324776785714283e-05 1.5 2.932533482142857e-05 0.0 2.933537946428571e-05 0.0 2.9335937499999997e-05 1.5 2.9342633928571425e-05 1.5 2.934319196428571e-05 0.0 2.9353236607142856e-05 0.0 2.935379464285714e-05 1.5 2.936049107142857e-05 1.5 2.9361049107142854e-05 0.0 2.937109375e-05 0.0 2.9371651785714282e-05 1.5 2.9378348214285713e-05 1.5 2.9378906249999996e-05 0.0 2.938895089285714e-05 0.0 2.9389508928571428e-05 1.5 2.9396205357142855e-05 1.5 2.9396763392857142e-05 0.0 2.9406808035714283e-05 0.0 2.940736607142857e-05 1.5 2.9414062499999998e-05 1.5 2.9414620535714284e-05 0.0 2.9424665178571426e-05 0.0 2.9425223214285712e-05 1.5 2.9432477678571427e-05 1.5 2.9433035714285713e-05 0.0 2.9441964285714285e-05 0.0 2.9442522321428568e-05 1.5 2.945033482142857e-05 1.5 2.9450892857142856e-05 0.0 2.9459821428571427e-05 0.0 2.9460379464285714e-05 1.5 2.946819196428571e-05 1.5 2.9468749999999998e-05 0.0 2.947767857142857e-05 0.0 2.9478236607142856e-05 1.5 2.9486049107142854e-05 1.5 2.948660714285714e-05 0.0 2.949553571428571e-05 0.0 2.9496093749999998e-05 1.5 2.950390625e-05 1.5 2.9504464285714283e-05 0.0 2.9513392857142854e-05 0.0 2.951395089285714e-05 1.5 2.952176339285714e-05 1.5 2.9522321428571425e-05 0.0 2.953125e-05 0.0 2.9531808035714283e-05 1.5 2.9539620535714284e-05 1.5 2.954017857142857e-05 0.0 2.9549107142857142e-05 0.0 2.9549665178571425e-05 1.5 2.9557477678571426e-05 1.5 2.9558035714285713e-05 0.0 2.9566964285714284e-05 0.0 2.956752232142857e-05 1.5 2.957533482142857e-05 1.5 2.9575892857142855e-05 0.0 2.9584821428571427e-05 0.0 2.9585379464285713e-05 1.5 2.959319196428571e-05 1.5 2.9593749999999998e-05 0.0 2.960267857142857e-05 0.0 2.9603236607142856e-05 1.5 2.9611049107142857e-05 1.5 2.961160714285714e-05 0.0 2.962053571428571e-05 0.0 2.9621093749999998e-05 1.5 2.962890625e-05 1.5 2.9629464285714282e-05 0.0 2.9638392857142853e-05 0.0 2.963895089285714e-05 1.5 2.964676339285714e-05 1.5 2.9647321428571428e-05 0.0 2.965625e-05 0.0 2.9656808035714283e-05 1.5 2.9664620535714284e-05 1.5 2.966517857142857e-05 0.0 2.967410714285714e-05 0.0 2.9674665178571425e-05 1.5 2.9682477678571426e-05 1.5 2.9683035714285713e-05 0.0 2.9691964285714284e-05 0.0 2.969252232142857e-05 1.5 2.9700334821428568e-05 1.5 2.9700892857142855e-05 0.0 2.9709821428571426e-05 0.0 2.9710379464285713e-05 1.5 2.971819196428571e-05 1.5 2.9718749999999997e-05 0.0 2.972767857142857e-05 0.0 2.9728236607142855e-05 1.5 2.9736049107142856e-05 1.5 2.973660714285714e-05 0.0 2.974553571428571e-05 0.0 2.9746093749999998e-05 1.5 2.975390625e-05 1.5 2.9754464285714282e-05 0.0 2.9763392857142857e-05 0.0 2.976395089285714e-05 1.5 2.977176339285714e-05 1.5 2.9772321428571428e-05 0.0 2.978125e-05 0.0 2.9781808035714282e-05 1.5 2.9789620535714283e-05 1.5 2.979017857142857e-05 0.0 2.979910714285714e-05 0.0 2.9799665178571428e-05 1.5 2.9807477678571426e-05 1.5 2.9808035714285712e-05 0.0 2.9816964285714283e-05 0.0 2.981752232142857e-05 1.5 2.9825334821428568e-05 1.5 2.9825892857142855e-05 0.0 2.9834821428571426e-05 0.0 2.9835379464285713e-05 1.5 2.9843191964285714e-05 1.5 2.9843749999999997e-05 0.0 2.9852678571428568e-05 0.0 2.9853236607142855e-05 1.5 2.9861049107142856e-05 1.5 2.986160714285714e-05 0.0 2.9870535714285714e-05 0.0 2.9871093749999997e-05 1.5 2.9878906249999998e-05 1.5 2.9879464285714285e-05 0.0 2.9888392857142856e-05 0.0 2.988895089285714e-05 1.5 2.989676339285714e-05 1.5 2.9897321428571427e-05 0.0 2.990625e-05 0.0 2.9906808035714285e-05 1.5 2.9914620535714283e-05 1.5 2.991517857142857e-05 0.0 2.992410714285714e-05 0.0 2.9924665178571428e-05 1.5 2.9932477678571425e-05 1.5 2.9933035714285712e-05 0.0 2.9941964285714283e-05 0.0 2.994252232142857e-05 1.5 2.995033482142857e-05 1.5 2.9950892857142854e-05 0.0 2.9959821428571425e-05 0.0 2.9960379464285712e-05 1.5 2.9968191964285713e-05 1.5 2.9968749999999997e-05 0.0 2.9977678571428568e-05 0.0 2.9978236607142855e-05 1.5 2.9986049107142856e-05 1.5 2.9986607142857142e-05 0.0 2.9995535714285713e-05 0.0 2.9996093749999997e-05 1.5 3.0003906249999998e-05 1.5 3.0004464285714285e-05 0.0 3.0013392857142856e-05 0.0 3.001395089285714e-05 1.5 3.002176339285714e-05 1.5 3.0022321428571427e-05 0.0 3.0031249999999998e-05 0.0 3.0031808035714285e-05 1.5 3.0039620535714283e-05 1.5 3.004017857142857e-05 0.0 3.004910714285714e-05 0.0 3.0049665178571427e-05 1.5 3.0057477678571425e-05 1.5 3.005803571428571e-05 0.0 3.0066964285714283e-05 0.0 3.006752232142857e-05 1.5 3.007533482142857e-05 1.5 3.0075892857142854e-05 0.0 3.0084821428571425e-05 0.0 3.0085379464285712e-05 1.5 3.0093191964285713e-05 1.5 3.0093749999999996e-05 0.0 3.0102120535714284e-05 0.0 3.010267857142857e-05 1.5 3.0111607142857142e-05 1.5 3.0112165178571425e-05 0.0 3.0119977678571426e-05 0.0 3.0120535714285713e-05 1.5 3.0129464285714284e-05 1.5 3.0130022321428568e-05 0.0 3.013783482142857e-05 0.0 3.0138392857142855e-05 1.5 3.0147321428571427e-05 1.5 3.0147879464285713e-05 0.0 3.015569196428571e-05 0.0 3.0156249999999998e-05 1.5 3.016517857142857e-05 1.5 3.0165736607142856e-05 0.0 3.0173549107142853e-05 0.0 3.017410714285714e-05 1.5 3.018303571428571e-05 1.5 3.0183593749999998e-05 0.0 3.019140625e-05 0.0 3.0191964285714282e-05 1.5 3.0200892857142854e-05 1.5 3.020145089285714e-05 0.0 3.020926339285714e-05 0.0 3.0209821428571425e-05 1.5 3.021875e-05 1.5 3.0219308035714283e-05 0.0 3.0227120535714284e-05 0.0 3.022767857142857e-05 1.5 3.023660714285714e-05 1.5 3.0237165178571425e-05 0.0 3.0244977678571426e-05 0.0 3.0245535714285713e-05 1.5 3.0254464285714284e-05 1.5 3.025502232142857e-05 0.0 3.026283482142857e-05 0.0 3.0263392857142855e-05 1.5 3.0272321428571426e-05 1.5 3.0272879464285713e-05 0.0 3.028069196428571e-05 0.0 3.0281249999999997e-05 1.5 3.029017857142857e-05 1.5 3.0290736607142855e-05 0.0 3.0298549107142856e-05 0.0 3.029910714285714e-05 1.5 3.030803571428571e-05 1.5 3.0308593749999998e-05 0.0 3.031640625e-05 0.0 3.0316964285714282e-05 1.5 3.0325892857142857e-05 1.5 3.032645089285714e-05 0.0 3.033426339285714e-05 0.0 3.0334821428571428e-05 1.5 3.034375e-05 1.5 3.0344308035714282e-05 0.0 3.0352120535714283e-05 0.0 3.035267857142857e-05 1.5 3.036160714285714e-05 1.5 3.0362165178571428e-05 0.0 3.0369977678571426e-05 0.0 3.0370535714285712e-05 1.5 3.0379464285714284e-05 1.5 3.038002232142857e-05 0.0 3.0387834821428568e-05 0.0 3.0388392857142855e-05 1.5 3.0397321428571426e-05 1.5 3.0397879464285713e-05 0.0 3.0405691964285714e-05 0.0 3.0406249999999997e-05 1.5 3.0415178571428568e-05 1.5 3.0415736607142855e-05 0.0 3.0423549107142856e-05 0.0 3.042410714285714e-05 1.5 3.043303571428571e-05 1.5 3.0433593749999997e-05 0.0 3.044140625e-05 0.0 3.0441964285714285e-05 1.5 3.0450892857142856e-05 1.5 3.045145089285714e-05 0.0 3.045926339285714e-05 0.0 3.0459821428571427e-05 1.5 3.046875e-05 1.5 3.0469308035714282e-05 0.0 3.0477120535714283e-05 0.0 3.047767857142857e-05 1.5 3.048660714285714e-05 1.5 3.0487165178571428e-05 0.0 3.0494977678571425e-05 0.0 3.0495535714285712e-05 1.5 3.0504464285714283e-05 1.5 3.050502232142857e-05 0.0 3.0512834821428568e-05 0.0 3.0513392857142854e-05 1.5 3.0522321428571426e-05 1.5 3.052287946428571e-05 0.0 3.053069196428571e-05 0.0 3.053125e-05 1.5 3.054017857142857e-05 1.5 3.054073660714286e-05 0.0 3.054854910714285e-05 0.0 3.054910714285714e-05 1.5 3.055803571428571e-05 1.5 3.055859375e-05 0.0 3.0566406249999995e-05 0.0 3.0566964285714285e-05 1.5 3.057589285714285e-05 1.5 3.057645089285714e-05 0.0 3.0584263392857144e-05 0.0 3.058482142857143e-05 1.5 3.0593749999999995e-05 1.5 3.0594308035714285e-05 0.0 3.0602120535714286e-05 0.0 3.060267857142857e-05 1.5 3.0611607142857144e-05 1.5 3.061216517857143e-05 0.0 3.061997767857143e-05 0.0 3.062053571428571e-05 1.5 3.0629464285714286e-05 1.5 3.063002232142857e-05 0.0 3.063783482142857e-05 0.0 3.0638392857142854e-05 1.5 3.064732142857143e-05 1.5 3.064787946428571e-05 0.0 3.065569196428571e-05 0.0 3.0656249999999996e-05 1.5 3.066517857142857e-05 1.5 3.0665736607142854e-05 0.0 3.0673549107142855e-05 0.0 3.067410714285714e-05 1.5 3.068303571428571e-05 1.5 3.068359375e-05 0.0 3.069140625e-05 0.0 3.069196428571428e-05 1.5 3.0700892857142856e-05 1.5 3.070145089285714e-05 0.0 3.070926339285714e-05 0.0 3.070982142857142e-05 1.5 3.071875e-05 1.5 3.071930803571428e-05 0.0 3.072712053571428e-05 0.0 3.072767857142857e-05 1.5 3.073660714285714e-05 1.5 3.0737165178571424e-05 0.0 3.0744977678571425e-05 0.0 3.0745535714285715e-05 1.5 3.075446428571428e-05 1.5 3.0755022321428566e-05 0.0 3.076283482142857e-05 0.0 3.076339285714286e-05 1.5 3.0772879464285715e-05 1.5 3.07734375e-05 0.0 3.0780133928571426e-05 0.0 3.078069196428571e-05 1.5 3.079073660714286e-05 1.5 3.079129464285714e-05 0.0 3.079799107142857e-05 0.0 3.079854910714285e-05 1.5 3.080859375e-05 1.5 3.080915178571428e-05 0.0 3.081584821428571e-05 0.0 3.081640625e-05 1.5 3.082645089285714e-05 1.5 3.0827008928571425e-05 0.0 3.083370535714285e-05 0.0 3.083426339285714e-05 1.5 3.0844308035714284e-05 1.5 3.084486607142857e-05 0.0 3.0851562499999995e-05 0.0 3.0852120535714285e-05 1.5 3.086216517857143e-05 1.5 3.086272321428571e-05 0.0 3.086941964285714e-05 0.0 3.086997767857143e-05 1.5 3.088002232142857e-05 1.5 3.088058035714285e-05 0.0 3.088727678571429e-05 0.0 3.088783482142857e-05 1.5 3.089787946428571e-05 1.5 3.0898437499999995e-05 0.0 3.090513392857143e-05 0.0 3.090569196428571e-05 1.5 3.0915736607142854e-05 1.5 3.0916294642857144e-05 0.0 3.092299107142857e-05 0.0 3.0923549107142855e-05 1.5 3.0933593749999996e-05 1.5 3.0934151785714286e-05 0.0 3.0940848214285714e-05 0.0 3.094140625e-05 1.5 3.095145089285714e-05 1.5 3.095200892857143e-05 0.0 3.0958705357142856e-05 0.0 3.095926339285714e-05 1.5 3.096930803571428e-05 1.5 3.096986607142857e-05 0.0 3.09765625e-05 0.0 3.097712053571428e-05 1.5 3.098716517857143e-05 1.5 3.098772321428571e-05 0.0 3.099441964285714e-05 0.0 3.0994977678571424e-05 1.5 3.100502232142857e-05 1.5 3.1005580357142855e-05 0.0 3.101227678571428e-05 0.0 3.1012834821428566e-05 1.5 3.1022879464285714e-05 1.5 3.10234375e-05 0.0 3.1030133928571425e-05 0.0 3.1030691964285715e-05 1.5 3.104073660714286e-05 1.5 3.104129464285714e-05 0.0 3.104799107142857e-05 0.0 3.104854910714286e-05 1.5 3.105859375e-05 1.5 3.105915178571428e-05 0.0 3.106584821428571e-05 0.0 3.106640625e-05 1.5 3.107645089285714e-05 1.5 3.1077008928571425e-05 0.0 3.108370535714285e-05 0.0 3.108426339285714e-05 1.5 3.1094308035714284e-05 1.5 3.109486607142857e-05 0.0 3.1101562499999995e-05 0.0 3.1102120535714285e-05 1.5 3.1112165178571426e-05 1.5 3.111272321428571e-05 0.0 3.1119419642857144e-05 0.0 3.111997767857143e-05 1.5 3.113002232142857e-05 1.5 3.113058035714285e-05 0.0 3.1137276785714286e-05 0.0 3.113783482142857e-05 1.5 3.114787946428571e-05 1.5 3.11484375e-05 0.0 3.115513392857143e-05 0.0 3.115569196428571e-05 1.5 3.116573660714285e-05 1.5 3.116629464285714e-05 0.0 3.117299107142857e-05 0.0 3.1173549107142854e-05 1.5 3.1183593749999995e-05 1.5 3.1184151785714285e-05 0.0 3.119084821428571e-05 0.0 3.1191406249999996e-05 1.5 3.120145089285714e-05 1.5 3.120200892857143e-05 0.0 3.1208705357142855e-05 0.0 3.120926339285714e-05 1.5 3.121930803571429e-05 1.5 3.121986607142857e-05 0.0 3.12265625e-05 0.0 3.122712053571428e-05 1.5 3.123716517857143e-05 1.5 3.123772321428571e-05 0.0 3.124441964285714e-05 0.0 3.124497767857142e-05 1.5 3.125502232142857e-05 1.5 3.1255580357142855e-05 0.0 3.126227678571428e-05 0.0 3.126283482142857e-05 1.5 3.1272879464285714e-05 1.5 3.12734375e-05 0.0 3.1280133928571425e-05 0.0 3.1280691964285715e-05 1.5 3.1290736607142856e-05 1.5 3.129129464285714e-05 0.0 3.129799107142857e-05 0.0 3.129854910714286e-05 1.5 3.130859375e-05 1.5 3.130915178571428e-05 0.0 3.131584821428571e-05 0.0 3.131640625e-05 1.5 3.132645089285714e-05 1.5 3.1327008928571424e-05 0.0 3.133370535714286e-05 0.0 3.133426339285714e-05 1.5 3.134430803571428e-05 1.5 3.1344866071428566e-05 0.0 3.13515625e-05 0.0 3.1352120535714284e-05 1.5 3.1362165178571425e-05 1.5 3.1362723214285715e-05 0.0 3.136941964285714e-05 0.0 3.1369977678571426e-05 1.5 3.138002232142857e-05 1.5 3.138058035714286e-05 0.0 3.1387276785714285e-05 0.0 3.138783482142857e-05 1.5 3.139787946428571e-05 1.5 3.13984375e-05 0.0 3.140513392857143e-05 0.0 3.140569196428571e-05 1.5 3.141573660714285e-05 1.5 3.141629464285714e-05 0.0 3.142299107142857e-05 0.0 3.142354910714285e-05 1.5 3.1433593749999995e-05 1.5 3.1434151785714285e-05 0.0 3.144084821428571e-05 0.0 3.1441406249999996e-05 1.5 3.1451450892857144e-05 1.5 3.145200892857143e-05 0.0 3.1458705357142855e-05 0.0 3.145926339285714e-05 1.5 3.1469308035714286e-05 1.5 3.146986607142857e-05 0.0 3.14765625e-05 0.0 3.147712053571428e-05 1.5 3.148716517857143e-05 1.5 3.148772321428571e-05 0.0 3.149441964285714e-05 0.0 3.149497767857143e-05 1.5 3.150502232142857e-05 1.5 3.1505580357142854e-05 0.0 3.151227678571428e-05 0.0 3.151283482142857e-05 1.5 3.152287946428571e-05 1.5 3.1523437499999996e-05 0.0 3.1530133928571424e-05 0.0 3.1530691964285714e-05 1.5 3.1540736607142855e-05 1.5 3.154129464285714e-05 0.0 3.1547991071428566e-05 0.0 3.1548549107142856e-05 1.5 3.155859375e-05 1.5 3.155915178571428e-05 0.0 3.1565848214285715e-05 0.0 3.156640625e-05 1.5 3.157645089285714e-05 1.5 3.157700892857142e-05 0.0 3.158370535714286e-05 0.0 3.158426339285714e-05 1.5 3.159430803571428e-05 1.5 3.159486607142857e-05 0.0 3.16015625e-05 0.0 3.160212053571428e-05 1.5 3.1612165178571425e-05 1.5 3.1612723214285715e-05 0.0 3.161941964285714e-05 0.0 3.1619977678571426e-05 1.5 3.163002232142857e-05 1.5 3.163058035714286e-05 0.0 3.1637276785714285e-05 0.0 3.163783482142857e-05 1.5 3.164787946428571e-05 1.5 3.16484375e-05 0.0 3.165513392857143e-05 0.0 3.165569196428571e-05 1.5 3.166573660714285e-05 1.5 3.166629464285714e-05 0.0 3.167299107142857e-05 0.0 3.167354910714285e-05 1.5 3.168359375e-05 1.5 3.1684151785714284e-05 0.0 3.169084821428571e-05 0.0 3.1691406249999995e-05 1.5 3.170145089285714e-05 1.5 3.1702008928571426e-05 0.0 3.1708705357142854e-05 0.0 3.1709263392857144e-05 1.5 3.1719308035714285e-05 1.5 3.171986607142857e-05 0.0 3.1726562499999996e-05 0.0 3.1727120535714286e-05 1.5 3.173716517857143e-05 1.5 3.173772321428571e-05 0.0 3.174441964285714e-05 0.0 3.174497767857143e-05 1.5 3.175502232142857e-05 1.5 3.175558035714285e-05 0.0 3.176227678571428e-05 0.0 3.176283482142857e-05 1.5 3.177287946428571e-05 1.5 3.1773437499999996e-05 0.0 3.178013392857142e-05 0.0 3.178069196428571e-05 1.5 3.1790736607142855e-05 1.5 3.179129464285714e-05 0.0 3.179799107142857e-05 0.0 3.1798549107142856e-05 1.5 3.180859375e-05 1.5 3.180915178571428e-05 0.0 3.1815848214285715e-05 0.0 3.181640625e-05 1.5 3.182645089285714e-05 1.5 3.182700892857143e-05 0.0 3.183370535714286e-05 0.0 3.183426339285714e-05 1.5 3.184430803571428e-05 1.5 3.184486607142857e-05 0.0 3.18515625e-05 0.0 3.185212053571428e-05 1.5 3.1862165178571424e-05 1.5 3.1862723214285714e-05 0.0 3.186941964285714e-05 0.0 3.1869977678571425e-05 1.5 3.1880022321428566e-05 1.5 3.1880580357142856e-05 0.0 3.1887276785714284e-05 0.0 3.188783482142857e-05 1.5 3.1897879464285715e-05 1.5 3.18984375e-05 0.0 3.1905133928571426e-05 0.0 3.190569196428571e-05 1.5 3.191573660714286e-05 1.5 3.191629464285714e-05 0.0 3.192299107142857e-05 0.0 3.192354910714285e-05 1.5 3.193359375e-05 1.5 3.193415178571428e-05 0.0 3.194084821428571e-05 0.0 3.194140625e-05 1.5 3.195145089285714e-05 1.5 3.1952008928571426e-05 0.0 3.195870535714285e-05 0.0 3.195926339285714e-05 1.5 3.1969308035714285e-05 1.5 3.196986607142857e-05 0.0 3.1976562499999995e-05 0.0 3.1977120535714286e-05 1.5 3.198716517857143e-05 1.5 3.198772321428571e-05 0.0 3.199441964285714e-05 0.0 3.199497767857143e-05 1.5 3.200502232142857e-05 1.5 3.200558035714285e-05 0.0 3.201227678571428e-05 0.0 3.201283482142857e-05 1.5 3.202287946428571e-05 1.5 3.2023437499999995e-05 0.0 3.203013392857143e-05 0.0 3.203069196428571e-05 1.5 3.2040736607142854e-05 1.5 3.204129464285714e-05 0.0 3.204799107142857e-05 0.0 3.2048549107142855e-05 1.5 3.2058593749999996e-05 1.5 3.2059151785714286e-05 0.0 3.2065848214285714e-05 0.0 3.206640625e-05 1.5 3.207645089285714e-05 1.5 3.207700892857143e-05 0.0 3.2083705357142856e-05 0.0 3.208426339285714e-05 1.5 3.209430803571428e-05 1.5 3.209486607142857e-05 0.0 3.21015625e-05 0.0 3.210212053571428e-05 1.5 )"}
C {devices/code_shown.sym} 2820 -1610 0 0 {name=MODEL only_toplevel=true
format="tcleval( @value )"
value="
.lib cornerMOSlv.lib mos_tt
.lib cornerMOShv.lib mos_tt
.lib cornerHBT.lib hbt_typ
.lib cornerRES.lib res_typ
.lib cornerCAP.lib cap_typ
.lib cornerDIO.lib dio_tt
"}
C {devices/gnd.sym} 480 -1920 0 0 {name=l58 lab=GND}
C {devices/gnd.sym} 590 -1920 0 0 {name=l59 lab=GND}
C {devices/lab_pin.sym} 740 -2020 2 0 {name=l60 sig_type=std_logic lab=Vcm}
C {devices/gnd.sym} 1400 -1920 0 0 {name=l38 lab=GND}
C {devices/gnd.sym} 1510 -1920 0 0 {name=l39 lab=GND}
C {devices/lab_pin.sym} 1660 -2020 2 0 {name=l41 sig_type=std_logic lab=Vcm}
C {devices/lab_wire.sym} 1540 -720 0 1 {name=l37 sig_type=std_logic lab=vout_RF_filt}
C {devices/lab_wire.sym} 1040 -760 0 1 {name=l21 sig_type=std_logic lab=vout_RF}
C {devices/gnd.sym} 1220 -540 0 0 {name=l36 lab=GND}
C {res.sym} 1480 -630 0 0 {name=R1
value=\{Rload\}
footprint=1206
device=resistor
m=1}
C {devices/gnd.sym} 1480 -540 0 0 {name=l42 lab=GND}
C {devices/capa.sym} 1040 -630 0 0 {name=C1
m=1
value=\{Cload\}
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 1040 -540 0 0 {name=l43 lab=GND}
C {coupled_resonator_lc_bpf_1k_1k.sym} 1220 -720 0 0 {name=x3}
C {vsource.sym} 1390 -720 3 1 {name=Vmeas value=0 savecurrent=false}
C {iqmod_top.sym} 3860 -1580 0 0 {name=x1
spice_ignore=true}
C {iqmod_top_pex.sym} 3860 -520 0 0 {name=x2
spice_ignore=true}
C {vdd.sym} 300 -1260 0 0 {name=l2 lab=VDD}
C {title-2.sym} 0 0 0 0 {name=l6 author="Simon Dorrer" rev=1.0 lock=true}
C {lab_pin.sym} 180 -1080 2 1 {name=p13 sig_type=std_logic lab=vinp_I_pwm}
C {lab_pin.sym} 180 -940 2 1 {name=p14 sig_type=std_logic lab=vinn_I_pwm}
C {lab_pin.sym} 180 -540 2 1 {name=p15 sig_type=std_logic lab=vinp_Q_pwm}
C {lab_pin.sym} 180 -400 2 1 {name=p16 sig_type=std_logic lab=vinn_Q_pwm}
C {lab_pin.sym} 180 -1120 0 0 {name=p17 sig_type=std_logic lab=vinp_I_cosine}
C {lab_pin.sym} 180 -980 0 0 {name=p18 sig_type=std_logic lab=vinn_I_cosine}
C {lab_pin.sym} 180 -500 0 0 {name=p19 sig_type=std_logic lab=vinn_Q_sine}
C {lab_pin.sym} 180 -360 0 0 {name=p20 sig_type=std_logic lab=vinp_Q_sine}
C {devices/gnd.sym} 180 -320 1 0 {name=l18 lab=GND}
C {devices/gnd.sym} 180 -1160 1 0 {name=l19 lab=GND}
C {iqmod_top_pex.sym} 560 -740 0 0 {name=x5
}
C {single2dm.sym} 620 -2020 0 0 {name=x6 gain=1}
C {single2dm.sym} 1540 -2020 0 0 {name=x4 gain=1}
C {devices/code_shown.sym} 2540 -1730 0 0 {name=SAVE only_toplevel=true
format="tcleval( @value )"
value="
.include [file rootname [file tail [xschem get schname]]].save
"}
