** sch_path: ihp130/macros/iqmod/testbenches/xschem/iqmod_mfb_lpf_ota_core_tb_Vout.sch
**.subckt iqmod_mfb_lpf_ota_core_tb_Vout
VDD VDD GND {VDD}
Vgsp vin GND 0
C2 voutn GND {Cload} m=1
C3 voutp GND {Cload} m=1
Vcm Vcm GND {Vcm}
x4 voutp voutn vinn vinp VDD GND VDD iqmod_mfb_lpf_ota_core_hybrid_bm
x6 vinp vin Vcm GND vinn single2dm
**** begin user architecture code


.include ../../../netlist/pex/iqmod_mfb_lpf_ota_core_hybrid_bm_pex.spice
.param VDD=1.5
.csparam VDD=VDD
.param Vcm=VDD/2
.temp 27
.param Cload=10p
.options savecurrents klu method=gear reltol=1e-3 abstol=1e-12 gmin=1e-12
.control

save all

* Operating Point Analysis
op
remzerovec
write @schname\.raw
set appendwrite

* DC Sweep
dc Vgsp -$&VDD $&VDD 1m
remzerovec
write @schname\.raw
set appendwrite

* Plotting
plot vinp voutp voutn

* Measurement
meas dc Vgsp_at_Vcm when voutp=voutn
print Vgsp_at_Vcm

meas dc vout_pp_max MAX v(voutp)
meas dc vout_pp_min MIN v(voutp)
let vout_pp = vout_pp_max - vout_pp_min
print vout_pp

* Write Data
unset appendwrite
set wr_vecnames
set wr_singlescale
wrdata ../plot_simulations/data/iqmod_mfb_lpf_ota_core_tb_Vout.txt v(vinp) v(voutp) v(voutn)

*quit
.endc



.lib cornerMOSlv.lib mos_tt
.lib cornerMOShv.lib mos_tt
.lib cornerHBT.lib hbt_typ
.lib cornerRES.lib res_typ
.lib cornerCAP.lib cap_typ
.lib cornerDIO.lib dio_tt


.include [file rootname [file tail [xschem get schname]]].save

**** end user architecture code
**.ends
.GLOBAL GND
.GLOBAL VDD
.end
