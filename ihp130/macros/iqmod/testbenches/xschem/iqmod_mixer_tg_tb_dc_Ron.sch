** sch_path: ihp130/macros/iqmod/testbenches/xschem/iqmod_mixer_tg_tb_dc_Ron.sch
**.subckt iqmod_mixer_tg_tb_dc_Ron
VDD VDD GND {VDD}
vin vin_tg GND 0
vds_x3 vin_tg vout_tg_w_dummy_on 1mV
x3 VDD GND GND VDD vin_tg vout_tg_w_dummy_on iqmod_mixer_tg_pex
**** begin user architecture code


.include ../../../netlist/pex/iqmod_mixer_tg_pex.spice
.param VDD=1.5
.csparam VDD=VDD
.param Vcm=VDD/2
.temp 27
.param Cload=10p
.options savecurrents method=gear reltol=1e-3 abstol=1e-15 gmin=1e-15
.control

save all

* Operating Point Analysis
op
remzerovec
write @schname\.raw
set appendwrite

* DC Sweep Analysis
dc vin 0 $&VDD 0.01
write @schname\.raw

* On-Resistance
* LV with Dummy
let r_w_dummy_on = (v(vout_tg_w_dummy_on)-v(vin_tg))/I(vds_x3)
plot r_w_dummy_on xlabel 'Vin in V' ylabel 'Ron with Dummy in Ohm'

* Writing Data
unset appendwrite
set wr_singlescale
set wr_vecnames
wrdata ../plot_simulations/data/iqmod_mixer_tg_tb_dc_Ron.txt v(r_w_dummy_on)

*quit
.endc


.lib cornerMOSlv.lib mos_tt
.lib cornerMOShv.lib mos_tt
.lib cornerHBT.lib hbt_typ
.lib cornerRES.lib res_typ
.lib cornerCAP.lib cap_typ
.lib cornerDIO.lib dio_tt


.include [file rootname [file tail [xschem get schname]]].save

**** end user architecture code
**.ends

* expanding   symbol:  iqmod_mixer_tg.sym # of pins=8
** sym_path: ihp130/macros/iqmod/xschem/iqmod_mixer_tg.sym
** sch_path: ihp130/macros/iqmod/xschem/iqmod_mixer_tg.sch
.subckt iqmod_mixer_tg nwell psub VDD di_tg_ctrl VSS v_b v_a di_tg_ctrl_n
*.iopin v_a
*.iopin v_b
*.ipin di_tg_ctrl
*.ipin di_tg_ctrl_n
*.iopin VDD
*.iopin VSS
*.iopin nwell
*.iopin psub
XM1 v_a di_tg_ctrl v_b psub sg13_lv_nmos w=108.0u l=0.13u ng=36 m=1 mm_ok=1
XM2 v_a di_tg_ctrl_n v_b nwell sg13_lv_pmos w=324.0u l=0.13u ng=36 m=1 mm_ok=1
XMdummy2 v_b di_tg_ctrl v_b nwell sg13_lv_pmos w=162.0u l=0.13u ng=18 m=1 mm_ok=1
XMdummy1 v_b di_tg_ctrl_n v_b psub sg13_lv_nmos w=54.0u l=0.13u ng=18 m=1 mm_ok=1
XR1 VDD nwell ntap1 R=2.829 w=29.86e-6 l=11.02e-6 rw=0.3e-6
XR2 VSS psub ptap1 R=3.29 w=29.86e-6 l=5.38e-6 rw=0.3e-6
.ends

.GLOBAL GND
.GLOBAL VDD
.end
