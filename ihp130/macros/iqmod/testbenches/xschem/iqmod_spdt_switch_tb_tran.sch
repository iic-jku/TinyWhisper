** sch_path: ihp130/macros/iqmod/testbenches/xschem/iqmod_spdt_switch_tb_tran.sch
**.subckt iqmod_spdt_switch_tb_tran
C1 vout_a_spdt_ca GND 5p m=1
VDD VDD GND {VDD}
C2 vout_b_spdt_ca GND 5p m=1
x1 VDD VDD GND vin_spdt vout_b_spdt_ca vout_a_spdt_ca iqmod_spdt_switch_pex
x2 VDD GND GND vin_spdt vout_b_spdt_cb vout_a_spdt_cb iqmod_spdt_switch_pex
vpulse vin_spdt GND pulse(0 {VDD} 0 10p 10p {0.50/fsig} {1/fsig})
R1 vout_a_spdt_ca GND 100k m=1
R2 vout_b_spdt_ca GND 100k m=1
C3 vout_a_spdt_cb GND 5p m=1
C4 vout_b_spdt_cb GND 5p m=1
R3 vout_a_spdt_cb GND 100k m=1
R4 vout_b_spdt_cb GND 100k m=1
**** begin user architecture code


.include ../../../netlist/pex/iqmod_spdt_switch_pex.spice
.param VDD=1.5
.csparam VDD=VDD
.param Vcm=VDD/2
.temp 27
.param fsig=50e6
.options savecurrents klu method=gear reltol=1e-4 abstol=1e-15 gmin=1e-15
.control
save all

* Operating Point Analysis
op
remzerovec
write @schname\.raw
set appendwrite

* Transient Analysis
tran 1n 100n
write @schname\.raw

plot vout_b_spdt_ca vout_a_spdt_ca vin_spdt
plot vout_b_spdt_cb vout_a_spdt_cb vin_spdt

*quit
.endc


.lib cornerMOSlv.lib mos_tt
.lib cornerMOShv.lib mos_tt
.lib cornerHBT.lib hbt_typ
.lib cornerRES.lib res_typ
.lib cornerCAP.lib cap_typ
.lib cornerDIO.lib dio_tt


.include [file rootname [file tail [xschem get schname]]].save

**** end user architecture code
**.ends
.GLOBAL VDD
.GLOBAL GND
.end
