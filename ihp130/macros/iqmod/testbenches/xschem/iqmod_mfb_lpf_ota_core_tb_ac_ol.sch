** sch_path: ihp130/macros/iqmod/testbenches/xschem/iqmod_mfb_lpf_ota_core_tb_ac_ol.sch
**.subckt iqmod_mfb_lpf_ota_core_tb_ac_ol
VDD VDD GND {VDD}
C1 voutp GND {Cload} m=1
C2 voutn GND {Cload} m=1
E1 vout GND voutp voutn 1
vin vin GND dc 0 ac 1
Vcm Vcm GND {Vcm}
x1 voutp voutn vinn vinp VDD GND VDD iqmod_mfb_lpf_ota_core_hybrid_bm_pex
x6 vinp vin Vcm GND vinn single2dm
**** begin user architecture code


.include ../../../netlist/pex/iqmod_mfb_lpf_ota_core_hybrid_bm_pex.spice
.param VDD=1.5
.param Vcm=VDD/2
.temp 27
.param Cload=10p
.options savecurrents klu method=gear reltol=1e-4 abstol=1e-15 gmin=1e-15
.control

* optran 0 0 0 1u 1m 0
save all

set wr_vecnames
set wr_singlescale

* User Constants
let f_min = 0.1
let f_max = 10G
let fdc = 1

* Operating Point Analysis
op
remzerovec
write @schname\.raw
set appendwrite

* AC Analysis
ac dec 101 $&const.f_min $&const.f_max
remzerovec
write @schname\.raw

* Plotting
let Aol = v(vout)/v(vin)
let Aol_dB = vdb(Aol)
let Aol_arg = 180/PI*cphase(Aol)

plot Aol_dB ylabel 'Magnitude'
plot Aol_arg ylabel 'Phase'
plot Aol_dB Aol_arg ylabel 'Magnitude, Phase'

* Measurements
* DC open-loop gain
meas ac Adc_ol_dB find Aol_dB when frequency = fdc
print Adc_ol_dB

* 3dB cut-off frequency
let Aol_fc = Adc_ol_dB - 3
meas ac fc find frequency when Aol_dB = Aol_fc
print fc

* Unity Gain Bandwidth (Aol=1 or Aol_dB = 0dB)
meas ac UGB when Aol_dB=0  fall=1
print UGB

* Phase Margin at Aol=1 or Aol_dB = 0dB
meas ac arg_0dB find Aol_arg when Aol_dB=0
let PM = 180-abs(arg_0dB)
print PM

* Write Data
unset appendwrite
set wr_vecnames
set wr_singlescale
wrdata ../plot_simulations/data/iqmod_mfb_lpf_ota_core_tb_ac_ol.txt v(Aol_dB) v(Aol_arg)

*quit
.endc



.lib cornerMOSlv.lib mos_tt
.lib cornerMOShv.lib mos_tt
.lib cornerHBT.lib hbt_typ
.lib cornerRES.lib res_typ
.lib cornerCAP.lib cap_typ
.lib cornerDIO.lib dio_tt


.include [file rootname [file tail [xschem get schname]]].save

**** end user architecture code
**.ends
.GLOBAL GND
.GLOBAL VDD
.end
