** sch_path: ihp130/macros/iqmod/testbenches/xschem/iqmod_mfb_lpf_ota_core_tb_PSRR.sch
**.subckt iqmod_mfb_lpf_ota_core_tb_PSRR
C1 voutp GND {Cload} m=1
C2 voutn GND {Cload} m=1
Vcm net1 GND {Vcm}
E1 vout GND voutp voutn 1
VDD net2 GND {VDD}
VDD_NOISE VDD net2 dc 0 ac 1
x4 voutp voutn net1 net1 VDD GND VDD iqmod_mfb_lpf_ota_core_hybrid_bm
**** begin user architecture code


.include ../../../netlist/pex/iqmod_mfb_lpf_ota_core_hybrid_bm_pex.spice
.param VDD=1.5
.param Vcm=VDD/2
.temp 27
.param Cload=10p
.options savecurrents klu method=gear reltol=1e-4 abstol=1e-15 gmin=1e-15
.control

* save v(VDD) v(vout) v(voutp) v(voutn)
save all

set wr_vecnames
set wr_singlescale

* User Constants
let f_min = 0.1
let f_max = 1G
let fdc = 1

* Operating Point Analysis
op
remzerovec
write @schname\.raw
set appendwrite

* AC Analysis
ac dec 101 $&const.f_min $&const.f_max
remzerovec
write @schname\.raw

* Plotting
let PSRR = v(VDD)/v(vout)
let PSRRp = v(VDD)/v(voutp)
let PSRRn = v(VDD)/v(voutn)

let PSRR_dB = vdb(PSRR)
let PSRRp_dB = vdb(PSRRp)
let PSRRn_dB = vdb(PSRRn)

plot PSRR_dB PSRRp_dB PSRRn_dB ylabel 'PSRR, PSRR+, PSRR-'

* Measurements
meas ac PSRRdc_dB find PSRR_dB when frequency = fdc
print PSRRdc_dB

meas ac PSRRpdc_dB find PSRRp_dB when frequency = fdc
print PSRRpdc_dB

meas ac PSRRndc_dB find PSRRn_dB when frequency = fdc
print PSRRndc_dB

* Write Data
unset appendwrite
set wr_vecnames
set wr_singlescale
wrdata ../plot_simulations/data/iqmod_mfb_lpf_ota_core_tb_PSRR.txt v(PSRR_dB)

*quit
.endc



.lib cornerMOSlv.lib mos_tt_mismatch
.lib cornerMOShv.lib mos_tt_mismatch
.lib cornerHBT.lib hbt_typ
.lib cornerRES.lib res_typ
.lib cornerCAP.lib cap_typ
.lib cornerDIO.lib dio_tt


.include [file rootname [file tail [xschem get schname]]].save

**** end user architecture code
**.ends
.GLOBAL GND
.GLOBAL VDD
.end
