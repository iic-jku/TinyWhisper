** sch_path: ihp130/macros/iqmod/testbenches/xschem/iqmod_spdt_switch_tb_dc_Ileak.sch
**.subckt iqmod_spdt_switch_tb_dc_Ileak
vout_x1 vout_b_spdt_ca GND {Vcm}
vout_x2 vout_a_spdt_cb GND {Vcm}
vin vin_spdt GND {Vcm}
VDD VDD GND {VDD}
x1 VDD VDD GND vin_spdt vout_b_spdt_ca net1 iqmod_spdt_switch_pex
x2 VDD GND GND vin_spdt net2 vout_a_spdt_cb iqmod_spdt_switch_pex
**** begin user architecture code


.include ../../../netlist/pex/iqmod_spdt_switch_pex.spice
.param VDD=1.5
.csparam VDD=VDD
.param Vcm=VDD/2
.temp 27
.options savecurrents klu method=gear reltol=1e-4 abstol=1e-15 gmin=1e-15
.control
save all

* Operating Point Analysis
op
remzerovec
write @schname\.raw
set appendwrite

* DC Sweep Analysis x1
dc vin 0 $&VDD 10m vout_x1 0 $&VDD 0.25
write @schname\.raw
set appendwrite

*Off-Leakage Current v_c to v_b
let Ileak_cb = I(vout_x1)
plot Ileak_cb

* DC Sweep Analysis x2
dc vin 0 $&VDD 10m vout_x2 0 $&VDD 0.25
write @schname\.raw

*Off-Leakage Current v_c to v_a
let Ileak_ca = I(vout_x2)
plot Ileak_ca

*quit
.endc


.lib cornerMOSlv.lib mos_tt
.lib cornerMOShv.lib mos_tt
.lib cornerHBT.lib hbt_typ
.lib cornerRES.lib res_typ
.lib cornerCAP.lib cap_typ
.lib cornerDIO.lib dio_tt


.include [file rootname [file tail [xschem get schname]]].save

**** end user architecture code
**.ends
.GLOBAL VDD
.GLOBAL GND
.end
