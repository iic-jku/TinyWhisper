** sch_path: ihp130/macros/iqmod/testbenches/xschem/iqmod_mfb_lpf_tb_loopgain.sch
**.subckt iqmod_mfb_lpf_tb_loopgain
VDD VDD GND {VDD}
Ven filter_ota_en GND {VDD}
C4 voutp2 GND {Cload} m=1
C5 voutn2 GND {Cload} m=1
E3 vout2 GND voutp2 voutn2 1
R4a voutn2 net3 {R4} m=1
R4b voutp2 net4 {R4} m=1
C3a voutn2 vrp2 {C3} m=1
C3b voutp2 vrn2 {C3} m=1
C2 net4 net3 {C2} m=1
E7 vout3 GND voutp3 voutn3 1
E8 vf2 GND vfp2 vfn2 0.5
E9 vr2 GND vrp2 vrn2 0.5
Vtestp2 vfp2 vrp2 dc 0 ac 1
Vtestn2 vfn2 vrn2 dc 0 ac -1
Virp3 net7 net2 0
.save i(virp3)
Vifp3 net2 net13 0
.save i(vifp3)
Itestn3 GND net1 dc 0 ac -1
Virn3 net9 net1 0
.save i(virn3)
Vifn3 net1 net14 0
.save i(vifn3)
Itestp3 GND net2 dc 0 ac 1
Vcm Vcm GND {Vcm}
R3a vrp2 net3 {R3} m=1
R3b vrn2 net4 {R3} m=1
R2a net3 net5 {R2} m=1
R1a net5 Vcm {R1} m=1
R2b net4 net6 {R2} m=1
R1b net6 Vcm {R1} m=1
C1 net6 net5 {C1} m=1
C3 voutp3 GND {Cload} m=1
C6 voutn3 GND {Cload} m=1
R1 voutn3 net8 {R4} m=1
R2 voutp3 net10 {R4} m=1
C7 voutn3 net7 {C3} m=1
C8 voutp3 net9 {C3} m=1
C9 net10 net8 {C2} m=1
R3 net7 net8 {R3} m=1
R4 net9 net10 {R3} m=1
R5 net8 net11 {R2} m=1
R6 net11 Vcm {R1} m=1
R7 net10 net12 {R2} m=1
R8 net12 Vcm {R1} m=1
C10 net12 net11 {C1} m=1
x1 voutp2 voutn2 vfn2 vfp2 VDD GND VDD iqmod_mfb_lpf_ota_core_hybrid_bm_pex
x4 voutp3 voutn3 net14 net13 VDD GND VDD iqmod_mfb_lpf_ota_core_hybrid_bm_pex
**** begin user architecture code


.include ../../../netlist/pex/iqmod_mfb_lpf_ota_core_hybrid_bm_pex.spice
.param VDD=1.5
.param Vcm=VDD/2
.temp 27
.param Cload=10p
.param R1=238e3
.param R2=285e3
.param R3=473e3
.param R4=537e3
.param C1=0.97e-12
.param C2=0.63e-12
.param C3=100e-15
.options savecurrents klu method=gear reltol=1e-4 abstol=1e-15 gmin=1e-15
.control

* optran 0 0 0 1u 1m 0

save all

* User Constants
let f_min = 1
let f_max = 1G
let fdc = 10
* ===================================================

* Operating Point Analysis
op
remzerovec
write @schname\.raw
set appendwrite
* ===================================================

* AC Analysis
ac dec 101 $&const.f_min $&const.f_max
remzerovec
write @schname\.raw
set appendwrite
* ===================================================

* Middlebrook's method
let Tv=-v(vr2)/v(vf2)
let Ti=-(i(Virp3) - i(Virn3))/(i(Vifp3) - i(Vifn3))
let Tmb =(Tv * Ti - 1)/(Tv + Ti + 2)

let Tmb_dB = vdb(Tmb)
let Tmb_arg = 180/PI*cphase(Tmb)

* DC loop gain
meas ac Tmbdc_dB find Tmb_dB when frequency = fdc
print Tmbdc_dB

* Phase margin
meas ac fug find frequency when Tmb_dB=0
meas ac pm find Tmb_arg when frequency=fug
let pm = 180-abs(pm)
* let pm = abs(pm)
print pm

* Plotting
plot Tmb_dB Tmb_arg title 'Bode Plot (Middlebrook)' ylabel 'Magnitude (dB), Phase (Deg)'

let Tmb_re = real(Tmb)
let Tmb_im = imag(Tmb)
plot Tmb_im vs Tmb_re retraceplot title 'Nyquist Plot (Middlebrook)' ylabel 'Imaginary Part' xlabel 'Real
+ Part'
* ===================================================

* Write Data
unset appendwrite
set wr_vecnames
set wr_singlescale
wrdata ../plot_simulations/data/iqmod_mfb_lpf_tb_loopgain.txt v(Tmb_dB) v(Tmb_arg)
* ===================================================

*quit
.endc



.lib cornerMOSlv.lib mos_tt
.lib cornerMOShv.lib mos_tt
.lib cornerHBT.lib hbt_typ
.lib cornerRES.lib res_typ
.lib cornerCAP.lib cap_typ
.lib cornerDIO.lib dio_tt


.include [file rootname [file tail [xschem get schname]]].save

**** end user architecture code
**.ends
.GLOBAL GND
.GLOBAL VDD
.end
