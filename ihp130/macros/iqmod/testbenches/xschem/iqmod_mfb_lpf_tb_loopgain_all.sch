** sch_path: ihp130/macros/iqmod/testbenches/xschem/iqmod_mfb_lpf_tb_loopgain_all.sch
**.subckt iqmod_mfb_lpf_tb_loopgain_all
VDD VDD GND {VDD}
Vcm1 Vcm1 GND {Vcm}
E4 Vcm1 vinn1 net1 GND 0.5
E5 vinp1 Vcm1 net1 GND 0.5
E6 net1 GND vin1 GND 1
E1 vout1 GND voutp1 voutn1 1
vin1 vin1 GND dc 0 ac 1
C8 vinp1 net2 1G m=1
L28 net2 vrp1 1G m=1
L16 net3 vrn1 1G m=1
C3 net3 vinn1 1G m=1
E2 vr1 GND vrp1 vrn1 1
E10 vout4 GND voutp4 voutn4 1
E11 vout5 GND voutp5 voutn5 1
Vtestp4 vmeasp4 net4 dc 0 ac 1
Vimeasp4 net26 net4 0
.save i(vimeasp4)
Itestp4 GND vmeasp4 dc 0 ac 0
Vimeasn4 net28 net5 0
.save i(vimeasn4)
Vtestn4 vmeasn4 net5 dc 0 ac -1
Itestn4 GND vmeasn4 dc 0 ac 0
Vimeasn5 net34 net6 0
.save i(vimeasn5)
Vtestn5 vmeasn5 net6 dc 0 ac 0
Itestn5 GND vmeasn5 dc 0 ac -1
Vtestp5 vmeasp5 net7 dc 0 ac 0
Vimeasp5 net32 net7 0
.save i(vimeasp5)
Itestp5 GND vmeasp5 dc 0 ac 1
E12 vmeas4 GND vmeasp4 vmeasn4 0.5
E13 vmeas5 GND vmeasp5 vmeasn5 0.5
Vcm2 Vcm2 GND {Vcm}
Vcm3 Vcm3 GND {Vcm}
C4 voutp2 GND {Cload} m=1
C5 voutn2 GND {Cload} m=1
E3 vout2 GND voutp2 voutn2 1
R4a voutn2 net8 {R4} m=1
R4b voutp2 net9 {R4} m=1
C3a voutn2 vrp2 {C3} m=1
C3b voutp2 vrn2 {C3} m=1
C6 net9 net8 {C2} m=1
E8 vf2 GND vfp2 vfn2 0.5
E9 vr2 GND vrp2 vrn2 0.5
Vtestp2 vfp2 vrp2 dc 0 ac 1
Vtestn2 vfn2 vrn2 dc 0 ac -1
R3a vrp2 net8 {R3} m=1
R3b vrn2 net9 {R3} m=1
R1 net8 net10 {R2} m=1
R1a net10 Vcm2 {R1} m=1
R2 net9 net11 {R2} m=1
R1b net11 Vcm2 {R1} m=1
C7 net11 net10 {C1} m=1
E7 vout3 GND voutp3 voutn3 1
Virp3 net14 net13 0
.save i(virp3)
Vifp3 net13 net20 0
.save i(vifp3)
Itestn3 GND net12 dc 0 ac -1
Virn3 net16 net12 0
.save i(virn3)
Vifn3 net12 net21 0
.save i(vifn3)
Itestp3 GND net13 dc 0 ac 1
C9 voutp3 GND {Cload} m=1
C10 voutn3 GND {Cload} m=1
R3 voutn3 net15 {R4} m=1
R4 voutp3 net17 {R4} m=1
C13 voutn3 net14 {C3} m=1
C14 voutp3 net16 {C3} m=1
C15 net17 net15 {C2} m=1
R9 net14 net15 {R3} m=1
R10 net16 net17 {R3} m=1
R11 net15 net18 {R2} m=1
R12 net18 Vcm2 {R1} m=1
R13 net17 net19 {R2} m=1
R14 net19 Vcm2 {R1} m=1
C16 net19 net18 {C1} m=1
C1 voutp1 GND {Cload} m=1
C2 voutn1 GND {Cload} m=1
R15 voutn1 net22 {R4} m=1
R16 voutp1 net23 {R4} m=1
C17 voutn1 vrp1 {C3} m=1
C18 voutp1 vrn1 {C3} m=1
C29 net23 net22 {C2} m=1
R17 vrp1 net22 {R3} m=1
R18 vrn1 net23 {R3} m=1
R19 net22 net24 {R2} m=1
R20 net24 Vcm1 {R1} m=1
R21 net23 net25 {R2} m=1
R22 net25 Vcm1 {R1} m=1
C30 net25 net24 {C1} m=1
C11 voutp4 GND {Cload} m=1
C12 voutn4 GND {Cload} m=1
R5 voutn4 net27 {R4} m=1
R6 voutp4 net29 {R4} m=1
C19 voutn4 net26 {C3} m=1
C20 voutp4 net28 {C3} m=1
C21 net29 net27 {C2} m=1
R23 net26 net27 {R3} m=1
R24 net28 net29 {R3} m=1
R25 net27 net30 {R2} m=1
R26 net30 Vcm3 {R1} m=1
R27 net29 net31 {R2} m=1
R28 net31 Vcm3 {R1} m=1
C22 net31 net30 {C1} m=1
C23 voutp5 GND {Cload} m=1
C24 voutn5 GND {Cload} m=1
R7 voutn5 net33 {R4} m=1
R8 voutp5 net35 {R4} m=1
C25 voutn5 net32 {C3} m=1
C26 voutp5 net34 {C3} m=1
C27 net35 net33 {C2} m=1
R29 net32 net33 {R3} m=1
R30 net34 net35 {R3} m=1
R31 net33 net36 {R2} m=1
R32 net36 Vcm3 {R1} m=1
R33 net35 net37 {R2} m=1
R34 net37 Vcm3 {R1} m=1
C28 net37 net36 {C1} m=1
x5 voutp1 voutn1 net3 net2 VDD GND VDD iqmod_mfb_lpf_ota_core_hybrid_bm
x4 voutp2 voutn2 vfn2 vfp2 VDD GND VDD iqmod_mfb_lpf_ota_core_hybrid_bm
x6 voutp3 voutn3 net21 net20 VDD GND VDD iqmod_mfb_lpf_ota_core_hybrid_bm
x7 voutp4 voutn4 vmeasn4 vmeasp4 VDD GND VDD iqmod_mfb_lpf_ota_core_hybrid_bm
x8 voutp5 voutn5 vmeasn5 vmeasp5 VDD GND VDD iqmod_mfb_lpf_ota_core_hybrid_bm
**** begin user architecture code


.include ../../../netlist/pex/iqmod_mfb_lpf_ota_core_hybrid_bm_pex.spice
.param VDD=1.5
.param Vcm=VDD/2
.temp 27
.param Cload=10p
.param R1=238e3
.param R2=285e3
.param R3=473e3
.param R4=537e3
.param C1=0.97e-12
.param C2=0.63e-12
.param C3=100e-15
.options savecurrents klu method=gear reltol=1e-4 abstol=1e-15 gmin=1e-15
.control

* optran 0 0 0 1u 1m 0

save all

* User Constants
let f_min = 1
let f_max = 1G
let fdc = 10
* ===================================================

* Operating Point Analysis
op
remzerovec
write @schname\.raw
set appendwrite
* ===================================================

* AC Analysis
ac dec 101 $&const.f_min $&const.f_max
remzerovec
write @schname\.raw
set appendwrite
* ===================================================

* Rosenstark's method
let L = -v(vr1)/v(vin1)
let L_dB = vdb(L)
let L_arg = 180/PI*cphase(L)

* DC loop gain
meas ac Ldc_dB find L_dB when frequency = fdc
print Ldc_dB

* Phase margin
meas ac fug find frequency when L_dB=0
meas ac pm find L_arg when frequency=fug
let pm = 180-abs(pm)
* let pm = abs(pm)
print pm

* Plotting
plot L_dB L_arg title 'Bode Plot (Rosenstark)' ylabel 'Magnitude (dB), Phase (Deg)'

let L_re = real(L)
let L_im = imag(L)
plot L_im vs L_re retraceplot title 'Nyquist Plot (Rosenstark)' ylabel 'Imaginary Part' xlabel 'Real
+ Part'
* ===================================================

* Middlebrook's method
let Tv=-v(vr2)/v(vf2)
let Ti=-(i(Virp3) - i(Virn3))/(i(Vifp3) - i(Vifn3))
let Tmb =(Tv * Ti - 1)/(Tv + Ti + 2)

let Tmb_dB = vdb(Tmb)
let Tmb_arg = 180/PI*cphase(Tmb)

* DC loop gain
meas ac Tmbdc_dB find Tmb_dB when frequency = fdc
print Tmbdc_dB

* Phase margin
meas ac fug find frequency when Tmb_dB=0
meas ac pm find Tmb_arg when frequency=fug
let pm = 180-abs(pm)
* let pm = abs(pm)
print pm

* Plotting
plot Tmb_dB Tmb_arg title 'Bode Plot (Middlebrook)' ylabel 'Magnitude (dB), Phase (Deg)'

let Tmb_re = real(Tmb)
let Tmb_im = imag(Tmb)
plot Tmb_im vs Tmb_re retraceplot title 'Nyquist Plot (Middlebrook)' ylabel 'Imaginary Part' xlabel 'Real Part'
* ===================================================

* Tian's Method
* vtest=0, itest=1:
let A=i(Vimeasp5)
let C=v(vmeas5)

* vtest=1, itest=0:
let B=i(Vimeasp4)
let D=v(vmeas4)

let Ttian=(A*D-B*C-A)/(2*(B*C-A*D)+A-D+1)

let Ttian_dB = vdb(Ttian)
let Ttian_arg = 180/PI*cphase(Ttian)

* DC loop gain
meas ac Ttianbdc_dB find Ttian_dB when frequency = fdc
print Ttianbdc_dB

* Phase margin
meas ac fug find frequency when Ttian_dB=0
meas ac pm find Ttian_arg when frequency=fug
let pm = 180-abs(pm)
* let pm = abs(pm)
print pm

* Plotting
plot Ttian_dB Ttian_arg title 'Bode Plot (Tian)' ylabel 'Magnitude (dB), Phase (Deg)'

let Ttian_re = real(Ttian)
let Ttian_im = imag(Ttian)
plot Ttian_im vs Ttian_re retraceplot title 'Nyquist Plot (Tian)' ylabel 'Imaginary Part' xlabel 'Real
+ Part'
* ===================================================

* Rosenstark vs. Middlebrook vs. Tian
plot L_dB Tmb_dB Ttian_dB title 'Rosenstark vs. Middlebrook vs. Tian' ylabel 'Magnitude (dB)'
plot L_arg Tmb_arg Ttian_arg title 'Rosenstark vs. Middlebrook vs. Tian' ylabel 'Phase (Deg)'

* plot L_im vs L_re Tmb_im vs Tmb_re Ttian_im vs Ttian_re retraceplot title 'Rosenstark vs. Middlebrook
*+ vs. Tian' ylabel 'Imaginary Part' xlabel 'Real Part'
plot Tmb_im vs Tmb_re Ttian_im vs Ttian_re retraceplot title 'Middlebrook vs. Tian' ylabel 'Imaginary
+ Part' xlabel 'Real Part'
* ===================================================

* Write Data
unset appendwrite
set wr_vecnames
set wr_singlescale
wrdata ../plot_simulations/data/iqmod_mfb_lpf_tb_loopgain_all.txt v(L_dB) v(L_arg) v(Tmb_dB) v(Tmb_arg) v(Ttian_dB) v(Ttian_arg)
* ===================================================

*quit
.endc



.lib cornerMOSlv.lib mos_tt
.lib cornerMOShv.lib mos_tt
.lib cornerHBT.lib hbt_typ
.lib cornerRES.lib res_typ
.lib cornerCAP.lib cap_typ
.lib cornerDIO.lib dio_tt


.include [file rootname [file tail [xschem get schname]]].save

**** end user architecture code
**.ends
.GLOBAL GND
.GLOBAL VDD
.end
