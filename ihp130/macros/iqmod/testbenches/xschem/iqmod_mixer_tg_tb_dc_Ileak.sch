** sch_path: ihp130/macros/iqmod/testbenches/xschem/iqmod_mixer_tg_tb_dc_Ileak.sch
**.subckt iqmod_mixer_tg_tb_dc_Ileak
VDD VDD GND {VDD}
vin vin_tg GND {Vcm}
vout_w_dummy vout_tg_w_dummy_off GND {Vcm}
x3 VDD VDD GND GND vin_tg vout_tg_w_dummy_off iqmod_mixer_tg_pex
**** begin user architecture code


.include ../../../netlist/pex/iqmod_mixer_tg_pex.spice
.param VDD=1.5
.csparam VDD=VDD
.param Vcm=VDD/2
.csparam Vcm=Vcm
.temp 27
.param Cload=10p
.options savecurrents klu method=gear reltol=1e-3 abstol=1e-15 gmin=1e-15
.control

save all

* Operating Point Analysis
op
remzerovec
write @schname\.raw
set appendwrite

* DC Sweep Analysis LV with Dummy
dc vin 0 $&VDD 10m vout_w_dummy 0 $&VDD $&Vcm
write @schname\.raw
set appendwrite

* Off-Leakage Current
let Ileak_w_dummy = i(vout_w_dummy)
plot Ileak_w_dummy

* Writing Data
set wr_singlescale
set wr_vecnames
let Ileak_w_dummy = dc1.Ileak_w_dummy
unset appendwrite
wrdata ../plot_simulations/data/iqmod_mixer_tg_tb_dc_Ileak.txt v(Ileak_w_dummy)

*quit
.endc


.lib cornerMOSlv.lib mos_tt
.lib cornerMOShv.lib mos_tt
.lib cornerHBT.lib hbt_typ
.lib cornerRES.lib res_typ
.lib cornerCAP.lib cap_typ
.lib cornerDIO.lib dio_tt


.include [file rootname [file tail [xschem get schname]]].save

**** end user architecture code
**.ends

* expanding   symbol:  iqmod_mixer_tg.sym # of pins=8
** sym_path: ihp130/macros/iqmod/xschem/iqmod_mixer_tg.sym
** sch_path: ihp130/macros/iqmod/xschem/iqmod_mixer_tg.sch
.subckt iqmod_mixer_tg nwell psub VDD di_tg_ctrl VSS v_b v_a di_tg_ctrl_n
*.iopin v_a
*.iopin v_b
*.ipin di_tg_ctrl
*.ipin di_tg_ctrl_n
*.iopin VDD
*.iopin VSS
*.iopin nwell
*.iopin psub
XM1 v_a di_tg_ctrl v_b psub sg13_lv_nmos w=108.0u l=0.13u ng=36 m=1 mm_ok=1
XM2 v_a di_tg_ctrl_n v_b nwell sg13_lv_pmos w=324.0u l=0.13u ng=36 m=1 mm_ok=1
XMdummy2 v_b di_tg_ctrl v_b nwell sg13_lv_pmos w=162.0u l=0.13u ng=18 m=1 mm_ok=1
XMdummy1 v_b di_tg_ctrl_n v_b psub sg13_lv_nmos w=54.0u l=0.13u ng=18 m=1 mm_ok=1
XR1 VDD nwell ntap1 R=2.829 w=29.86e-6 l=11.02e-6 rw=0.3e-6
XR2 VSS psub ptap1 R=3.29 w=29.86e-6 l=5.38e-6 rw=0.3e-6
.ends

.GLOBAL GND
.GLOBAL VDD
.end
