** sch_path: ihp130/macros/riscv/testbenches/xschem/riscv_top_tb_tran.sch
**.subckt riscv_top_tb_tran
VDD VDD GND {VDD}
vclk clock GND pulse(0 {VDD} 0 10p 10p {0.5/fclk} {1/fclk})
vrst reset_n GND pulse({VDD} 0 {2/fclk} 10p 10p {2/fclk} 1 1)
x1 VDD GND I_ae Q_ae clock GND ds_I_n ds_I_oe GND ds_I_p GND ds_Q_n ds_Q_oe GND ds_Q_p GND lo_I
+ lo_I_oe GND lo_Ix GND lo_Q lo_Q_oe GND lo_Qx reset_n GND i2c_scl spi_sclk GND i2c_sda i2c_sda_oe spi_si GND
+ spi_sram_ce uart_tx GND GND GND GND gpio_0 gpio_1 gpio_2 gpio_3 analog_en riscv_top
**** begin user architecture code


* Gate-Level Analog Mixed Signal Simulation (.xspice)
.include ../../../netlist/xspice/riscv_top.xspice
.param VDD=1.5
.temp 27
.param fclk=56e6
.csparam fclk=fclk
.options savecurrents klu method=gear reltol=1e-4 abstol=1e-15 gmin=1e-15
.control

set num_threads=16

save all

* User Constants
let tstop = 25u
let tstep = 1/fclk

* Operating Point Analysis
op
remzerovec
write @schname\.raw
set appendwrite

* Transient Analysis
tran $&tstep $&tstop
write @schname\.raw

*quit
.endc



.lib cornerMOSlv.lib mos_tt
.lib cornerMOShv.lib mos_tt
.lib cornerHBT.lib hbt_typ
.lib cornerRES.lib res_typ
.lib cornerCAP.lib cap_typ
.lib cornerDIO.lib dio_tt


.include [file rootname [file tail [xschem get schname]]].save

**** end user architecture code
**.ends
.GLOBAL GND
.GLOBAL VDD
.end
