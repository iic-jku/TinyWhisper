** sch_path: ihp130/schematic/tinywhisper_top.sch
**.subckt tinywhisper_top IOVDD VSS VDD VSS VDD VSS VDD VSS VSS clk_PAD rst_n_PAD input_PAD[5]
*+ input_PAD[4] output_PAD[4] output_PAD[8] output_PAD[7] output_PAD[6] output_PAD[5] input_PAD[3] input_PAD[2]
*+ input_PAD[1] input_PAD[0] output_PAD[3] output_PAD[2] output_PAD[1] output_PAD[0] analog_PAD[5] analog_PAD[4]
*+ analog_PAD[2] analog_PAD[3] analog_PAD[7] analog_PAD[6] analog_PAD[0] analog_PAD[1] VDD VSS VSS IOVDD VSS VDD VSS
*+ IOVDD VSS VDD VSS bidir_PAD[8] VDD VSS bidir_PAD[4] bidir_PAD[5] bidir_PAD[7] bidir_PAD[6] bidir_PAD[0]
*+ bidir_PAD[1] bidir_PAD[3] bidir_PAD[2]
*.iopin IOVDD
*.iopin VSS
*.iopin VDD
*.iopin VSS
*.iopin VDD
*.iopin VSS
*.iopin VDD
*.iopin VSS
*.iopin VSS
*.ipin clk_PAD
*.ipin rst_n_PAD
*.ipin input_PAD[5]
*.ipin input_PAD[4]
*.opin output_PAD[4]
*.opin output_PAD[8]
*.opin output_PAD[7]
*.opin output_PAD[6]
*.opin output_PAD[5]
*.ipin input_PAD[3]
*.ipin input_PAD[2]
*.ipin input_PAD[1]
*.ipin input_PAD[0]
*.opin output_PAD[3]
*.opin output_PAD[2]
*.opin output_PAD[1]
*.opin output_PAD[0]
*.iopin analog_PAD[5]
*.iopin analog_PAD[4]
*.iopin analog_PAD[2]
*.iopin analog_PAD[3]
*.iopin analog_PAD[7]
*.iopin analog_PAD[6]
*.iopin analog_PAD[0]
*.iopin analog_PAD[1]
*.iopin VDD
*.iopin VSS
*.iopin VSS
*.iopin IOVDD
*.iopin VSS
*.iopin VDD
*.iopin VSS
*.iopin IOVDD
*.iopin VSS
*.iopin VDD
*.iopin VSS
*.iopin bidir_PAD[8]
*.iopin VDD
*.iopin VSS
*.iopin bidir_PAD[4]
*.iopin bidir_PAD[5]
*.iopin bidir_PAD[7]
*.iopin bidir_PAD[6]
*.iopin bidir_PAD[0]
*.iopin bidir_PAD[1]
*.iopin bidir_PAD[3]
*.iopin bidir_PAD[2]
x1 VSS VDD VSS IOVDD net10 clk_PAD sg13g2_IOPadIn
x2 VSS VDD VSS IOVDD net11 rst_n_PAD sg13g2_IOPadIn
x3 VSS VDD VSS IOVDD net53 input_PAD[5] sg13g2_IOPadIn
x4 VSS VDD VSS IOVDD net16 output_PAD[8] sg13g2_IOPadOut30mA
x5 VSS VDD VSS IOVDD net17 output_PAD[7] sg13g2_IOPadOut30mA
x6 VSS VDD VSS IOVDD net18 output_PAD[6] sg13g2_IOPadOut30mA
x7 VSS VDD VSS IOVDD sg13g2_IOPadIOVdd
x8 VSS VDD VSS IOVDD sg13g2_IOPadIOVss
x9 VSS VDD VSS IOVDD sg13g2_IOPadVdd
x10 VSS VDD VSS IOVDD sg13g2_IOPadVss
x12 VSS VDD VSS IOVDD net14 output_PAD[5] sg13g2_IOPadOut30mA
x13 VSS VDD VSS IOVDD net12 input_PAD[4] sg13g2_IOPadIn
x14 VSS VDD VSS IOVDD net13 output_PAD[4] sg13g2_IOPadOut30mA
x15 VSS VDD VSS IOVDD sg13g2_IOPadIOVdd
x16 VSS VDD VSS IOVDD sg13g2_IOPadIOVss
x17 VSS VDD VSS IOVDD sg13g2_IOPadVdd
x18 VSS VDD VSS IOVDD sg13g2_IOPadVss
x19 VSS VDD VSS IOVDD net5 output_PAD[0] sg13g2_IOPadOut30mA
x20 VSS VDD VSS IOVDD net6 output_PAD[1] sg13g2_IOPadOut30mA
x21 VSS VDD VSS IOVDD net7 output_PAD[2] sg13g2_IOPadOut30mA
x22 VSS VDD VSS IOVDD net8 output_PAD[3] sg13g2_IOPadOut30mA
x23 VSS VDD VSS IOVDD sg13g2_IOPadVdd
x24 VSS VDD VSS IOVDD sg13g2_IOPadVss
x29 VSS VDD VSS IOVDD net52 net27 analog_PAD[0] sg13g2_IOPadAnalog
x30 VSS VDD VSS IOVDD net51 net26 analog_PAD[1] sg13g2_IOPadAnalog
x31 VSS VDD VSS IOVDD sg13g2_IOPadVss
x32 VSS VDD VSS IOVDD sg13g2_IOPadVdd
x33 VSS VDD VSS IOVDD sg13g2_IOPadVss
x35 VSS VDD VSS IOVDD net58 net49 analog_PAD[3] sg13g2_IOPadAnalog
x36 VSS VDD VSS IOVDD net19 net48 analog_PAD[4] sg13g2_IOPadAnalog
x37 VSS VDD VSS IOVDD net56 net47 analog_PAD[5] sg13g2_IOPadAnalog
x38 VSS VDD VSS IOVDD sg13g2_IOPadVss
x39 VSS VDD VSS IOVDD sg13g2_IOPadVdd
x40 VSS VDD VSS IOVDD sg13g2_IOPadVss
x48 VSS VDD VSS IOVDD sg13g2_IOPadVdd
x47 VSS VDD VSS IOVDD sg13g2_IOPadVss
x41 VSS VDD VSS IOVDD net46 net29 analog_PAD[6] sg13g2_IOPadAnalog
x42 VSS VDD VSS IOVDD net45 net28 analog_PAD[7] sg13g2_IOPadAnalog
x49 VSS VDD VSS IOVDD net4 input_PAD[3] sg13g2_IOPadIn
x50 VSS VDD VSS IOVDD net3 input_PAD[2] sg13g2_IOPadIn
x51 VSS VDD VSS IOVDD net2 input_PAD[1] sg13g2_IOPadIn
x52 VSS VDD VSS IOVDD net1 input_PAD[0] sg13g2_IOPadIn
x56 VSS VDD VSS IOVDD sg13g2_IOPadIOVdd
x55 VSS VDD VSS IOVDD sg13g2_IOPadIOVss
x54 VSS VDD VSS IOVDD sg13g2_IOPadVdd
x53 VSS VDD VSS IOVDD sg13g2_IOPadVss
x11 VSS VDD VSS IOVDD net44 net9 net15 bidir_PAD[8] sg13g2_IOPadInOut30mA
x25 VSS VDD VSS IOVDD net37 net39 net36 bidir_PAD[4] sg13g2_IOPadInOut30mA
x26 VSS VDD VSS IOVDD net38 net40 net36 bidir_PAD[5] sg13g2_IOPadInOut30mA
x27 VSS VDD VSS IOVDD net41 net43 net25 bidir_PAD[6] sg13g2_IOPadInOut30mA
x28 VSS VDD VSS IOVDD net42 net24 net25 bidir_PAD[7] sg13g2_IOPadInOut30mA
x43 VSS VDD VSS IOVDD net23 net34 net33 bidir_PAD[3] sg13g2_IOPadInOut30mA
x44 VSS VDD VSS IOVDD net22 net35 net33 bidir_PAD[2] sg13g2_IOPadInOut30mA
x45 VSS VDD VSS IOVDD net21 net32 net31 bidir_PAD[1] sg13g2_IOPadInOut30mA
x46 VSS VDD VSS IOVDD net20 net30 net31 bidir_PAD[0] sg13g2_IOPadInOut30mA
x34 VSS VDD VSS IOVDD net57 net50 analog_PAD[2] sg13g2_IOPadAnalog
* noconn #net45
* noconn #net46
* noconn #net47
* noconn #net48
* noconn #net49
* noconn #net50
* noconn #net51
* noconn #net52
xcpu VDD VSS net54 net55 net10 net21 net32 net31 net20 net30 net38 net40 net36 net37 net39 net22
+ net35 net33 net23 net34 net41 net43 net25 net42 net24 net11 net12 net14 net17 net44 net9 net15 net16
+ net53 net18 net13 net1 net2 net3 net4 net5 net6 net7 net8 net59 riscv_top
xiqmod net30 net54 net32 net40 net55 net39 net27 net26 net35 net34 net56 net28 net29 net43 net24
+ net19 net57 net58 VDD VSS net59 iqmod_top
XR1 VSS [expr {$lvs_ignore ? {VSS} : {sub!}}] ptap1 R=262.8 w=0.78e-6 l=0.78e-6
**.ends
.end
