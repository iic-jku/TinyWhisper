** sch_path: sky130/macros/iqmod/verification/cace/templates/wspr_tx_iqmod_mfb_lpf_tb_ac.sch
**.subckt wspr_tx_iqmod_mfb_lpf_tb_ac
VDD VDD GND CACE{vdd}
C1 voutn1 GND CACE{cload} m=1
C2 voutp1 GND CACE{cload} m=1
V1 filter_ota_en GND CACE{vdd}
E1 vout1 GND voutp1 voutn1 1
VSS VSS GND 0
C3 voutn2 GND CACE{cload} m=1
C4 voutp2 GND CACE{cload} m=1
E8 vout2 GND voutp2 net1 0.5
E10 net1 GND voutn2 GND -1
C5 voutn3 GND CACE{cload} m=1
C6 voutp3 GND CACE{cload} m=1
E9 vout3 GND voutp3 voutn3 1
Vcm1 Vcm1 GND CACE{vcm}
Vcm2 Vcm2 GND CACE{vcm}
Vcm3 Vcm3 GND CACE{vcm}
VDD_PSRR net2 GND CACE{vdd}
VDD_NOISE vdd_noise net2 dc 0 ac 1
x1 filter_ota_en voutp1 vinp1 voutn1 vinn1 VDD GND wspr_tx_iqmod_mfb_lpf
x2 filter_ota_en voutp2 vinp2 voutn2 vinn2 VDD GND wspr_tx_iqmod_mfb_lpf
x3 filter_ota_en voutp3 Vcm3 voutn3 Vcm3 vdd_noise GND wspr_tx_iqmod_mfb_lpf
vin vin GND dc 0 ac 1
x6 vinp1 vin Vcm1 GND vinn1 single2dm
x7 vinp2 vin Vcm2 GND vinn2 single2cm
**** begin user architecture code


.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/combined/sky130.lib.spice CACE{corner}
.include CACE{DUT_path}
*.include ../../spice/wspr_tx_iqmod_mfb_lpf.spice
.temp CACE{temp}
*.param W_long=18.0
*.param W_short=12.0
*.param a=3
*.param L=1.0
*.param NF_long=6
*.param NF_short=4
.options savecurrents klu method=gear reltol=1e-4 abstol=1e-15 gmin=1e-15 SEED=CACE[CACE{seed=12345}
+ + CACE{iterations=0}]
* Flag unsafe operating conditions (exceeds models' specified limits)
.option warn=1
.control

* optran 0 0 0 1u 1m 0

* save v(vin) v(vout1) v(vout2) v(vout3) v(vdd_noise) v(vin_dm) v(vin_cm)
save all

set num_threads=1

* AC Analysis
ac dec 101 1 1G

* Closed-loop gain
let Acl=v(vout1)/v(vin)
let Acl_dB = vdb(Acl)

* Common-mode gain
let Acm=v(vout2)/v(vin)
let Acm_dB = vdb(Acm)

* Common Mode Rejection Ratio (CMRR)
* let CMRR = v(vout1)/v(vout2)
let CMRR = v(Acl)/v(Acm)
let CMRR_dB = vdb(CMRR)
* let CMRR_dB = Acl_dB - Acm_dB

* PSRR
let PSRR = v(vdd_noise)/v(vout3)
let PSRR_dB = vdb(PSRR)

* Measurements
* 10Hz closed-loop gain
meas ac Adc_cl_dB find Acl_dB when frequency = 10

* Upper 3dB cut-off frequency
let Amag_fc = Adc_cl_dB-3
meas ac fcu find frequency when Acl_dB = Amag_fc FALL=1

* 10Hz CMRR
meas ac CMRR_dc_dB find CMRR_dB when frequency = 10

* 10Hz PSRR
meas ac PSRR_dc_dB find PSRR_dB when frequency = 10

echo $&Adc_cl_dB $&fcu $&CMRR_dc_dB $&PSRR_dc_dB > CACE{simpath}/CACE{filename}_CACE{N}.data

.endc


**** end user architecture code
**.ends
.GLOBAL GND
.GLOBAL VDD
.end
